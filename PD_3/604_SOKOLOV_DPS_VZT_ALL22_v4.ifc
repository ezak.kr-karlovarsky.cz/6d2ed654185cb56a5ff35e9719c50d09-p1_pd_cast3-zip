Properties of the parts of a building model (IFC2X3), part 3 of 51

# IfcBuildingElementProxy (417)
Name | In | Allright_Stavebni_dil_ID | Jednotka | Název_objektu | V6 (m) = V7 (m) = V8 (m) = V9 | Označení | Kód prvku | Podlaží | Délka (m) | Třída reakce na oheň
ABL Regler RN | Půdorys 1.NP | 6782Obj0798484287 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.03.30033 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.01a; Jmenovitá velikost vstupu: DN125; Průtok: 150 m3/h; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/10; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
Absperrklappe elektrisch NAK-E | Půdorys 1.NP | 6782Obj0798490928 | Stk | Konstrukce v aktuální hladině | 0 | Absperrklappe elektrisch NAK-E | KA.03.30034 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.01b; Jmenovitá velikost vstupu: DN200; Průtok: 250 m3/h; K_GEWERK: 1; K_BLOCKNAME: Absperrklappe elektrisch NAK-E; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|200.00|200.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.1; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN200; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/17; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN200; Provozní tlak: -; Tlaková třída: -; Typ ovladání: manuální; K_EBT_BOX_WC: 51447.753|-6283.877|3360.000|51247.753|-6593.877|3160.000|0.000|0.000|0.000|1.000
Absperrklappe elektrisch NAK-E | Půdorys 1.NP | 6782Obj0798490937 | Stk | Konstrukce v aktuální hladině | 0 | Absperrklappe elektrisch NAK-E | KA.03.30035 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.01b; Jmenovitá velikost vstupu: DN200; Průtok: 250 m3/h; K_GEWERK: 1; K_BLOCKNAME: Absperrklappe elektrisch NAK-E; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|200.00|200.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.1; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN200; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/17; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN200; Provozní tlak: -; Tlaková třída: -; Typ ovladání: manuální; K_EBT_BOX_WC: 49039.753|-6308.877|3360.000|48839.753|-6618.877|3160.000|0.000|0.000|0.000|1.000
Absperrklappe elektrisch NAK-E | Půdorys 1.NP | 6782Obj0798490946 | Stk | Konstrukce v aktuální hladině | 0 | Absperrklappe elektrisch NAK-E | KA.03.30036 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.01b; Jmenovitá velikost vstupu: DN200; Průtok: 250 m3/h; K_GEWERK: 1; K_BLOCKNAME: Absperrklappe elektrisch NAK-E; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|200.00|200.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.1; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN200; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/17; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN200; Provozní tlak: -; Tlaková třída: -; Typ ovladání: manuální; K_EBT_BOX_WC: 46440.753|-6958.277|3360.000|46130.753|-7158.277|3160.000|0.000|0.000|0.000|1.000
Absperrklappe elektrisch NAK-E | Půdorys 1.NP | 6782Obj0798491580 | Stk | Konstrukce v aktuální hladině | 0 | Absperrklappe elektrisch NAK-E | KA.03.30037 | Nadzení podlaží 1.NP | 0.3 | - | NEMSOK - Číslo místnosti: 1.01; Jmenovitá velikost vstupu: DN200; Průtok: 275 m3/h; K_GEWERK: 1; K_BLOCKNAME: Absperrklappe elektrisch NAK-E; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|200.00|200.00|300.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 300; L_BES_DIM: DN200; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/19; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN200; Provozní tlak: -; Tlaková třída: -; Typ ovladání: manuální
Absperrklappe elektrisch NAK-E | Půdorys 1.NP | 6782Obj0798490990 | Stk | Konstrukce v aktuální hladině | 0 | Absperrklappe elektrisch NAK-E | KA.03.30038 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.01; Jmenovitá velikost vstupu: DN200; Průtok: 275 m3/h; K_GEWERK: 1; K_BLOCKNAME: Absperrklappe elektrisch NAK-E; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|200.00|200.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.1; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN200; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/17; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN200; Provozní tlak: -; Tlaková třída: -; Typ ovladání: manuální; K_EBT_BOX_WC: 42550.014|-7028.300|3200.000|42350.014|-7338.300|3000.000|0.000|0.000|0.000|1.000
ZG Klappe | Půdorys 1.NP | 6782Obj0798485853 | Stk | Konstrukce v aktuální hladině | 0 | ZG Klappe | KA.03.30039 | Nadzení podlaží 1.NP | 0.3 | - | NEMSOK - Číslo místnosti: 1.04; Jmenovitá velikost vstupu: DN100; Průtok: 50 m3/h; K_GEWERK: 1; K_BLOCKNAME: ZG Klappe; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|100.00|100.00|300.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\zentralgeräte\zg klappen\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 300; L_BES_DIM: DN100; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/11; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN100; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
Absperrklappe elektrisch NAK-E | Půdorys 1.NP | 6782Obj0798484349 | Stk | Konstrukce v aktuální hladině | 0 | Absperrklappe elektrisch NAK-E | KA.03.30040 | Nadzení podlaží 1.NP | 0.28 | - | NEMSOK - Číslo místnosti: 1.04; Jmenovitá velikost vstupu: DN100; Průtok: 50 m3/h; K_GEWERK: 1; K_BLOCKNAME: Absperrklappe elektrisch NAK-E; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|100.00|100.00|280.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 280; L_BES_DIM: DN100; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/10; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN100; Provozní tlak: -; Tlaková třída: -; Typ ovladání: manuální
ABL Regler RN | Půdorys 1.NP | 6782Obj0798484323 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.03.30041 | Nadzení podlaží 1.NP | 0.29 | - | NEMSOK - Číslo místnosti: 1.04; Jmenovitá velikost vstupu: DN125; Průtok: 100 m3/h; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|290.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 290; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/10; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
ABL Regler RN | Půdorys 1.NP | 6782Obj0798489830 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.03.30043 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.05; Jmenovitá velikost vstupu: DN125; Průtok: 100 m3/h; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/13; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
ABL Regler RN | Půdorys 1.NP | 6782Obj0798484204 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.03.30044 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.05; Jmenovitá velikost vstupu: DN125; Průtok: 100 m3/h; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/10; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
ABL Regler RN | Půdorys 1.NP | 6782Obj0798491029 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.03.30046 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.06; Jmenovitá velikost vstupu: DN160; Průtok: 250 m3/h; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|160.00|160.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN160; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/17; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN160; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
ABL Regler RN | Půdorys 1.NP | 6782Obj0798487890 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.03.30047 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.06; Jmenovitá velikost vstupu: DN160; Průtok: 250 m3/h; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|160.00|160.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN160; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/12; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN160; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
Absperrklappe elektrisch NAK-E | Půdorys 1.NP | 6782Obj0798484370 | Stk | Konstrukce v aktuální hladině | 0 | Absperrklappe elektrisch NAK-E | KA.03.30048 | Nadzení podlaží 1.NP | 0.28 | - | NEMSOK - Číslo místnosti: 1.07; Jmenovitá velikost vstupu: DN100; Průtok: 50 m3/h; K_GEWERK: 1; K_BLOCKNAME: Absperrklappe elektrisch NAK-E; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|100.00|100.00|280.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 280; L_BES_DIM: DN100; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/10; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN100; Provozní tlak: -; Tlaková třída: -; Typ ovladání: manuální
ZG Klappe | Půdorys 1.NP | 6782Obj0798485827 | Stk | Konstrukce v aktuální hladině | 0 | ZG Klappe | KA.03.30049 | Nadzení podlaží 1.NP | 0.3 | - | NEMSOK - Číslo místnosti: 1.32; Jmenovitá velikost vstupu: DN125; Průtok: 100 m3/h; K_GEWERK: 1; K_BLOCKNAME: ZG Klappe; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|300.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\zentralgeräte\zg klappen\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 300; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/11; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
Absperrklappe elektrisch NAK-E | Půdorys 1.NP | 6782Obj0798484386 | Stk | Konstrukce v aktuální hladině | 0 | Absperrklappe elektrisch NAK-E | KA.03.30050 | Nadzení podlaží 1.NP | 0.28 | - | NEMSOK - Číslo místnosti: 1.07; Jmenovitá velikost vstupu: DN100; Průtok: 50 m3/h; K_GEWERK: 1; K_BLOCKNAME: Absperrklappe elektrisch NAK-E; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|100.00|100.00|280.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 280; L_BES_DIM: DN100; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/10; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN100; Provozní tlak: -; Tlaková třída: -; Typ ovladání: manuální
ABL Regler RN | Půdorys 1.NP | 6782Obj0798484498 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.03.30051 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.30; Jmenovitá velikost vstupu: DN160; Průtok: 250 m3/h; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|160.00|160.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.1; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN160; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/10; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN160; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon; K_EBT_BOX_WC: 42229.989|18558.816|2825.106|42069.939|18248.772|2665.071|0.000|0.000|0.000|1.000
ABL Regler RN | Půdorys 1.NP | 6782Obj0798487156 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.03.30052 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.52; Jmenovitá velikost vstupu: DN160; Průtok: 150 m3/h; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|160.00|160.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN160; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/12; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN160; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
ABL Regler RN | Půdorys 1.NP | 6782Obj0798484518 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.03.30053 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.27; Jmenovitá velikost vstupu: DN200; Průtok: 370 m3/h; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|200.00|200.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN200; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/10; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN200; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
ABL Regler RN | Půdorys 1.NP | 6782Obj0798487178 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.03.30054 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.30; Jmenovitá velikost vstupu: DN160; Průtok: 240 m3/h; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|160.00|160.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN160; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/12; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN160; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
ABL Regler RN | Půdorys 1.NP | 6782Obj0798490265 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.03.30055 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.30; Jmenovitá velikost vstupu: DN200; Průtok: 300 m3/h; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|200.00|200.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN200; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/15; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN200; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
ABL Regler RN | Půdorys 1.NP | 6782Obj0798484450 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.03.30056 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.20; Jmenovitá velikost vstupu: DN200; Průtok: 300 m3/h; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|200.00|200.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN200; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/10; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN200; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
ABL Regler RN | Půdorys 1.NP | 6782Obj0798484470 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.03.30057 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.20; Jmenovitá velikost vstupu: DN200; Průtok: 310 m3/h; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|200.00|200.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN200; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/10; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN200; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
ABL Regler RN | Půdorys 1.NP | 6782Obj0798484460 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.03.30058 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.20; Jmenovitá velikost vstupu: DN160; Průtok: 240 m3/h; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|160.00|160.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN160; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/10; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN160; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
Absperrklappe elektrisch NAK-E | Půdorys 1.NP | 6782Obj0798483705 | Stk | Konstrukce v aktuální hladině | 0 | Absperrklappe elektrisch NAK-E | KA.03.30059 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.28; Jmenovitá velikost vstupu: DN160; Průtok: 150 m3/h; K_GEWERK: 1; K_BLOCKNAME: Absperrklappe elektrisch NAK-E; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|160.00|160.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN160; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/09; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN160; Provozní tlak: -; Tlaková třída: -; Typ ovladání: manuální
Absperrklappe elektrisch NAK-E | Půdorys 1.NP | 6782Obj0798483676 | Stk | Konstrukce v aktuální hladině | 0 | Absperrklappe elektrisch NAK-E | KA.03.30060 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.28; Jmenovitá velikost vstupu: DN100; Průtok: 30 m3/h; K_GEWERK: 1; K_BLOCKNAME: Absperrklappe elektrisch NAK-E; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|100.00|100.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN100; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/09; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN100; Provozní tlak: -; Tlaková třída: -; Typ ovladání: manuální
Absperrklappe elektrisch NAK-E | Půdorys 1.NP | 6782Obj0798483689 | Stk | Konstrukce v aktuální hladině | 0 | Absperrklappe elektrisch NAK-E | KA.03.30061 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.28a; Jmenovitá velikost vstupu: DN100; Průtok: 50 m3/h; K_GEWERK: 1; K_BLOCKNAME: Absperrklappe elektrisch NAK-E; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|100.00|100.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN100; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/09; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN100; Provozní tlak: -; Tlaková třída: -; Typ ovladání: manuální
ABL Regler RN | Půdorys 1.NP | 6782Obj0798484528 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.03.30062 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.20; Jmenovitá velikost vstupu: DN125; Průtok: 100 m3/h; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/10; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
Absperrklappe elektrisch NAK-E | Půdorys 1.NP | 6782Obj0798483651 | Stk | Konstrukce v aktuální hladině | 0 | Absperrklappe elektrisch NAK-E | KA.03.30063 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.21; Jmenovitá velikost vstupu: DN100; Průtok: 80 m3/h; K_GEWERK: 1; K_BLOCKNAME: Absperrklappe elektrisch NAK-E; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|100.00|100.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN100; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/09; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN100; Provozní tlak: -; Tlaková třída: -; Typ ovladání: manuální
Absperrklappe elektrisch NAK-E | Půdorys 1.NP | 6782Obj0798483650 | Stk | Konstrukce v aktuální hladině | 0 | Absperrklappe elektrisch NAK-E | KA.03.30064 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.22; Jmenovitá velikost vstupu: DN100; Průtok: 80 m3/h; K_GEWERK: 1; K_BLOCKNAME: Absperrklappe elektrisch NAK-E; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|100.00|100.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN100; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/09; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN100; Provozní tlak: -; Tlaková třída: -; Typ ovladání: manuální
Absperrklappe elektrisch NAK-E | Půdorys 1.NP | 6782Obj0798483643 | Stk | Konstrukce v aktuální hladině | 0 | Absperrklappe elektrisch NAK-E | KA.03.30065 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.23; Jmenovitá velikost vstupu: DN100; Průtok: 50 m3/h; K_GEWERK: 1; K_BLOCKNAME: Absperrklappe elektrisch NAK-E; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|100.00|100.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN100; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/09; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN100; Provozní tlak: -; Tlaková třída: -; Typ ovladání: manuální
Regulační klapka | Půdorys 1.NP | 6782Obj0798483991 | Stk | Konstrukce v aktuální hladině | 0 | Regulační klapka | KA.03.30066 | Nadzení podlaží 1.NP | 0.28 | - | NEMSOK - Číslo místnosti: 1.17; Jmenovitá velikost vstupu: DN100; Průtok: 50 m3/h; K_GEWERK: 1; K_BLOCKNAME: Absperrklappe elektrisch NAK-E; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|100.00|100.00|280.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 280; L_BES_DIM: DN100; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/10; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN100; Provozní tlak: -; Tlaková třída: -; Typ ovladání: manuální
 | Půdorys 1.NP | 6782ExE0798482346 | m3 | Rozšířený element |  |  | RE.03.30005 | Nadzemní podlaží 1.NP | 0.5 | B | NEMSOK - Šířka: 0.5 m; Výška: 0.05 m; Číslo mísnosti: K1.07
 | Půdorys 1.NP | 6782ExE0798482344 | m3 | Rozšířený element |  |  | RE.03.30003 | Nadzemní podlaží 1.NP | 0.5 | B | NEMSOK - Šířka: 0.5 m; Výška: 0.05 m; Číslo mísnosti: K1.07
 | Půdorys 1.NP | 6782ExE0798482342 | m3 | Rozšířený element |  |  | RE.03.30001 | Nadzemní podlaží 1.NP | 0.5 | B | NEMSOK - Šířka: 0.5 m; Výška: 0.05 m; Číslo mísnosti: K1.07
 | Půdorys 1.NP | 6782ExE0798488760 | m3 | Rozšířený element |  |  | RE.03.30007 | Nadzemní podlaží 1.NP | 0.5 | B | NEMSOK - Šířka: 0.5 m; Výška: 0.05 m; Číslo mísnosti: K1.09
 | Půdorys 1.NP | 6782ExE0798482345 | m3 | Rozšířený element |  |  | RE.03.30004 | Nadzemní podlaží 1.NP | 0.5 | B | NEMSOK - Šířka: 0.5 m; Výška: 0.05 m; Číslo mísnosti: K1.08
 | Půdorys 1.NP | 6782ExE0798482887 | m3 | Rozšířený element |  |  | RE.03.30006 | Nadzemní podlaží 1.NP | 0.5 | B | NEMSOK - Šířka: 0.5 m; Výška: 0.05 m; Číslo mísnosti: K1.07
 | Půdorys 1.NP | 6782ExE0798482343 | m3 | Rozšířený element |  |  | RE.03.30002 | Nadzemní podlaží 1.NP | 0.5 | B | NEMSOK - Šířka: 0.5 m; Výška: 0.05 m; Číslo mísnosti: K1.07
Lamellenhaube | Půdorys 2.NP | 6792Obj0000000298 | Stk | Objekt | 0 | Lamellenhaube | KA.04.30001 | Nadzení podlaží 2.NP | 0.32 | B | NEMSOK - Číslo místnosti: EXTERIÉR; Jmenovitá velikost vstupu: DN250; Průtok: 1,002 m3/s; Dolní_hrana: 0 m; Horní_hrana: 0 m; Plocha: 1; K_GEWERK: 1; K_BLOCKNAME: Lamellenhaube; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|250.00|250.00|320.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_DWGNAME: ${PROD}l\einbauteile rund\deflektorhauben\; K_MATERIAL: POZINK|0.00; K_PROFIL: ||||; L_BES_LAENGE: 320; L_BES_DIM: DN250; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/13; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: POZINK; Jmenovitá velikost výstupu: DN250; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
Lamellenhaube | Půdorys 2.NP | 6792Obj0000000307 | Stk | Objekt | 0 | Lamellenhaube | KA.04.30002 | Nadzení podlaží 2.NP | 0.32 | B | NEMSOK - Číslo místnosti: EXTERIÉR; Jmenovitá velikost vstupu: DN200; Průtok: 1,002 m3/s; Dolní_hrana: 0 m; Horní_hrana: 0 m; Plocha: 1; K_GEWERK: 1; K_BLOCKNAME: Lamellenhaube; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|200.00|200.00|320.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.1; K_DWGNAME: ${PROD}l\einbauteile rund\deflektorhauben\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; L_BES_LAENGE: 320; L_BES_DIM: DN200; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/13; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN200; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální; K_EBT_BOX_WC: 28730.952|-7269.048|4547.000|28369.048|-7630.952|4350.000|0.000|0.000|0.000|1.000
Dachhaube gelocht | Půdorys střechy | 6882Obj0000000005 | Stk | Objekt | 0 | Dachhaube gelocht | HV.05.30001 | Nadzemní podlaží 3.NP | 0.315 | NEMSOK - Šířka: 0.4 m; Výška: 0.48 m; Průměr: 250 mm; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: Dachhaube gelocht; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|250.00|250.00|315.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_DWGNAME: ${PROD}l\einbauteile rund\deflektorhauben\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Alu kaschiert|100.00; L_BES_LAENGE: 315; L_BES_DIM: DN250; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/10/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ
Dachhaube gelocht | Půdorys střechy | 6882Obj0000000006 | Stk | Objekt | 0 | Dachhaube gelocht | HV.05.30002 | Nadzemní podlaží 3.NP | 0.315 | NEMSOK - Šířka: 0.4 m; Výška: 0.48 m; Průměr: 250 mm; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: Dachhaube gelocht; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|250.00|250.00|315.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_DWGNAME: ${PROD}l\einbauteile rund\deflektorhauben\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Alu kaschiert|100.00; L_BES_LAENGE: 315; L_BES_DIM: DN250; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/10/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ
Dachhaube gelocht | Půdorys střechy | 6882Obj0000000007 | Stk | Objekt | 0 | Dachhaube gelocht | HV.05.30003 | Nadzemní podlaží 3.NP | 0.315 | NEMSOK - Šířka: 0.4 m; Výška: 0.48 m; Průměr: 250 mm; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: Dachhaube gelocht; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|250.00|250.00|315.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_DWGNAME: ${PROD}l\einbauteile rund\deflektorhauben\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Alu kaschiert|100.00; L_BES_LAENGE: 315; L_BES_DIM: DN250; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/10/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ
Dachhaube gelocht | Půdorys střechy | 6882Obj0000000008 | Stk | Objekt | 0 | Dachhaube gelocht | HV.05.30004 | Nadzemní podlaží 3.NP | 0.315 | NEMSOK - Šířka: 0.4 m; Výška: 0.48 m; Průměr: 250 mm; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: Dachhaube gelocht; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|250.00|250.00|315.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_DWGNAME: ${PROD}l\einbauteile rund\deflektorhauben\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Alu kaschiert|100.00; L_BES_LAENGE: 315; L_BES_DIM: DN250; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/10/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ
Dachhaube gelocht | Půdorys střechy | 6882Obj0000000009 | Stk | Konstrukce v aktuální hladině | 0 | Dachhaube gelocht | HV.05.30005 | Nadzemní podlaží 3.NP | 0.315 | NEMSOK - Šířka: 0.4 m; Výška: 0.48 m; Průměr: 250 mm; K_GEWERK: 1; K_BLOCKNAME: Dachhaube gelocht; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|250.00|250.00|315.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_DWGNAME: ${PROD}l\einbauteile rund\deflektorhauben\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Alu kaschiert|100.00; L_BES_LAENGE: 315; L_BES_DIM: DN250; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/10/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ
Dachhaube gelocht | Půdorys střechy | 6882Obj0000000010 | Stk | Objekt | 0 | Dachhaube gelocht | HV.05.30006 | Nadzemní podlaží 3.NP | 0.315 | NEMSOK - Šířka: 0.4 m; Výška: 0.48 m; Průměr: 250 mm; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: Dachhaube gelocht; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|250.00|250.00|315.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_DWGNAME: ${PROD}l\einbauteile rund\deflektorhauben\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Alu kaschiert|100.00; L_BES_LAENGE: 315; L_BES_DIM: DN250; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/10/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ
Dachhaube gelocht | Půdorys střechy | 6882Obj0000000011 | Stk | Objekt | 0 | Dachhaube gelocht | HV.07.30001 | Nadzemní podlaží 5.NP | 0.315 | NEMSOK - Šířka: 0.4 m; Výška: 0.48 m; Průměr: 250 mm; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: Dachhaube gelocht; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|250.00|250.00|315.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_DWGNAME: ${PROD}l\einbauteile rund\deflektorhauben\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Alu kaschiert|100.00; L_BES_LAENGE: 315; L_BES_DIM: DN250; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/10/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ
Dachhaube gelocht | Půdorys střechy | 6882Obj0000000012 | Stk | Objekt | 0 | Dachhaube gelocht | HV.07.30002 | Nadzemní podlaží 5.NP | 0.315 | NEMSOK - Šířka: 0.4 m; Výška: 0.48 m; Průměr: 250 mm; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: Dachhaube gelocht; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|250.00|250.00|315.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_DWGNAME: ${PROD}l\einbauteile rund\deflektorhauben\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Alu kaschiert|100.00; L_BES_LAENGE: 315; L_BES_DIM: DN250; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/10/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ
Dachhaube gelocht | Půdorys střechy | 6882Obj0000000013 | Stk | Objekt | 0 | Dachhaube gelocht | HV.07.30003 | Nadzemní podlaží 5.NP | 0.315 | NEMSOK - Šířka: 0.4 m; Výška: 0.48 m; Průměr: 250 mm; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: Dachhaube gelocht; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|250.00|250.00|315.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_DWGNAME: ${PROD}l\einbauteile rund\deflektorhauben\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Alu kaschiert|100.00; L_BES_LAENGE: 315; L_BES_DIM: DN250; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/10/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ
Dachhaube gelocht | Půdorys střechy | 6882Obj0000000014 | Stk | Objekt | 0 | Dachhaube gelocht | HV.07.30004 | Nadzemní podlaží 5.NP | 0.315 | NEMSOK - Šířka: 0.4 m; Výška: 0.48 m; Průměr: 250 mm; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: Dachhaube gelocht; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|250.00|250.00|315.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_DWGNAME: ${PROD}l\einbauteile rund\deflektorhauben\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Alu kaschiert|100.00; L_BES_LAENGE: 315; L_BES_DIM: DN250; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/10/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ
Dachhaube gelocht | Půdorys střechy | 6882Obj0000000015 | Stk | Objekt | 0 | Dachhaube gelocht | HV.07.30005 | Nadzemní podlaží 5.NP | 0.315 | NEMSOK - Šířka: 0.4 m; Výška: 0.48 m; Průměr: 250 mm; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: Dachhaube gelocht; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|250.00|250.00|315.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_DWGNAME: ${PROD}l\einbauteile rund\deflektorhauben\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Alu kaschiert|100.00; L_BES_LAENGE: 315; L_BES_DIM: DN250; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/10/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ
Dachhaube gelocht | Půdorys střechy | 6882Obj0000000016 | Stk | Objekt | 0 | Dachhaube gelocht | HV.07.30006 | Nadzemní podlaží 5.NP | 0.315 | NEMSOK - Šířka: 0.4 m; Výška: 0.48 m; Průměr: 250 mm; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: Dachhaube gelocht; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|250.00|250.00|315.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_DWGNAME: ${PROD}l\einbauteile rund\deflektorhauben\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Alu kaschiert|100.00; L_BES_LAENGE: 315; L_BES_DIM: DN250; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/10/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ
Dachhaube gelocht | Půdorys střechy | 6882Obj0000000017 | Stk | Objekt | 0 | Dachhaube gelocht | HV.07.30007 | Nadzemní podlaží 5.NP | 0.315 | NEMSOK - Šířka: 0.4 m; Výška: 0.48 m; Průměr: 250 mm; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: Dachhaube gelocht; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|250.00|250.00|315.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_DWGNAME: ${PROD}l\einbauteile rund\deflektorhauben\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Alu kaschiert|100.00; L_BES_LAENGE: 315; L_BES_DIM: DN250; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/10/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ
Dachhaube gelocht | Půdorys střechy | 6882Obj0000000018 | Stk | Objekt | 0 | Dachhaube gelocht | HV.07.30008 | Nadzemní podlaží 5.NP | 0.315 | NEMSOK - Šířka: 0.4 m; Výška: 0.48 m; Průměr: 250 mm; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: Dachhaube gelocht; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|250.00|250.00|315.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_DWGNAME: ${PROD}l\einbauteile rund\deflektorhauben\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Alu kaschiert|100.00; L_BES_LAENGE: 315; L_BES_DIM: DN250; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/10/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ
Dachhaube gelocht | Půdorys střechy | 6882Obj0000000019 | Stk | Objekt | 0 | Dachhaube gelocht | HV.07.30009 | Nadzemní podlaží 5.NP | 0.315 | NEMSOK - Šířka: 0.4 m; Výška: 0.48 m; Průměr: 250 mm; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: Dachhaube gelocht; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|250.00|250.00|315.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_DWGNAME: ${PROD}l\einbauteile rund\deflektorhauben\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Alu kaschiert|100.00; L_BES_LAENGE: 315; L_BES_DIM: DN250; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/10/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ
Dachhaube gelocht | Půdorys střechy | 6882Obj0000000020 | Stk | Objekt | 0 | Dachhaube gelocht | HV.07.30010 | Nadzemní podlaží 5.NP | 0.315 | NEMSOK - Šířka: 0.4 m; Výška: 0.48 m; Průměr: 250 mm; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: Dachhaube gelocht; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|250.00|250.00|315.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_DWGNAME: ${PROD}l\einbauteile rund\deflektorhauben\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Alu kaschiert|100.00; L_BES_LAENGE: 315; L_BES_DIM: DN250; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/10/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ
Dachhaube gelocht | Půdorys střechy | 6882Obj0000000021 | Stk | Objekt | 0 | Dachhaube gelocht | HV.07.30011 | Nadzemní podlaží 5.NP | 0.315 | NEMSOK - Šířka: 0.4 m; Výška: 0.48 m; Průměr: 250 mm; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: Dachhaube gelocht; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|250.00|250.00|315.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_DWGNAME: ${PROD}l\einbauteile rund\deflektorhauben\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Alu kaschiert|100.00; L_BES_LAENGE: 315; L_BES_DIM: DN250; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/10/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ
Dachhaube gelocht | Půdorys střechy | 6882Obj0000000022 | Stk | Objekt | 0 | Dachhaube gelocht | HV.07.30012 | Nadzemní podlaží 5.NP | 0.315 | NEMSOK - Šířka: 0.4 m; Výška: 0.48 m; Průměr: 250 mm; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: Dachhaube gelocht; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|250.00|250.00|315.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_DWGNAME: ${PROD}l\einbauteile rund\deflektorhauben\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Alu kaschiert|100.00; L_BES_LAENGE: 315; L_BES_DIM: DN250; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/10/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ
Dachhaube gelocht | Půdorys střechy | 6882Obj0000000023 | Stk | Objekt | 0 | Dachhaube gelocht | HV.08.30001 | Nadzemní podlaží 6.NP | 0.315 | NEMSOK - Šířka: 0.4 m; Výška: 0.48 m; Průměr: 250 mm; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: Dachhaube gelocht; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|250.00|250.00|315.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_DWGNAME: ${PROD}l\einbauteile rund\deflektorhauben\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Alu kaschiert|100.00; L_BES_LAENGE: 315; L_BES_DIM: DN250; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/10/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ
Dachhaube gelocht | Půdorys střechy | 6882Obj0000000024 | Stk | Objekt | 0 | Dachhaube gelocht | HV.08.30002 | Nadzemní podlaží 6.NP | 0.315 | NEMSOK - Šířka: 0.4 m; Výška: 0.48 m; Průměr: 250 mm; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: Dachhaube gelocht; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|250.00|250.00|315.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_DWGNAME: ${PROD}l\einbauteile rund\deflektorhauben\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Alu kaschiert|100.00; L_BES_LAENGE: 315; L_BES_DIM: DN250; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/10/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ
Dachhaube gelocht | Půdorys střechy | 6882Obj0000000025 | Stk | Objekt | 0 | Dachhaube gelocht | HV.08.30003 | Nadzemní podlaží 6.NP | 0.315 | NEMSOK - Šířka: 0.4 m; Výška: 0.48 m; Průměr: 250 mm; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: Dachhaube gelocht; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|250.00|250.00|315.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_DWGNAME: ${PROD}l\einbauteile rund\deflektorhauben\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Alu kaschiert|100.00; L_BES_LAENGE: 315; L_BES_DIM: DN250; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/10/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ

# IfcElementAssembly (2)
In: Půdorys 1.PP
NEMSOK - Podlaží: Podzemní podlaží 1.PP; Napajecí napětí: 400 V; Jednotka: Kus; Název_objektu: Skupina elementů
Name | Kód prvku | Délka (m) | Šířka (m) | Výška (m) | Hmotnost | Maximální tlak | Jmenovitý výkon | Chladicí výkon citelný | Chladící výkon | Topný výkon | Odvaděný vzduch = Přiváděný vzduch | Stupeň krytí | Allright_Stavebni_dil_ID
 | JV.02.3002 | 2.3 | 0.58 | 1.8 | 382 kg | 0,008 bar | 2,32 kW | 0 kW | 0 kW | 0,8 kW | 1975 m3/hod | IP 44 | 6772SEl0000161545
 | JV.02.30001 | 5.85 | 0.96 | 2.06 | 1054 kg | 0,011 bar | 5,5 kW | - | 11,3 kW | 22,83kW | 4555 m3/hod | IP 66 | 6772SEl0000139221

# IfcFlowFitting (2887)
NEMSOK - V6: 0 m; V7: 0 m; V8: 0 m; V9: 0; K_GEWERK: 1
Name | In | Jednotka | Délka (m) | Označení | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_DIM | L_BES_DIM_A2 | L_BES_DIM_B2 | L_BES_DIM_A | K_VOLSTROM | K_MLH_GOST = K_MLD_GOST | K_LISTVALUE | Kód prvku | Třída reakce na oheň | Allright_Stavebni_dil_ID | Název_objektu | K_EBT_BOX_WC | Plocha | L_BES_LAENGE | K_INTERNAL_ISO | Tloušťka (m) | Součinitel tepelné vodivost
21104710315050504501x9045xxxx | Půdorys 1.PP | m2 | 0 | 21104710315050504501x9045xxxx | BOGEN ASY. | 20 | 21 | 2/0/0/0/180.0/0/90.0/450.0000/450.0000/710.0000/1/307.5000/505.0000/0/90.0/0/90.0/1.0000/450.0000/315.0000/1/ | 21/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/710.00/315.00/0/50.00/50.00/450.00/100.00/90.00/90.00/1.00/450.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x710 | 450 | 315 | 450 | 0.000 | 0 | 3.180 m2 | TA.02.3152 | A1 | 6772Obj0000001340 | Objekt | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 710; K_LISTVALUE_ISO: 3.950 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.45 m; Výška: 0.71 m
211044x315050503x1x903xxxx0 | Půdorys 1.PP | m2 | 0 | 211044x315050503x1x903xxxx0 | BOGEN ASY. | 20 | 21 | 2/0/0/0/180.0/0/270.0/300.0000/300.0000/400.0000/1/307.5000/350.0000/0/90.0/0/270.0/0/300.0000/315.0000/1/ | 21/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/315.00/0/50.00/50.00/300.00/100.00/90.00/270.00/0/300.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 300x400 | 300 | 315 | 300 | 0.000 | 0 | 1.240 m2 | TA.02.3154 | A1 | 6772Obj0000001343 | Objekt | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; K_LISTVALUE_ISO: 2.290 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.3 m; Výška: 0.4 m
21104710315050504501x9045xxxx | Půdorys 1.PP | m2 | 0 | 21104710315050504501x9045xxxx | BOGEN ASY. | 20 | 21 | 2/0/0/0/180.0/0/90.0/450.0000/450.0000/710.0000/1/307.5000/505.0000/0/90.0/0/90.0/0/450.0000/315.0000/1/ | 21/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/710.00/315.00/0/50.00/50.00/450.00/100.00/90.00/90.00/1.00/450.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x710 | 450 | 315 | 450 | 0.000 | 0 | 3.180 m2 | TA.02.3216 | A1 | 6772Obj0000001660 | Objekt | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 710; K_LISTVALUE_ISO: 3.790 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.45 m; Výška: 0.71 m
2110416016x50501601x9016xxxx | Půdorys 1.PP | m2 | 0 | 2110416016x50501601x9016xxxx | BOGEN ASY. | 20 | 21 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/1/230.0000/230.0000/0/90.0/0/0/125.0000/160.0000/160.0000/1/ | 21/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/160.00/100.00/90.00/0/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3369 | A1 | 6772Obj0000140810 | Objekt | NEMSOK - K_POSITION: L.22; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.16 m; Výška: 0.16 m
25204125012519xxxxxx | Půdorys 1.PP | Kus | 0 | 25204125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 |  | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 125 | 125 | 125 | 120.000 |  | 1.0 | TA.02.3001 | A1 | 6772Obj0000000596 | Objekt | NEMSOK - K_POSITION: L.1; L_BES_DIM_B: 125; Podlaží: Podzemní podlaží 1.PP; Průměr: DN100
