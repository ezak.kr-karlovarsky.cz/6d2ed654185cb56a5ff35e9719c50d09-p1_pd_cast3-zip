Properties of the parts of a building model (IFC2X3), part 44 of 51

# IfcFlowSegment (1090)
Name | In | Jednotka | Délka (m) | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_LAENGE | L_BES_DIM | L_BES_DIM_A2 = L_BES_DIM_A | L_BES_DIM_B2 | K_VOLSTROM | K_LISTVALUE | Kód prvku | Podlaží | Průměr | Teplonosná látka | Allright_Stavebni_dil_ID | Název_objektu | Označení | K_LISTVALUE_ISO
1520416016024xxxxxx0 | Půdorys 1.NP | m | 0.024 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/24.1884/160.0000/160.0000/2/24.1884/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/24.19/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 24 | DN160 | 160 | 160 | 0.000 | 0.024 m | PO.03.30399 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798480905 | Kruhové potrubí | 1520416016024xxxxxx0 | 0.018 m2
15204160160155xxxxxx0 | Půdorys 1.NP | m | 0.155 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/154.9118/160.0000/160.0000/2/154.9118/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/154.91/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 155 | DN160 | 160 | 160 | 0.000 | 0.155 m | PO.03.30400 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798480915 | Kruhové potrubí | 15204160160155xxxxxx0 | 0.117 m2
101063151604xxxxxxx0 | Půdorys 1.NP | m2 | 0.4 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/400.0000/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/400.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400 | 315x160 | 315 | 160 | 0.000 | 1.000 m2 | PO.03.30401 | Nadzemní podlaží 1.NP | - | vzduch | 6782Obj0798481014 | Hranaté potrubí | 101063151604xxxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.315 m; Výška: 0.16 m
1520616016021xxxxxx0 | Půdorys 1.NP | m | 0.021 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/21.1806/160.0000/160.0000/2/21.1806/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/21.18/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 21 | DN160 | 160 | 160 | 0.000 | 0.021 m | PO.03.30402 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798481019 | Kruhové potrubí | 1520616016021xxxxxx0 | 0.016 m2
1520616016064xxxxxx0 | Půdorys 1.NP | m | 0.064 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/64.2563/160.0000/160.0000/2/64.2563/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/64.26/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 64 | DN160 | 160 | 160 | 0.000 | 0.064 m | PO.03.30403 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798481029 | Kruhové potrubí | 1520616016064xxxxxx0 | 0.048 m2
1520616016021xxxxxx0 | Půdorys 1.NP | m | 0.021 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/20.9316/160.0000/160.0000/2/20.9316/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/20.93/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 21 | DN160 | 160 | 160 | 0.000 | 0.021 m | PO.03.30404 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798481039 | Kruhové potrubí | 1520616016021xxxxxx0 | 0.016 m2
1520616016073xxxxxx0 | Půdorys 1.NP | m | 0.073 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/73.2210/160.0000/160.0000/2/73.2210/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/73.22/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 73 | DN160 | 160 | 160 | 0.000 | 0.073 m | PO.03.30405 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798481044 | Kruhové potrubí | 1520616016073xxxxxx0 | 0.055 m2
1520616016064xxxxxx0 | Půdorys 1.NP | m | 0.064 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/64.2563/160.0000/160.0000/2/64.2563/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/64.26/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 64 | DN160 | 160 | 160 | 0.000 | 0.064 m | PO.03.30406 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798481054 | Kruhové potrubí | 1520616016064xxxxxx0 | 0.048 m2
1520616016073xxxxxx0 | Půdorys 1.NP | m | 0.073 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/73.1716/160.0000/160.0000/2/73.1716/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/73.17/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 73 | DN160 | 160 | 160 | 0.000 | 0.073 m | PO.03.30407 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798481064 | Kruhové potrubí | 1520616016073xxxxxx0 | 0.055 m2
1520416016047xxxxxx0 | Půdorys 1.NP | m | 0.047 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/47.2352/160.0000/160.0000/2/47.2352/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/47.24/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 47 | DN160 | 160 | 160 | 0.000 | 0.047 m | PO.03.30408 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798481280 | Kruhové potrubí | 1520416016047xxxxxx0 | 0.036 m2
1520416016083xxxxxx0 | Půdorys 1.NP | m | 0.083 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/82.9124/160.0000/160.0000/2/82.9124/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/82.91/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 83 | DN160 | 160 | 160 | 0.000 | 0.083 m | PO.03.30409 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798481491 | Kruhové potrubí | 1520416016083xxxxxx0 | 0.063 m2
1520425025011xxxxxx0 | Půdorys 1.NP | m | 0.011 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/11.3925/250.0000/250.0000/2/11.3925/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/11.39/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 11 | DN250 | 250 | 250 | 0.000 | 0.011 m | PO.03.30410 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798481514 | Kruhové potrubí | 1520425025011xxxxxx0 | 0.016 m2
1520425025013xxxxxx0 | Půdorys 1.NP | m | 0.013 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/13.4408/250.0000/250.0000/2/13.4408/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/13.44/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 13 | DN250 | 250 | 250 | 0.000 | 0.013 m | PO.03.30411 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798481534 | Kruhové potrubí | 1520425025013xxxxxx0 | 0.019 m2
 | Půdorys 1.NP | m | 1.126 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/126.0000/250.0000/250.0000/2/126.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/126.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 126 | DN250 | 250 | 250 | 0.000 | 0.126 m | PO.03.30412 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798481589 | Kruhové potrubí |  | 0.178 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 1126.000|125.000|125.000|0.000|-125.000|-125.000|0.000|0.000|0.000|1.000
1520625025063xxxxxxx | Půdorys 1.NP | m | 0.63 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/130.0000/250.0000/250.0000/2/130.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/130.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Mineralwolle/100.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | 130 | DN250 | 250 | 250 | 0.000 | 0.130 m | PO.03.30413 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798481610 | Kruhové potrubí | 1520625025063xxxxxxx | 0.184 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 630.000|125.000|125.000|0.000|-125.000|-125.000|0.000|0.000|0.000|1.000
15204160160167xxxxxx0 | Půdorys 1.NP | m | 0.167 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/166.7821/160.0000/160.0000/2/166.7821/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/166.78/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 167 | DN160 | 160 | 160 | 0.000 | 0.167 m | PO.03.30414 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798481618 | Kruhové potrubí | 15204160160167xxxxxx0 | 0.126 m2
1010532016014xxxxxxx | Půdorys 1.NP | m2 | 0.14 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/320.0000/160.0000/1/140.0000/0/0/0/0/0/1.0000/320.0000/160.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/320.00/160.00/140.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 140 | 320x160 | 320 | 160 | 0.000 | 1.000 m2 | PO.03.30415 | Nadzemní podlaží 1.NP | - | vzduch | 6782Obj0798481651 | Hranaté potrubí | 1010532016014xxxxxxx | 1.000 m2 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.32 m; Výška: 0.16 m; K_EBT_BOX_WC: 400.000|177.500|100.000|0.000|-177.500|-100.000|0.000|0.000|0.000|1.000
152042x2x5xxxxxxx | Půdorys 1.NP | m | 0.05 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/50.0000/200.0000/200.0000/2/50.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 50 | DN200 | 200 | 200 | 0.000 | 0.050 m | PO.03.30416 | Nadzemní podlaží 1.NP | DN200 | vzduch | 6782Obj0798481667 | Kruhové potrubí | 152042x2x5xxxxxxx | 0.044 m2
152042x2x76xxxxxx0 | Půdorys 1.NP | m | 0.076 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/75.7514/200.0000/200.0000/2/75.7514/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/75.75/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 76 | DN200 | 200 | 200 | 0.000 | 0.076 m | PO.03.30417 | Nadzemní podlaží 1.NP | DN200 | vzduch | 6782Obj0798481707 | Kruhové potrubí | 152042x2x76xxxxxx0 | 0.067 m2
101043151603xxxxxxx0 | Půdorys 1.NP | m | 0.3 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/300.0000/160.0000/160.0000/2/300.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/300.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 300 | DN160 | 160 | 160 | 0.000 | 0.300 m | PO.03.30418 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798481951 | Kruhové potrubí | 101043151603xxxxxxx0 | 0.226 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 300.000|177.500|100.000|0.000|-177.500|-100.000|0.000|0.000|0.000|1.000
1520416016067xxxxxx0 | Půdorys 1.NP | m | 0.067 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/67.4930/160.0000/160.0000/2/67.4930/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/67.49/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 67 | DN160 | 160 | 160 | 0.000 | 0.068 m | PO.03.30419 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798481984 | Kruhové potrubí | 1520416016067xxxxxx0 | 0.051 m2
1520416016055xxxxxxx | Půdorys 1.NP | m | 0.55 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/200.0000/160.0000/160.0000/2/200.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/200.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200 | DN160 | 160 | 160 | 120.000 | 0.200 m | PO.03.30420 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798482034 | Kruhové potrubí | 1520416016055xxxxxxx | 0.151 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 550.211|80.000|80.000|0.000|-80.000|-80.000|0.000|0.000|0.000|1.000
15204160160567xxxxxx0 | Půdorys 1.NP | m | 0.567 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/200.0000/160.0000/160.0000/2/200.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/200.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200 | DN160 | 160 | 160 | 120.000 | 0.200 m | PO.03.30421 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798482039 | Kruhové potrubí | 15204160160567xxxxxx0 | 0.151 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 567.019|80.000|80.000|0.000|-80.000|-80.000|0.000|0.000|0.000|1.000
1520416016022xxxxxxx | Půdorys 1.NP | m | 0.22 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/220.3991/160.0000/160.0000/2/220.3991/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/220.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 220 | DN160 | 160 | 160 | 120.000 | 0.220 m | PO.03.30422 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798482054 | Kruhové potrubí | 1520416016022xxxxxxx | 0.166 m2
15204160160154xxxxxx0 | Půdorys 1.NP | m | 0.154 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/154.0621/160.0000/160.0000/2/154.0621/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/154.06/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 154 | DN160 | 160 | 160 | 120.000 | 0.154 m | PO.03.30423 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798482064 | Kruhové potrubí | 15204160160154xxxxxx0 | 0.116 m2
152041601608xxxxxxx | Půdorys 1.NP | m | 0.08 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/80.1033/160.0000/160.0000/2/80.1033/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/80.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 80 | DN160 | 160 | 160 | 120.000 | 0.080 m | PO.03.30424 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798482069 | Kruhové potrubí | 152041601608xxxxxxx | 0.060 m2
1520416016022xxxxxxx | Půdorys 1.NP | m | 0.22 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/220.3991/160.0000/160.0000/2/220.3991/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/220.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 220 | DN160 | 160 | 160 | 120.000 | 0.220 m | PO.03.30425 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798482079 | Kruhové potrubí | 1520416016022xxxxxxx | 0.166 m2
152041601608xxxxxxx | Půdorys 1.NP | m | 0.08 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/80.0552/160.0000/160.0000/2/80.0552/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/80.06/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 80 | DN160 | 160 | 160 | 120.000 | 0.080 m | PO.03.30426 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798482089 | Kruhové potrubí | 152041601608xxxxxxx | 0.060 m2
1520416016017xxxxxx0 | Půdorys 1.NP | m | 0.017 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/17.3000/160.0000/160.0000/2/17.3000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/17.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 17 | DN160 | 160 | 160 | 0.000 | 0.017 m | PO.03.30427 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798482124 | Kruhové potrubí | 1520416016017xxxxxx0 | 0.013 m2
152041601604xxxxxx0 | Půdorys 1.NP | m | 0.004 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/4.2563/160.0000/160.0000/2/4.2563/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/4.26/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 4 | DN160 | 160 | 160 | 0.000 | 0.004 m | PO.03.30428 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798482134 | Kruhové potrubí | 152041601604xxxxxx0 | 0.003 m2
15204160160226xxxxxxx | Půdorys 1.NP | m | 2.26 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/2260.0000/160.0000/160.0000/2/2260.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/2260.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 2260 | DN160 | 160 | 160 | 120.000 | 2.260 m | PO.03.30429 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798482144 | Kruhové potrubí | 15204160160226xxxxxxx | 1.704 m2
1520416016039xxxxxx0 | Půdorys 1.NP | m | 0.039 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/39.1931/160.0000/160.0000/2/39.1931/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/39.19/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 39 | DN160 | 160 | 160 | 120.000 | 0.039 m | PO.03.30430 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798482160 | Kruhové potrubí | 1520416016039xxxxxx0 | 0.030 m2
1520416016056xxxxxx0 | Půdorys 1.NP | m | 0.056 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/55.6497/160.0000/160.0000/2/55.6497/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/55.65/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 56 | DN160 | 160 | 160 | 120.000 | 0.056 m | PO.03.30431 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798482170 | Kruhové potrubí | 1520416016056xxxxxx0 | 0.042 m2
1520416016039xxxxxx0 | Půdorys 1.NP | m | 0.039 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/39.0606/160.0000/160.0000/2/39.0606/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/39.06/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 39 | DN160 | 160 | 160 | 120.000 | 0.039 m | PO.03.30432 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798482180 | Kruhové potrubí | 1520416016039xxxxxx0 | 0.029 m2
15204160160185xxxxxx0 | Půdorys 1.NP | m | 0.185 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/184.8006/160.0000/160.0000/2/184.8006/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/184.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 185 | DN160 | 160 | 160 | 120.000 | 0.185 m | PO.03.30433 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798482185 | Kruhové potrubí | 15204160160185xxxxxx0 | 0.139 m2
152041601606xxxxxxx | Půdorys 1.NP | m | 0.06 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/59.8924/160.0000/160.0000/2/59.8924/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/59.89/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 60 | DN160 | 160 | 160 | 120.000 | 0.060 m | PO.03.30434 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798482195 | Kruhové potrubí | 152041601606xxxxxxx | 0.045 m2
15204160160345xxxxxx0 | Půdorys 1.NP | m | 0.345 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/344.8006/160.0000/160.0000/2/344.8006/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/344.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 345 | DN160 | 160 | 160 | 120.000 | 0.345 m | PO.03.30435 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798482200 | Kruhové potrubí | 15204160160345xxxxxx0 | 0.260 m2
15204125125324xxxxxx0 | Půdorys 1.NP | m | 0.324 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/324.0000/125.0000/125.0000/2/324.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/324.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 324 | DN125 | 125 | 125 | 120.000 | 0.324 m | PO.03.30436 | Nadzemní podlaží 1.NP | DN125 | vzduch | 6782Obj0798482205 | Kruhové potrubí | 15204125125324xxxxxx0 | 0.209 m2
15204160160142xxxxxx0 | Půdorys 1.NP | m | 0.142 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/142.2000/160.0000/160.0000/2/142.2000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/142.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 142 | DN160 | 160 | 160 | 120.000 | 0.142 m | PO.03.30437 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798482210 | Kruhové potrubí | 15204160160142xxxxxx0 | 0.107 m2
15204125125138xxxxxx0 | Půdorys 1.NP | m | 0.138 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/137.5000/125.0000/125.0000/2/137.5000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/137.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 138 | DN125 | 125 | 125 | 120.000 | 0.138 m | PO.03.30438 | Nadzemní podlaží 1.NP | DN125 | vzduch | 6782Obj0798482215 | Kruhové potrubí | 15204125125138xxxxxx0 | 0.089 m2
152041251254xxxxxxx | Půdorys 1.NP | m | 0.04 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/40.0000/125.0000/125.0000/2/40.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/40.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 40 | DN125 | 125 | 125 | 120.000 | 0.040 m | PO.03.30439 | Nadzemní podlaží 1.NP | DN125 | vzduch | 6782Obj0798482220 | Kruhové potrubí | 152041251254xxxxxxx | 0.026 m2
15204125125138xxxxxx0 | Půdorys 1.NP | m | 0.138 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/137.5000/125.0000/125.0000/2/137.5000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/137.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 138 | DN125 | 125 | 125 | 120.000 | 0.138 m | PO.03.30440 | Nadzemní podlaží 1.NP | DN125 | vzduch | 6782Obj0798482225 | Kruhové potrubí | 15204125125138xxxxxx0 | 0.089 m2
15204125125348xxxxxx0 | Půdorys 1.NP | m | 0.348 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/347.6732/125.0000/125.0000/2/347.6732/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/347.67/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 348 | DN125 | 125 | 125 | 120.000 | 0.348 m | PO.03.30441 | Nadzemní podlaží 1.NP | DN125 | vzduch | 6782Obj0798482230 | Kruhové potrubí | 15204125125348xxxxxx0 | 0.224 m2
15204125125108xxxxxx0 | Půdorys 1.NP | m | 0.108 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/107.6561/125.0000/125.0000/2/107.6561/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/107.66/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 108 | DN125 | 125 | 125 | 120.000 | 0.108 m | PO.03.30442 | Nadzemní podlaží 1.NP | DN125 | vzduch | 6782Obj0798482235 | Kruhové potrubí | 15204125125108xxxxxx0 | 0.069 m2
15204125125182xxxxxx0 | Půdorys 1.NP | m | 0.182 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/181.8342/125.0000/125.0000/2/181.8342/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/181.83/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 182 | DN125 | 125 | 125 | 120.000 | 0.182 m | PO.03.30443 | Nadzemní podlaží 1.NP | DN125 | vzduch | 6782Obj0798482245 | Kruhové potrubí | 15204125125182xxxxxx0 | 0.117 m2
15204125125108xxxxxx0 | Půdorys 1.NP | m | 0.108 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/107.7141/125.0000/125.0000/2/107.7141/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/107.71/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 108 | DN125 | 125 | 125 | 120.000 | 0.108 m | PO.03.30444 | Nadzemní podlaží 1.NP | DN125 | vzduch | 6782Obj0798482255 | Kruhové potrubí | 15204125125108xxxxxx0 | 0.069 m2
15204125125316xxxxxx0 | Půdorys 1.NP | m | 0.316 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/315.8152/125.0000/125.0000/2/315.8152/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/315.82/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 316 | DN125 | 125 | 125 | 120.000 | 0.316 m | PO.03.30445 | Nadzemní podlaží 1.NP | DN125 | vzduch | 6782Obj0798482260 | Kruhové potrubí | 15204125125316xxxxxx0 | 0.203 m2
152041x1x24xxxxxx0 | Půdorys 1.NP | m | 0.024 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/24.3714/100.0000/100.0000/2/24.3714/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/24.37/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 24 | DN100 | 100 | 100 | 0.000 | 0.024 m | PO.03.30446 | Nadzemní podlaží 1.NP | DN100 | vzduch | 6782Obj0798482266 | Kruhové potrubí | 152041x1x24xxxxxx0 | 0.014 m2
152041x1x24xxxxxx0 | Půdorys 1.NP | m | 0.024 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/24.3714/100.0000/100.0000/2/24.3714/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/24.37/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 24 | DN100 | 100 | 100 | 0.000 | 0.024 m | PO.03.30447 | Nadzemní podlaží 1.NP | DN100 | vzduch | 6782Obj0798482291 | Kruhové potrubí | 152041x1x24xxxxxx0 | 0.014 m2
152041x1x432xxxxxx0 | Půdorys 1.NP | m | 0.432 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/231.8000/100.0000/100.0000/2/231.8000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/231.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 232 | DN100 | 100 | 100 | 0.000 | 0.232 m | PO.03.30448 | Nadzemní podlaží 1.NP | DN100 | vzduch | 6782Obj0798482319 | Kruhové potrubí | 152041x1x432xxxxxx0 | 0.131 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 431.843|50.000|50.000|0.000|-50.000|-50.000|0.000|0.000|0.000|1.000
152041x1x104xxxxxx0 | Půdorys 1.NP | m | 0.104 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/104.2526/100.0000/100.0000/2/104.2526/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/104.25/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 104 | DN100 | 100 | 100 | 120.000 | 0.104 m | PO.03.30449 | Nadzemní podlaží 1.NP | DN100 | vzduch | 6782Obj0798482487 | Kruhové potrubí | 152041x1x104xxxxxx0 | 0.059 m2
152041x1x276xxxxxx0 | Půdorys 1.NP | m | 0.276 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/276.2438/100.0000/100.0000/2/276.2438/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/276.24/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 276 | DN100 | 100 | 100 | 120.000 | 0.276 m | PO.03.30450 | Nadzemní podlaží 1.NP | DN100 | vzduch | 6782Obj0798482497 | Kruhové potrubí | 152041x1x276xxxxxx0 | 0.156 m2
152041x1x146xxxxxx0 | Půdorys 1.NP | m | 0.146 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/145.6739/100.0000/100.0000/2/145.6739/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/145.67/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 146 | DN100 | 100 | 100 | 120.000 | 0.146 m | PO.03.30451 | Nadzemní podlaží 1.NP | DN100 | vzduch | 6782Obj0798482502 | Kruhové potrubí | 152041x1x146xxxxxx0 | 0.082 m2
15204160160522xxxxxx0 | Půdorys 1.NP | m | 0.522 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/521.6011/160.0000/160.0000/2/521.6011/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/521.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 522 | DN160 | 160 | 160 | 0.000 | 0.522 m | PO.03.30452 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798482527 | Kruhové potrubí | 15204160160522xxxxxx0 | 0.393 m2
15204160160343xxxxxx0 | Půdorys 1.NP | m | 0.343 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/33.0000/160.0000/160.0000/2/33.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/33.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 33 | DN160 | 160 | 160 | 0.000 | 0.033 m | PO.03.30453 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798482541 | Kruhové potrubí | 15204160160343xxxxxx0 | 0.025 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 343.000|80.000|80.000|0.000|-80.000|-80.000|0.000|0.000|0.000|1.000
15204160160876xxxxxx0 | Půdorys 1.NP | m | 0.876 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/566.0000/160.0000/160.0000/2/566.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/566.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 566 | DN160 | 160 | 160 | 0.000 | 0.566 m | PO.03.30454 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798482728 | Kruhové potrubí | 15204160160876xxxxxx0 | 0.427 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 876.000|80.000|80.000|0.000|-80.000|-80.000|0.000|0.000|0.000|1.000
152042x2x1xxxxxxx0 | Půdorys 1.NP | m | 0.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/100.0000/200.0000/200.0000/2/100.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 100 | DN200 | 200 | 200 | 0.000 | 0.100 m | PO.03.30455 | Nadzemní podlaží 1.NP | DN200 | vzduch | 6782Obj0798482735 | Kruhové potrubí | 152042x2x1xxxxxxx0 | 0.088 m2
152041x1x2xxxxxxx | Půdorys 1.NP | m | 0.02 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/19.9000/100.0000/100.0000/2/19.9000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/19.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 20 | DN100 | 100 | 100 | 0.000 | 0.020 m | PO.03.30456 | Nadzemní podlaží 1.NP | DN100 | vzduch | 6782Obj0798482753 | Kruhové potrubí | 152041x1x2xxxxxxx | 0.011 m2
1520425025025xxxxxx0 | Půdorys 1.NP | m | 0.025 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/24.7000/250.0000/250.0000/2/24.7000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/24.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 25 | DN250 | 250 | 250 | 0.000 | 0.025 m | PO.03.30457 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798482813 | Kruhové potrubí | 1520425025025xxxxxx0 | 0.026 m2
1520425025025xxxxxx0 | Půdorys 1.NP | m | 0.025 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/24.7000/250.0000/250.0000/2/24.7000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/24.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 25 | DN250 | 250 | 250 | 0.000 | 0.025 m | PO.03.30458 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798482818 | Kruhové potrubí | 1520425025025xxxxxx0 | 0.026 m2
15204160160245xxxxxx0 | Půdorys 1.NP | m | 0.245 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/245.0000/160.0000/160.0000/2/245.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/245.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 245 | DN160 | 160 | 160 | 0.000 | 0.245 m | PO.03.30459 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798482849 | Kruhové potrubí | 15204160160245xxxxxx0 | 0.185 m2
1520416016019xxxxxx0 | Půdorys 1.NP | m | 0.019 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/19.2872/160.0000/160.0000/2/19.2872/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/19.29/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 19 | DN160 | 160 | 160 | 0.000 | 0.019 m | PO.03.30460 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798482874 | Kruhové potrubí | 1520416016019xxxxxx0 | 0.015 m2
15204250250145xxxxxxx | Půdorys 1.NP | m | 1.45 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1450.0000/250.0000/250.0000/2/1450.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/1450.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | 1450 | DN250 | 250 | 250 | 0.000 | 1.450 m | PO.03.30461 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798486191 | Kruhové potrubí | 15204250250145xxxxxxx | 1.503 m2
15204250250578xxxxxx0 | Půdorys 1.NP | m | 0.578 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/577.9000/250.0000/250.0000/2/577.9000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/577.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | 578 | DN250 | 250 | 250 | 0.000 | 0.578 m | PO.03.30462 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798486197 | Kruhové potrubí | 15204250250578xxxxxx0 | 0.599 m2
152041251253xxxxxxx0 | Půdorys 1.NP | m | 0.3 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/60.0000/125.0000/125.0000/2/60.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | 60 | DN125 | 125 | 125 | 0.000 | 0.060 m | PO.03.30463 | Nadzemní podlaží 1.NP | DN125 | vzduch | 6782Obj0798486201 | Kruhové potrubí | 152041251253xxxxxxx0 | 0.039 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 300.000|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
15204125125341xxxxxx0 | Půdorys 1.NP | m | 0.341 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/340.5812/125.0000/125.0000/2/340.5812/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/340.58/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | 341 | DN125 | 125 | 125 | 0.000 | 0.341 m | PO.03.30464 | Nadzemní podlaží 1.NP | DN125 | vzduch | 6782Obj0798486205 | Kruhové potrubí | 15204125125341xxxxxx0 | 0.219 m2
15204125125352xxxxxx0 | Půdorys 1.NP | m | 0.352 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/352.2000/125.0000/125.0000/2/352.2000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/352.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | 352 | DN125 | 125 | 125 | 0.000 | 0.352 m | PO.03.30465 | Nadzemní podlaží 1.NP | DN125 | vzduch | 6782Obj0798486209 | Kruhové potrubí | 15204125125352xxxxxx0 | 0.227 m2
15204160160595xxxxxx0 | Půdorys 1.NP | m | 0.595 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/595.2000/160.0000/160.0000/2/595.2000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/595.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | 595 | DN160 | 160 | 160 | 0.000 | 0.595 m | PO.03.30466 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798486217 | Kruhové potrubí | 15204160160595xxxxxx0 | 0.449 m2
15204125125178xxxxxx0 | Půdorys 1.NP | m | 0.178 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/178.3000/125.0000/125.0000/2/178.3000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/178.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | 178 | DN125 | 125 | 125 | 0.000 | 0.178 m | PO.03.30467 | Nadzemní podlaží 1.NP | DN125 | vzduch | 6782Obj0798486223 | Kruhové potrubí | 15204125125178xxxxxx0 | 0.115 m2
15204125125261xxxxxx0 | Půdorys 1.NP | m | 0.261 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/260.9000/125.0000/125.0000/2/260.9000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/260.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | 261 | DN125 | 125 | 125 | 0.000 | 0.261 m | PO.03.30468 | Nadzemní podlaží 1.NP | DN125 | vzduch | 6782Obj0798486227 | Kruhové potrubí | 15204125125261xxxxxx0 | 0.168 m2
1520416016054xxxxxxx | Půdorys 1.NP | m | 0.54 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/540.0000/160.0000/160.0000/2/540.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/540.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | 540 | DN160 | 160 | 160 | 0.000 | 0.540 m | PO.03.30469 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798486229 | Kruhové potrubí | 1520416016054xxxxxxx | 0.407 m2
15204250250781xxxxxx0 | Půdorys 1.NP | m | 0.781 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/781.2000/250.0000/250.0000/2/781.2000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/781.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | 781 | DN250 | 250 | 250 | 0.000 | 0.781 m | PO.03.30470 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798486250 | Kruhové potrubí | 15204250250781xxxxxx0 | 0.810 m2
152041601604xxxxxxx | Půdorys 1.NP | m | 0.04 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/40.0000/160.0000/160.0000/2/40.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/40.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 40 | DN160 | 160 | 160 | 0.000 | 0.040 m | PO.03.30471 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798488155 | Kruhové potrubí | 152041601604xxxxxxx | 0.030 m2
1520416016079xxxxxxx | Půdorys 1.NP | m | 0.79 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/100.0000/160.0000/160.0000/2/100.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | 100 | DN160 | 160 | 160 | 0.000 | 0.100 m | PO.03.30472 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798488767 | Kruhové potrubí | 1520416016079xxxxxxx | 0.075 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 480.000|80.000|80.000|0.000|-80.000|-80.000|0.000|0.000|0.000|1.000
15204250250993xxxxxx0 | Půdorys 1.NP | m | 0.993 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/600.0000/250.0000/250.0000/2/600.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/600.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | 600 | DN250 | 250 | 250 | 0.000 | 0.600 m | PO.03.30473 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798488772 | Kruhové potrubí | 15204250250993xxxxxx0 | 0.622 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 992.500|125.000|125.000|0.000|-125.000|-125.000|0.000|0.000|0.000|1.000
152042x2x58xxxxxx0 | Půdorys 1.NP | m | 0.058 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/58.4000/200.0000/200.0000/2/58.4000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/58.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 58 | DN200 | 200 | 200 | 0.000 | 0.058 m | PO.03.30474 | Nadzemní podlaží 1.NP | DN200 | vzduch | 6782Obj0798488782 | Kruhové potrubí | 152042x2x58xxxxxx0 | 0.051 m2
152042502506xxxxxx0 | Půdorys 1.NP | m | 0.006 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/5.5156/250.0000/250.0000/2/5.5156/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/5.52/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 6 | DN250 | 250 | 250 | 0.000 | 0.005 m | PO.03.30475 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798488792 | Kruhové potrubí | 152042502506xxxxxx0 | 0.006 m2
15204250250196xxxxxx0 | Půdorys 1.NP | m | 0.196 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/195.9953/250.0000/250.0000/2/195.9953/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/196.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 196 | DN250 | 250 | 250 | 0.000 | 0.196 m | PO.03.30476 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798488802 | Kruhové potrubí | 15204250250196xxxxxx0 | 0.203 m2
152042502506xxxxxx0 | Půdorys 1.NP | m | 0.006 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/5.7025/250.0000/250.0000/2/5.7025/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/5.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 6 | DN250 | 250 | 250 | 0.000 | 0.006 m | PO.03.30477 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798488812 | Kruhové potrubí | 152042502506xxxxxx0 | 0.006 m2
15206250250704xxxxxx0 | Půdorys 1.NP | m | 0.704 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/704.0000/250.0000/250.0000/2/704.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/704.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | 704 | DN250 | 250 | 250 | 0.000 | 0.704 m | PO.03.30478 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798488817 | Kruhové potrubí | 15206250250704xxxxxx0 | 0.730 m2
152061601608xxxxxx0 | Půdorys 1.NP | m | 0.008 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/8.1110/160.0000/160.0000/2/8.1110/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/8.11/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 8 | DN160 | 160 | 160 | 0.000 | 0.008 m | PO.03.30479 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798488833 | Kruhové potrubí | 152061601608xxxxxx0 | 0.006 m2
15206160160116xxxxxx0 | Půdorys 1.NP | m | 0.116 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/116.2829/160.0000/160.0000/2/116.2829/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/116.28/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 116 | DN160 | 160 | 160 | 0.000 | 0.116 m | PO.03.30480 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798488843 | Kruhové potrubí | 15206160160116xxxxxx0 | 0.088 m2
152061601608xxxxxx0 | Půdorys 1.NP | m | 0.008 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/7.7464/160.0000/160.0000/2/7.7464/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/7.75/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 8 | DN160 | 160 | 160 | 0.000 | 0.008 m | PO.03.30481 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798488853 | Kruhové potrubí | 152061601608xxxxxx0 | 0.006 m2
15206250250229xxxxxx0 | Půdorys 1.NP | m | 0.229 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/228.5000/250.0000/250.0000/2/228.5000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/228.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 229 | DN250 | 250 | 250 | 0.000 | 0.229 m | PO.03.30482 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798488858 | Kruhové potrubí | 15206250250229xxxxxx0 | 0.237 m2
1520412512512xxxxxxx | Půdorys 1.NP | m | 0.12 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/120.3954/125.0000/125.0000/2/120.3954/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/120.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 120 | DN125 | 125 | 125 | 120.000 | 0.120 m | PO.03.30483 | Nadzemní podlaží 1.NP | DN125 | vzduch | 6782Obj0798488868 | Kruhové potrubí | 1520412512512xxxxxxx | 0.078 m2
1520412512597xxxxxx0 | Půdorys 1.NP | m | 0.097 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/97.4845/125.0000/125.0000/2/97.4845/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/97.48/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 97 | DN125 | 125 | 125 | 120.000 | 0.098 m | PO.03.30484 | Nadzemní podlaží 1.NP | DN125 | vzduch | 6782Obj0798488888 | Kruhové potrubí | 1520412512597xxxxxx0 | 0.063 m2
15204125125261xxxxxx0 | Půdorys 1.NP | m | 0.261 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/20.7000/125.0000/125.0000/2/20.7000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/20.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 21 | DN125 | 125 | 125 | 120.000 | 0.021 m | PO.03.30485 | Nadzemní podlaží 1.NP | DN125 | vzduch | 6782Obj0798488907 | Kruhové potrubí | 15204125125261xxxxxx0 | 0.013 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 260.684|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
1520412512529xxxxxxx | Půdorys 1.NP | m | 0.29 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/290.0000/125.0000/125.0000/2/290.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/290.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | 290 | DN125 | 125 | 125 | 0.000 | 0.290 m | PO.03.30486 | Nadzemní podlaží 1.NP | DN125 | vzduch | 6782Obj0798488985 | Kruhové potrubí | 1520412512529xxxxxxx | 0.187 m2
15204125125172xxxxxx0 | Půdorys 1.NP | m | 0.172 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/171.6221/125.0000/125.0000/2/171.6221/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/171.62/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 172 | DN125 | 125 | 125 | 0.000 | 0.172 m | PO.03.30487 | Nadzemní podlaží 1.NP | DN125 | vzduch | 6782Obj0798488990 | Kruhové potrubí | 15204125125172xxxxxx0 | 0.111 m2
15204125125172xxxxxx0 | Půdorys 1.NP | m | 0.172 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/171.5713/125.0000/125.0000/2/171.5713/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/171.57/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 172 | DN125 | 125 | 125 | 0.000 | 0.172 m | PO.03.30488 | Nadzemní podlaží 1.NP | DN125 | vzduch | 6782Obj0798489010 | Kruhové potrubí | 15204125125172xxxxxx0 | 0.111 m2
15204125125336xxxxxx0 | Půdorys 1.NP | m | 0.336 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/95.9000/125.0000/125.0000/2/95.9000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/95.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 96 | DN125 | 125 | 125 | 0.000 | 0.096 m | PO.03.30489 | Nadzemní podlaží 1.NP | DN125 | vzduch | 6782Obj0798489023 | Kruhové potrubí | 15204125125336xxxxxx0 | 0.062 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 335.918|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
10104315160531xxxxxx0 | Půdorys 1.NP | m2 | 0.531 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/530.5193/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/530.52/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 531 | 315x160 | 315 | 160 | 0.000 | 1.000 m2 | PO.03.30490 | Nadzemní podlaží 1.NP | - | vzduch | 6782Obj0798489976 | Hranaté potrubí | 10104315160531xxxxxx0 | 1.000 m2 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.315 m; Výška: 0.16 m
 | Půdorys 1.NP | m2 | 1.097 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/1097.0867/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/1097.09/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1097 | 315x160 | 315 | 160 | 0.000 | 1.040 m2 | PO.03.30491 | Nadzemní podlaží 1.NP | - | vzduch | 6782Obj0798490006 | Hranaté potrubí |  | 1.390 m2 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.315 m; Výška: 0.16 m
15206250250238xxxxxx0 | Půdorys 1.NP | m | 0.238 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/238.1588/250.0000/250.0000/2/238.1588/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/238.16/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 238 | DN250 | 250 | 250 | 0.000 | 0.238 m | PO.03.30492 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798490037 | Kruhové potrubí | 15206250250238xxxxxx0 | 0.247 m2
15206160160208xxxxxx0 | Půdorys 1.NP | m | 0.208 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/208.4000/160.0000/160.0000/2/208.4000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/208.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 208 | DN160 | 160 | 160 | 0.000 | 0.208 m | PO.03.30493 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798490062 | Kruhové potrubí | 15206160160208xxxxxx0 | 0.157 m2
1520616016015xxxxxx0 | Půdorys 1.NP | m | 0.015 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/14.6973/160.0000/160.0000/2/14.6973/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/14.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 15 | DN160 | 160 | 160 | 0.000 | 0.015 m | PO.03.30494 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798490072 | Kruhové potrubí | 1520616016015xxxxxx0 | 0.011 m2
15206160160334xxxxxx0 | Půdorys 1.NP | m | 0.334 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/334.1770/160.0000/160.0000/2/334.1770/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/334.18/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 334 | DN160 | 160 | 160 | 0.000 | 0.334 m | PO.03.30495 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798490082 | Kruhové potrubí | 15206160160334xxxxxx0 | 0.252 m2
1520616016015xxxxxx0 | Půdorys 1.NP | m | 0.015 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/14.6426/160.0000/160.0000/2/14.6426/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/14.64/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 15 | DN160 | 160 | 160 | 0.000 | 0.015 m | PO.03.30496 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798490092 | Kruhové potrubí | 1520616016015xxxxxx0 | 0.011 m2
152041x1x35xxxxxx0 | Půdorys 1.NP | m | 0.035 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/35.0386/100.0000/100.0000/2/35.0386/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/35.04/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 35 | DN100 | 100 | 100 | 0.000 | 0.035 m | PO.03.30497 | Nadzemní podlaží 1.NP | DN100 | vzduch | 6782Obj0798490097 | Kruhové potrubí | 152041x1x35xxxxxx0 | 0.020 m2
