Properties of the parts of a building model (IFC2X3), part 45 of 51

# IfcFlowSegment (1090)
Name | In | Jednotka | Délka (m) | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_LAENGE | L_BES_DIM | L_BES_DIM_A2 = L_BES_DIM_A | L_BES_DIM_B2 | K_VOLSTROM | K_LISTVALUE | Kód prvku | Podlaží | Průměr | Teplonosná látka | Allright_Stavebni_dil_ID | Název_objektu | Označení | K_LISTVALUE_ISO
152041x1x402xxxxxx0 | Půdorys 1.NP | m | 0.402 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/402.0000/100.0000/100.0000/2/402.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/402.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 402 | DN100 | 100 | 100 | 0.000 | 0.402 m | PO.03.30498 | Nadzemní podlaží 1.NP | DN100 | vzduch | 6782Obj0798490107 | Kruhové potrubí | 152041x1x402xxxxxx0 | 0.227 m2
15204160160206xxxxxx0 | Půdorys 1.NP | m | 0.206 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/206.3049/160.0000/160.0000/2/206.3049/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/206.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 206 | DN160 | 160 | 160 | 0.000 | 0.206 m | PO.03.30499 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798490122 | Kruhové potrubí | 15204160160206xxxxxx0 | 0.156 m2
152041x1x263xxxxxx0 | Půdorys 1.NP | m | 0.263 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/100.0000/100.0000/100.0000/2/100.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 100 | DN100 | 100 | 100 | 0.000 | 0.100 m | PO.03.30500 | Nadzemní podlaží 1.NP | DN100 | vzduch | 6782Obj0798490147 | Kruhové potrubí | 152041x1x263xxxxxx0 | 0.057 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 262.500|50.000|50.000|0.000|-50.000|-50.000|0.000|0.000|0.000|1.000
152041x1x35xxxxxx0 | Půdorys 1.NP | m | 0.035 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/34.7776/100.0000/100.0000/2/34.7776/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/34.78/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 35 | DN100 | 100 | 100 | 0.000 | 0.035 m | PO.03.30501 | Nadzemní podlaží 1.NP | DN100 | vzduch | 6782Obj0798490152 | Kruhové potrubí | 152041x1x35xxxxxx0 | 0.020 m2
152041x1x491xxxxxx0 | Půdorys 1.NP | m | 0.491 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/491.1937/100.0000/100.0000/2/491.1937/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/491.19/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 491 | DN100 | 100 | 100 | 0.000 | 0.491 m | PO.03.30502 | Nadzemní podlaží 1.NP | DN100 | vzduch | 6782Obj0798490162 | Kruhové potrubí | 152041x1x491xxxxxx0 | 0.278 m2
152041x1x35xxxxxx0 | Půdorys 1.NP | m | 0.035 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/34.8514/100.0000/100.0000/2/34.8514/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/34.85/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 35 | DN100 | 100 | 100 | 0.000 | 0.035 m | PO.03.30503 | Nadzemní podlaží 1.NP | DN100 | vzduch | 6782Obj0798490172 | Kruhové potrubí | 152041x1x35xxxxxx0 | 0.020 m2
152042x2x209xxxxxx0 | Půdorys 1.NP | m | 0.209 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/209.0000/200.0000/200.0000/2/209.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/209.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | 209 | DN200 | 200 | 200 | 0.000 | 0.209 m | PO.03.30504 | Nadzemní podlaží 1.NP | DN200 | vzduch | 6782Obj0798490192 | Kruhové potrubí | 152042x2x209xxxxxx0 | 0.184 m2
152042x2x1781xxxxxx0 | Půdorys 1.NP | m | 1.781 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1000.0000/200.0000/200.0000/2/1000.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/1000.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1000 | DN200 | 200 | 200 | 0.000 | 1.000 m | PO.03.30505 | Nadzemní podlaží 1.NP | DN200 | vzduch | 6782Obj0798491137 | Kruhové potrubí | 152042x2x1781xxxxxx0 | 0.880 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 1780.700|100.000|100.000|0.000|-100.000|-100.000|0.000|0.000|0.000|1.000
152042x2x19xxxxxxx | Půdorys 1.NP | m | 0.19 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/190.4131/200.0000/200.0000/2/190.4131/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/190.41/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 190 | DN200 | 200 | 200 | 0.000 | 0.190 m | PO.03.30506 | Nadzemní podlaží 1.NP | DN200 | vzduch | 6782Obj0798491142 | Kruhové potrubí | 152042x2x19xxxxxxx | 0.167 m2
152042x2x64xxxxxx0 | Půdorys 1.NP | m | 0.064 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/64.2417/200.0000/200.0000/2/64.2417/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/64.24/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 64 | DN200 | 200 | 200 | 0.000 | 0.064 m | PO.03.30507 | Nadzemní podlaží 1.NP | DN200 | vzduch | 6782Obj0798491167 | Kruhové potrubí | 152042x2x64xxxxxx0 | 0.056 m2
152042x2x119xxxxxx0 | Půdorys 1.NP | m | 0.119 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/118.9066/200.0000/200.0000/2/118.9066/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/118.91/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 119 | DN200 | 200 | 200 | 0.000 | 0.119 m | PO.03.30508 | Nadzemní podlaží 1.NP | DN200 | vzduch | 6782Obj0798491182 | Kruhové potrubí | 152042x2x119xxxxxx0 | 0.105 m2
152042x2x64xxxxxx0 | Půdorys 1.NP | m | 0.064 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/64.2417/200.0000/200.0000/2/64.2417/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/64.24/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 64 | DN200 | 200 | 200 | 0.000 | 0.064 m | PO.03.30509 | Nadzemní podlaží 1.NP | DN200 | vzduch | 6782Obj0798491192 | Kruhové potrubí | 152042x2x64xxxxxx0 | 0.056 m2
15204250250405xxxxxx0 | Půdorys 1.NP | m | 0.405 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/405.0000/250.0000/250.0000/2/405.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/405.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 405 | DN250 | 250 | 250 | 0.000 | 0.405 m | PO.03.30510 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798491202 | Kruhové potrubí | 15204250250405xxxxxx0 | 0.420 m2
10104315160228xxxxxx0 | Půdorys 1.NP | m2 | 0.228 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/227.9000/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/227.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 228 | 315x160 | 315 | 160 | 0.000 | 1.000 m2 | PO.03.30511 | Nadzemní podlaží 1.NP | - | vzduch | 6782Obj0798491217 | Hranaté potrubí | 10104315160228xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.315 m; Výška: 0.16 m
1520416016021xxxxxx0 | Půdorys 1.NP | m | 0.021 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/20.9788/160.0000/160.0000/2/20.9788/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/20.98/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 21 | DN160 | 160 | 160 | 0.000 | 0.021 m | PO.03.30512 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798491222 | Kruhové potrubí | 1520416016021xxxxxx0 | 0.016 m2
15204160160279xxxxxx0 | Půdorys 1.NP | m | 0.279 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/279.1075/160.0000/160.0000/2/279.1075/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/279.11/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 279 | DN160 | 160 | 160 | 0.000 | 0.279 m | PO.03.30513 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798491232 | Kruhové potrubí | 15204160160279xxxxxx0 | 0.210 m2
1520416016021xxxxxx0 | Půdorys 1.NP | m | 0.021 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/21.0021/160.0000/160.0000/2/21.0021/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/21.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 21 | DN160 | 160 | 160 | 0.000 | 0.021 m | PO.03.30514 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798491242 | Kruhové potrubí | 1520416016021xxxxxx0 | 0.016 m2
15204160160726xxxxxx0 | Půdorys 1.NP | m | 0.726 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/200.0000/160.0000/160.0000/2/200.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/200.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200 | DN160 | 160 | 160 | 0.000 | 0.200 m | PO.03.30515 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798491247 | Kruhové potrubí | 15204160160726xxxxxx0 | 0.151 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 726.200|80.000|80.000|0.000|-80.000|-80.000|0.000|0.000|0.000|1.000
15204160160199xxxxxx0 | Půdorys 1.NP | m | 0.199 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/198.9524/160.0000/160.0000/2/198.9524/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/198.95/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// |  | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 199 | DN160 | 160 | 160 | 0.000 | 0.199 m | PO.03.30516 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798491252 | Kruhové potrubí | 15204160160199xxxxxx0
15204160160197xxxxxx0 | Půdorys 1.NP | m | 0.197 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/197.4142/160.0000/160.0000/2/197.4142/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/197.41/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// |  | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 197 | DN160 | 160 | 160 | 0.000 | 0.197 m | PO.03.30517 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798491262 | Kruhové potrubí | 15204160160197xxxxxx0
15204160160199xxxxxx0 | Půdorys 1.NP | m | 0.199 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/198.9375/160.0000/160.0000/2/198.9375/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/198.94/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// |  | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 199 | DN160 | 160 | 160 | 0.000 | 0.199 m | PO.03.30518 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798491272 | Kruhové potrubí | 15204160160199xxxxxx0
15205250250129xxxxxx0 | Půdorys 1.NP | m | 0.129 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/129.2837/250.0000/250.0000/2/129.2837/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/129.28/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 129 | DN250 | 250 | 250 | 0.000 | 0.129 m | PO.03.30519 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798491277 | Kruhové potrubí | 15205250250129xxxxxx0 | 0.134 m2
15205250250108xxxxxx0 | Půdorys 1.NP | m | 0.108 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/108.0406/250.0000/250.0000/2/108.0406/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/108.04/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 108 | DN250 | 250 | 250 | 0.000 | 0.108 m | PO.03.30520 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798491287 | Kruhové potrubí | 15205250250108xxxxxx0 | 0.112 m2
15205250250129xxxxxx0 | Půdorys 1.NP | m | 0.129 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/128.7888/250.0000/250.0000/2/128.7888/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/128.79/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 129 | DN250 | 250 | 250 | 0.000 | 0.129 m | PO.03.30521 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798491297 | Kruhové potrubí | 15205250250129xxxxxx0 | 0.134 m2
15204160160105xxxxxx0 | Půdorys 1.NP | m | 0.105 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/105.0382/160.0000/160.0000/2/105.0382/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/105.04/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 105 | DN160 | 160 | 160 | 0.000 | 0.105 m | PO.03.30522 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798491307 | Kruhové potrubí | 15204160160105xxxxxx0 | 0.079 m2
1520416016018xxxxxxx | Půdorys 1.NP | m | 0.18 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/180.2967/160.0000/160.0000/2/180.2967/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/180.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 180 | DN160 | 160 | 160 | 0.000 | 0.180 m | PO.03.30523 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798491317 | Kruhové potrubí | 1520416016018xxxxxxx | 0.136 m2
15204160160105xxxxxx0 | Půdorys 1.NP | m | 0.105 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/105.0204/160.0000/160.0000/2/105.0204/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/105.02/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 105 | DN160 | 160 | 160 | 0.000 | 0.105 m | PO.03.30524 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798491327 | Kruhové potrubí | 15204160160105xxxxxx0 | 0.079 m2
152042x2x391xxxxxx0 | Půdorys 1.NP | m | 0.391 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/391.0000/200.0000/200.0000/2/391.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/391.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 391 | DN200 | 200 | 200 | 0.000 | 0.391 m | PO.03.30525 | Nadzemní podlaží 1.NP | DN200 | vzduch | 6782Obj0798491432 | Kruhové potrubí | 152042x2x391xxxxxx0
152042x2x3xxxxxxx0 | Půdorys 1.NP | m | 0.3 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/300.0000/200.0000/200.0000/2/300.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/300.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 300 | DN200 | 200 | 200 | 0.000 | 0.300 m | PO.03.30526 | Nadzemní podlaží 1.NP | DN200 | vzduch | 6782Obj0798491437 | Kruhové potrubí | 152042x2x3xxxxxxx0
152042x2x94xxxxxx0 | Půdorys 1.NP | m | 0.094 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/94.0000/200.0000/200.0000/2/94.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/94.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | 94 | DN200 | 200 | 200 | 0.000 | 0.094 m | PO.03.30527 | Nadzemní podlaží 1.NP | DN200 | vzduch | 6782Obj0798491442 | Kruhové potrubí | 152042x2x94xxxxxx0
 | Půdorys 1.NP | m2 | 1.197 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/1196.8431/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/1196.84/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1197 | 315x160 | 315 | 160 | 0.000 | 1.140 m2 | PO.03.30528 | Nadzemní podlaží 1.NP | - | vzduch | 6782Obj0798491457 | Hranaté potrubí |  | 1.520 m2 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.315 m; Výška: 0.16 m
10104315160921xxxxxx0 | Půdorys 1.NP | m2 | 0.921 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/920.9000/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/920.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 921 | 315x160 | 315 | 160 | 0.000 | 0.870 m2 | PO.03.30529 | Nadzemní podlaží 1.NP | - | vzduch | 6782Obj0798491472 | Hranaté potrubí | 10104315160921xxxxxx0 | 1.170 m2 | NEMSOK - K_POSITION: L.6; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.315 m; Výška: 0.16 m
1520516016027xxxxxxx | Půdorys 1.NP | m | 0.27 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/230.0000/160.0000/160.0000/2/230.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/230.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | 230 | DN160 | 160 | 160 | 120.000 | 0.230 m | PO.03.30530 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798491479 | Kruhové potrubí | 1520516016027xxxxxxx | 0.173 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 270.000|80.000|80.000|0.000|-80.000|-80.000|0.000|0.000|0.000|1.000
1520625025015xxxxxxx | Půdorys 1.NP | m | 0.15 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/150.0000/250.0000/250.0000/2/150.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/150.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | 150 | DN250 | 250 | 250 | 0.000 | 0.150 m | PO.03.30531 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798491504 | Kruhové potrubí | 1520625025015xxxxxxx | 0.156 m2
252041x01x19xxxxxx | Půdorys 1.NP | m | 0 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/100.0000/100.0000/100.0000/2/100.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 100 | DN100 | 100 | 100 | 120.000 | 0.100 m | PO.03.30532 | Nadzemní podlaží 1.NP | DN100 | vzduch | 6782Obj0798492258 | Kruhové potrubí | 252041x01x19xxxxxx | 0.057 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 106.066|64.645|50.000|0.000|-50.000|-50.000|0.000|0.000|0.000|1.000
152041x1x186xxxxxx0 | Půdorys 1.NP | m | 0.186 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/185.9000/100.0000/100.0000/2/185.9000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/185.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | 186 | DN100 | 100 | 100 | 0.000 | 0.186 m | PO.03.30533 | Nadzemní podlaží 1.NP | DN100 | vzduch | 6782Obj0798492263 | Kruhové potrubí | 152041x1x186xxxxxx0 | 0.105 m2
15204250250205xxxxxx0 | Půdorys 1.NP | m | 0.205 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/205.0000/250.0000/250.0000/2/205.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/205.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | 205 | DN250 | 250 | 250 | 0.000 | 0.205 m | PO.03.30534 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798492323 | Kruhové potrubí | 15204250250205xxxxxx0 | 0.213 m2
152041x1x53xxxxxx0 | Půdorys 1.NP | m | 0.053 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/53.3673/100.0000/100.0000/2/53.3673/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/53.37/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 53 | DN100 | 100 | 100 | 0.000 | 0.053 m | PO.03.30535 | Nadzemní podlaží 1.NP | DN100 | vzduch | 6782Obj0798492343 | Kruhové potrubí | 152041x1x53xxxxxx0 | 0.030 m2
152041x1x2xxxxxxx | Půdorys 1.NP | m | 0.02 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/19.8386/100.0000/100.0000/2/19.8386/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/19.84/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 20 | DN100 | 100 | 100 | 0.000 | 0.020 m | PO.03.30536 | Nadzemní podlaží 1.NP | DN100 | vzduch | 6782Obj0798492363 | Kruhové potrubí | 152041x1x2xxxxxxx | 0.011 m2
152041x1x289xxxxxx0 | Půdorys 1.NP | m | 0.289 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/49.3000/100.0000/100.0000/2/49.3000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/49.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 49 | DN100 | 100 | 100 | 0.000 | 0.049 m | PO.03.30537 | Nadzemní podlaží 1.NP | DN100 | vzduch | 6782Obj0798492376 | Kruhové potrubí | 152041x1x289xxxxxx0 | 0.028 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 289.311|50.000|50.000|0.000|-50.000|-50.000|0.000|0.000|0.000|1.000
15204160160246xxxxxx0 | Půdorys 1.NP | m | 0.246 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/245.7071/160.0000/160.0000/2/245.7071/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/245.71/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | 246 | DN160 | 160 | 160 | 0.000 | 0.246 m | PO.03.30538 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798492384 | Kruhové potrubí | 15204160160246xxxxxx0 | 0.185 m2
15204160160204xxxxxx0 | Půdorys 1.NP | m | 0.204 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/203.8038/160.0000/160.0000/2/203.8038/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/203.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | 204 | DN160 | 160 | 160 | 0.000 | 0.204 m | PO.03.30539 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798492394 | Kruhové potrubí | 15204160160204xxxxxx0 | 0.154 m2
152042502506xxxxxxx | Půdorys 1.NP | m | 0.06 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/60.0000/250.0000/250.0000/2/60.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | 60 | DN250 | 250 | 250 | 0.000 | 0.060 m | PO.03.30540 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798492591 | Kruhové potrubí | 152042502506xxxxxxx
152042502506xxxxxxx | Půdorys 1.NP | m | 0.06 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/60.0000/250.0000/250.0000/2/60.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | 60 | DN250 | 250 | 250 | 0.000 | 0.060 m | PO.03.30541 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798492596 | Kruhové potrubí | 152042502506xxxxxxx
152042502506xxxxxxx | Půdorys 1.NP | m | 0.06 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/60.0000/250.0000/250.0000/2/60.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 60 | DN250 | 250 | 250 | 0.000 | 0.060 m | PO.03.30542 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798492606 | Kruhové potrubí | 152042502506xxxxxxx
1520416016081xxxxxx0 | Půdorys 1.NP | m | 0.081 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/80.6122/160.0000/160.0000/2/80.6122/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/80.61/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 81 | DN160 | 160 | 160 | 0.000 | 0.081 m | PO.03.30543 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798492617 | Kruhové potrubí | 1520416016081xxxxxx0
152041601604xxxxxx0 | Půdorys 1.NP | m | 0.004 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/4.2563/160.0000/160.0000/2/4.2563/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/4.26/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 4 | DN160 | 160 | 160 | 0.000 | 0.004 m | PO.03.30544 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798492627 | Kruhové potrubí | 152041601604xxxxxx0
1520416016081xxxxxx0 | Půdorys 1.NP | m | 0.081 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/80.6018/160.0000/160.0000/2/80.6018/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/80.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 81 | DN160 | 160 | 160 | 0.000 | 0.081 m | PO.03.30545 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798492637 | Kruhové potrubí | 1520416016081xxxxxx0
152042x2x219xxxxxx0 | Půdorys 1.NP | m | 0.219 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/218.7000/200.0000/200.0000/2/218.7000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/218.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 219 | DN200 | 200 | 200 | 0.000 | 0.219 m | PO.03.30546 | Nadzemní podlaží 1.NP | DN200 | vzduch | 6782Obj0798492642 | Kruhové potrubí | 152042x2x219xxxxxx0
152042x2x9xxxxxxx | Půdorys 1.NP | m | 0.09 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/90.0000/200.0000/200.0000/2/90.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 90 | DN200 | 200 | 200 | 0.000 | 0.090 m | PO.03.30547 | Nadzemní podlaží 1.NP | DN200 | vzduch | 6782Obj0798492652 | Kruhové potrubí | 152042x2x9xxxxxxx
152042x2x117xxxxxx0 | Půdorys 1.NP | m | 0.117 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/116.7025/200.0000/200.0000/2/116.7025/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/116.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 117 | DN200 | 200 | 200 | 0.000 | 0.117 m | PO.03.30548 | Nadzemní podlaží 1.NP | DN200 | vzduch | 6782Obj0798492662 | Kruhové potrubí | 152042x2x117xxxxxx0
152042x2x207xxxxxx0 | Půdorys 1.NP | m | 0.207 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/206.6143/200.0000/200.0000/2/206.6143/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/206.61/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 207 | DN200 | 200 | 200 | 0.000 | 0.207 m | PO.03.30549 | Nadzemní podlaží 1.NP | DN200 | vzduch | 6782Obj0798492677 | Kruhové potrubí | 152042x2x207xxxxxx0
152042x2x117xxxxxx0 | Půdorys 1.NP | m | 0.117 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/116.7000/200.0000/200.0000/2/116.7000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/116.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 117 | DN200 | 200 | 200 | 0.000 | 0.117 m | PO.03.30550 | Nadzemní podlaží 1.NP | DN200 | vzduch | 6782Obj0798492692 | Kruhové potrubí | 152042x2x117xxxxxx0
152042x2x117xxxxxx0 | Půdorys 1.NP | m | 0.117 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/116.7000/200.0000/200.0000/2/116.7000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/116.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 117 | DN200 | 200 | 200 | 0.000 | 0.117 m | PO.03.30551 | Nadzemní podlaží 1.NP | DN200 | vzduch | 6782Obj0798492697 | Kruhové potrubí | 152042x2x117xxxxxx0
15204160160324xxxxxx0 | Půdorys 1.NP | m | 0.324 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/324.1116/160.0000/160.0000/2/324.1116/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/324.11/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 324 | DN160 | 160 | 160 | 0.000 | 0.324 m | PO.03.30552 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798492702 | Kruhové potrubí | 15204160160324xxxxxx0
1520416016012xxxxxxx | Půdorys 1.NP | m | 0.12 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/119.7643/160.0000/160.0000/2/119.7643/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/119.76/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 120 | DN160 | 160 | 160 | 0.000 | 0.120 m | PO.03.30553 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798492712 | Kruhové potrubí | 1520416016012xxxxxxx
15204160160324xxxxxx0 | Půdorys 1.NP | m | 0.324 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/324.1263/160.0000/160.0000/2/324.1263/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/324.13/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 324 | DN160 | 160 | 160 | 0.000 | 0.324 m | PO.03.30554 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798492722 | Kruhové potrubí | 15204160160324xxxxxx0
1520416016047xxxxxx0 | Půdorys 1.NP | m | 0.047 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/47.3621/160.0000/160.0000/2/47.3621/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/47.36/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 47 | DN160 | 160 | 160 | 0.000 | 0.047 m | PO.03.30555 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798492727 | Kruhové potrubí | 1520416016047xxxxxx0
15204160160383xxxxxx0 | Půdorys 1.NP | m | 0.383 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/382.7925/160.0000/160.0000/2/382.7925/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/382.79/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 383 | DN160 | 160 | 160 | 0.000 | 0.383 m | PO.03.30556 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798492737 | Kruhové potrubí | 15204160160383xxxxxx0
1520416016047xxxxxx0 | Půdorys 1.NP | m | 0.047 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/47.3455/160.0000/160.0000/2/47.3455/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/47.35/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 47 | DN160 | 160 | 160 | 0.000 | 0.047 m | PO.03.30557 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798492747 | Kruhové potrubí | 1520416016047xxxxxx0
1520431531523xxxxxxx | Půdorys 1.NP | m | 0.23 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/230.0000/315.0000/315.0000/2/230.0000/0/0/0/0/0/315.0000/315.0000/315.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/230.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/70.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 230 | DN315 | 315 | 315 | 0.000 | 0.230 m | PO.03.30558 | Nadzemní podlaží 1.NP | DN315 | vzduch | 6782Obj0798492754 | Kruhové potrubí | 1520431531523xxxxxxx
1520431531523xxxxxxx | Půdorys 1.NP | m | 0.23 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/230.0000/315.0000/315.0000/2/230.0000/0/0/0/0/0/315.0000/315.0000/315.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/230.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/70.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 230 | DN315 | 315 | 315 | 0.000 | 0.230 m | PO.03.30559 | Nadzemní podlaží 1.NP | DN315 | vzduch | 6782Obj0798492755 | Kruhové potrubí | 1520431531523xxxxxxx
152052502503xxxxxxx0 | Půdorys 1.NP | m | 0.3 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/300.0000/250.0000/250.0000/2/300.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/300.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Alu kaschiert/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 300 | DN250 | 250 | 250 | 0.000 | 0.300 m | PO.03.30560 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798492756 | Kruhové potrubí | 152052502503xxxxxxx0 | 0.424 m2
15206250250102xxxxxx0 | Půdorys 1.NP | m | 0.102 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/101.5000/250.0000/250.0000/2/101.5000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/101.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Alu kaschiert/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 102 | DN250 | 250 | 250 | 0.000 | 0.102 m | PO.03.30561 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798492760 | Kruhové potrubí | 15206250250102xxxxxx0
15204250250439xxxxxx0 | Půdorys 1.NP | m | 0.439 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/220.0000/250.0000/250.0000/2/220.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/220.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Alu kaschiert/50.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | 220 | DN250 | 250 | 250 | 0.000 | 0.220 m | PO.03.30562 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798492762 | Kruhové potrubí | 15204250250439xxxxxx0 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 250.000|125.000|125.000|0.000|-125.000|-125.000|0.000|0.000|0.000|1.000
15204250250439xxxxxx0 | Půdorys 1.NP | m | 0.439 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/210.0000/250.0000/250.0000/2/210.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/210.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Alu kaschiert/50.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | 210 | DN250 | 250 | 250 | 0.000 | 0.210 m | PO.03.30563 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798492764 | Kruhové potrubí | 15204250250439xxxxxx0 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 439.000|125.000|125.000|0.000|-125.000|-125.000|0.000|0.000|0.000|1.000
152042x2x1xxxxxxx0 | Půdorys 1.NP | m | 0.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/210.0000/200.0000/200.0000/2/210.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/210.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 210 | DN200 | 200 | 200 | 0.000 | 0.210 m | PO.03.30564 | Nadzemní podlaží 1.NP | DN200 | vzduch | 6782Obj0798492766 | Kruhové potrubí | 152042x2x1xxxxxxx0 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 100.000|100.000|100.000|0.000|-100.000|-100.000|0.000|0.000|0.000|1.000
152041x1x7xxxxxxx0 | Půdorys 1.NP | m | 0.7 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/700.0000/100.0000/100.0000/2/700.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/700.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 700 | DN100 | 100 | 100 | 0.000 | 0.700 m | PO.03.30001 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798492523 | Objekt | 152041x1x7xxxxxxx0 | 0.019 m2
152041x1x256xxxxxxx | Půdorys 1.NP | m | 2.56 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/2560.0000/100.0000/100.0000/2/2560.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/2560.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 2560 | DN100 | 100 | 100 | 0.000 | 2.560 m | PO.03.30002 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798492528 | Objekt | 152041x1x256xxxxxxx | 0.019 m2
101044502x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 450x200 | 450 | 200 | 0.000 | 1.950 m2 | PO.03.30003 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798492543 | Objekt | 101044502x15xxxxxxx0 | 0.019 m2 | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.45 m; Výška: 0.2 m
101044502x57xxxxxx0 | Půdorys 1.NP | m2 | 0.057 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/56.5000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/56.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 57 | 450x200 | 450 | 200 | 0.000 | 1.000 m2 | PO.03.30004 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798492558 | Objekt | 101044502x57xxxxxx0 | 0.019 m2 | NEMSOK - K_POSITION: L.5; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.45 m; Výška: 0.2 m
101044502x793xxxxxx0 | Půdorys 1.NP | m2 | 0.793 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/793.0000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/793.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 793 | 450x200 | 450 | 200 | 0.000 | 1.030 m2 | PO.03.30005 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798492573 | Objekt | 101044502x793xxxxxx0 | 0.019 m2 | NEMSOK - K_POSITION: L.6; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.45 m; Výška: 0.2 m
152041x1x1767xxxxxx0 | Půdorys 1.NP | m | 1.767 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1767.4000/100.0000/100.0000/2/1767.4000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/1767.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1767 | DN100 | 100 | 100 | 0.000 | 1.767 m | PO.03.30006 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798492575 | Objekt | 152041x1x1767xxxxxx0 | 0.019 m2
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.03.30007 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798478841 | Objekt | 152041251253xxxxxxx | 0.019 m2
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.03.30008 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798478843 | Objekt | 152041251253xxxxxxx | 0.019 m2
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.03.30009 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798478845 | Objekt | 152041251253xxxxxxx | 0.019 m2
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.03.30010 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798478847 | Objekt | 152041251253xxxxxxx | 0.019 m2
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.03.30011 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798478849 | Objekt | 152041251253xxxxxxx | 0.019 m2
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/160.0000/160.0000/2/30.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN160 | 160 | 160 | 0.000 | 0.030 m | PO.03.30012 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798478851 | Objekt | 152041251253xxxxxxx | 0.023 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 30.000|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.03.30013 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798478855 | Objekt | 152041251253xxxxxxx | 0.019 m2
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.03.30014 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798478857 | Objekt | 152041251253xxxxxxx | 0.019 m2
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/200.0000/200.0000/2/30.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN200 | 200 | 200 | 0.000 | 0.030 m | PO.03.30015 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798478859 | Objekt | 152041251253xxxxxxx | 0.026 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 30.000|80.000|80.000|0.000|-80.000|-80.000|0.000|0.000|0.000|1.000
152041601605xxxxxxx | Půdorys 1.NP | m | 0.05 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/50.0000/160.0000/160.0000/2/50.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | 50 | DN160 | 160 | 160 | 120.000 | 0.050 m | PO.03.30016 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798478860 | Objekt | 152041601605xxxxxxx | 0.038 m2
152041x1x5xxxxxxx | Půdorys 1.NP | m | 0.05 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/50.0000/100.0000/100.0000/2/50.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | 50 | DN100 | 100 | 100 | 120.000 | 0.050 m | PO.03.30017 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798478864 | Objekt | 152041x1x5xxxxxxx | 0.028 m2
152041x1x5xxxxxxx | Půdorys 1.NP | m | 0.05 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/50.0000/100.0000/100.0000/2/50.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | 50 | DN100 | 100 | 100 | 120.000 | 0.050 m | PO.03.30018 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798478871 | Objekt | 152041x1x5xxxxxxx | 0.028 m2
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.03.30019 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798478877 | Objekt | 152041251253xxxxxxx | 0.019 m2
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/200.0000/200.0000/2/30.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN200 | 200 | 200 | 0.000 | 0.030 m | PO.03.30020 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798478879 | Objekt | 152041251253xxxxxxx | 0.026 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 30.000|80.000|80.000|0.000|-80.000|-80.000|0.000|0.000|0.000|1.000
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/200.0000/200.0000/2/30.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN200 | 200 | 200 | 0.000 | 0.030 m | PO.03.30021 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798478881 | Objekt | 152041251253xxxxxxx | 0.026 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 30.000|80.000|80.000|0.000|-80.000|-80.000|0.000|0.000|0.000|1.000
152041x1x5xxxxxxx | Půdorys 1.NP | m | 0.05 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/50.0000/100.0000/100.0000/2/50.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | 50 | DN100 | 100 | 100 | 120.000 | 0.050 m | PO.03.30022 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798478883 | Objekt | 152041x1x5xxxxxxx | 0.028 m2
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/160.0000/160.0000/2/30.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN160 | 160 | 160 | 0.000 | 0.030 m | PO.03.30023 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798479173 | Objekt | 152041251253xxxxxxx | 0.023 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 30.000|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
101042x2x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/200.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 200x200 | 200 | 200 | 0.000 | 1.200 m2 | PO.03.30024 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798479182 | Objekt | 101042x2x15xxxxxxx0 | 1.680 m2 | NEMSOK - K_POSITION: L.38; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.2 m; Výška: 0.2 m
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/200.0000/200.0000/2/30.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN200 | 200 | 200 | 0.000 | 0.030 m | PO.03.30025 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798479191 | Objekt | 152041251253xxxxxxx | 0.026 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 30.000|80.000|80.000|0.000|-80.000|-80.000|0.000|0.000|0.000|1.000
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/200.0000/200.0000/2/30.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN200 | 200 | 200 | 0.000 | 0.030 m | PO.03.30026 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798479193 | Objekt | 152041251253xxxxxxx | 0.026 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 30.000|80.000|80.000|0.000|-80.000|-80.000|0.000|0.000|0.000|1.000
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/200.0000/200.0000/2/30.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN200 | 200 | 200 | 0.000 | 0.030 m | PO.03.30027 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798479195 | Objekt | 152041251253xxxxxxx | 0.026 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 30.000|80.000|80.000|0.000|-80.000|-80.000|0.000|0.000|0.000|1.000
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.03.30028 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798479197 | Objekt | 152041251253xxxxxxx | 0.019 m2
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.03.30029 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798479258 | Objekt | 152041251253xxxxxxx | 0.019 m2
101042802x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/280.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/280.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 280x200 | 280 | 200 | 0.000 | 1.440 m2 | PO.03.30030 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798479272 | Objekt | 101042802x15xxxxxxx0 | 1.920 m2 | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.28 m; Výška: 0.2 m
101042802x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/280.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/280.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 280x200 | 280 | 200 | 0.000 | 1.440 m2 | PO.03.30031 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798479273 | Objekt | 101042802x15xxxxxxx0 | 1.920 m2 | NEMSOK - K_POSITION: L.5; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.28 m; Výška: 0.2 m
152041x1x5xxxxxxx | Půdorys 1.NP | m | 0.05 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/50.0000/100.0000/100.0000/2/50.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | 50 | DN100 | 100 | 100 | 120.000 | 0.050 m | PO.03.30032 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798479284 | Objekt | 152041x1x5xxxxxxx | 0.028 m2
