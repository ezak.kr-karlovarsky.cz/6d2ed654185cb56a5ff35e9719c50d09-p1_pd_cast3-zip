Properties of the parts of a building model (IFC2X3), part 10 of 51

# IfcFlowFitting (2887)
Name | In | Jednotka | Délka (m) | Označení | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_DIM | L_BES_DIM_A2 | L_BES_DIM_B2 | L_BES_DIM_A | K_VOLSTROM | K_MLH_GOST = K_MLD_GOST | K_LISTVALUE | Kód prvku | Třída reakce na oheň | Allright_Stavebni_dil_ID | Název_objektu | K_EBT_BOX_WC | Plocha | L_BES_LAENGE | K_INTERNAL_ISO | Tloušťka (m) | Součinitel tepelné vodivost
10104160160579xxxxxx0 | Půdorys 1.PP | Kus | 0 | 10104160160579xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/1/212.6346/88.0761/0/45.0/0/180.0/1.0000/160.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/160.00/100.00/45.00/180.00/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30079 | A1 | 6774Obj0000042293 | Objekt | 283.345/158.787/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
2010416016x50501601x4516xxxx | Půdorys 1.PP | Kus | 0.767 | 2010416016x50501601x4516xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/766.8605/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/766.86/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30080 | A1 | 6774Obj0000042307 | Objekt | 766.861/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 767 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
10104160160767xxxxxx0 | Půdorys 1.PP | Kus | 0.474 | 10104160160767xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/474.0000/160.0000/160.0000/2/474.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/474.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.474 m | IT.02.30081 | A1 | 6774Obj0000042310 | Objekt | 474.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.474 | 474 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.357 m2
15204160160474xxxxxx0 | Půdorys 1.PP | Kus | 0.271 | 15204160160474xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/271.1958/125.0000/125.0000/2/271.1958/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/271.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.271 m | IT.02.30082 | A1 | 6774Obj0000042313 | Objekt | 271.196/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.271 | 271 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.175 m2
51216125160505012516x14218171125 | Půdorys 1.PP | Kus | 0.142 | 51216125160505012516x14218171125 | UEBERGANG ECK/RU AS | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/125.0000/125.0000/2/142.4000/-0.0388/-7.0000/0/0/0/0/160.0000/160.0000/1/ | 51/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/125.00/160.00/50.00/50.00/125.00/160.00/0/142.40/17.54/17.46/10.50/24.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 160 | 160 | 125 | 0.000 | 0 | 1.000 m2 | IT.02.30083 | A1 | 6774Obj0000042435 | Objekt | 142.400/79.961/73.000/0.000/-80.039/-87.000/0.000/0.000/0.000/1.000 | 1 | 142 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.12; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); K_LISTVALUE_ISO: 1.000 m2
51216125160505012516x14218171125 | Půdorys 1.PP | Kus | 0.142 | 51216125160505012516x14218171125 | UEBERGANG ECK/RU AS | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/125.0000/125.0000/2/142.4000/0.0388/-7.0000/0/0/0/0/160.0000/160.0000/1/ | 51/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/125.00/160.00/50.00/50.00/125.00/160.00/0/142.40/17.46/17.54/10.50/24.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 160 | 160 | 125 | 0.000 | 0 | 1.000 m2 | IT.02.30084 | A1 | 6774Obj0000042457 | Objekt | 142.400/80.039/73.000/0.000/-79.961/-87.000/0.000/0.000/0.000/1.000 | 1 | 142 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); K_LISTVALUE_ISO: 1.000 m2
51216125160505012516x14217181125 | Půdorys 1.PP | Kus | 0.5 | 51216125160505012516x14217181125 | T-STCK. GERADE | 20 | 1016 | 3/0/0/0/180.0/0/0/200.0000/200.0000/160.0000/1/230.0000/-250.0000/0/270.0/0/0/310.0000/160.0000/160.0000/1/230.0000/250.0000/0/90.0/0/0/160.0000/160.0000/160.0000/1/ | 70/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/200.00/200.00/50.00/50.00/50.00/50.00/160.00/0/0/0/500.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x160 | 160 | 160 | 200 | 0.000 | 0 | 1.000 m2 | IT.02.30085 | A1 | 6774Obj0000042513 | Objekt | 330.000/250.000/100.000/0.000/-250.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.9; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
101052x16071xxxxxxx | Půdorys 1.PP | Kus | 0.303 | 101052x16071xxxxxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/200.0000/160.0000/1/302.6000/0/0/0/0/0/1.0000/200.0000/160.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/160.00/302.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x160 | 200 | 160 | 200 | 0.000 | 0 | 1.000 m2 | IT.02.30086 | A1 | 6774Obj0000042665 | Objekt | 302.600/120.000/100.000/0.000/-120.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 303 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.10; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
1520412512541xxxxxx0 | Půdorys 1.PP | Kus | 0.86 | 1520412512541xxxxxx0 | T-STCK. GERADE | 20 | 1016 | 3/0/0/0/180.0/0/180.0/315.0000/315.0000/160.0000/1/860.0000/0/0/0/0/180.0/1.0000/315.0000/160.0000/1/430.0000/307.5000/0/90.0/0/180.0/560.0000/560.0000/160.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/560.00/560.00/50.00/50.00/50.00/50.00/160.00/0/0/180.00/860.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.030 m2 | IT.02.30087 | A1 | 6774Obj0000042956 | Objekt | 860.000/307.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1.03 | 860 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.31; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.360 m2
701043153155605605050505016x086x | Půdorys 1.PP | Kus | 0 | 701043153155605605050505016x086x | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/270.0/560.0000/560.0000/160.0000/1/230.0000/230.0000/0/90.0/0/270.0/260.0000/560.0000/160.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/560.00/100.00/90.00/270.00/0/560.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 560 | 160 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30088 | A1 | 6774Obj0000043038 | Objekt | 330.000/230.000/300.000/0.000/-100.000/-300.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.5; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.010 m2
2010516016x50505601x9056xxxx | Půdorys 1.PP | Kus | 0.574 | 2010516016x50505601x9056xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/160.0000/1/574.3000/0/0/0/0/0/1.0000/560.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/160.00/574.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 560 | 160 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30089 | A1 | 6774Obj0000043052 | Objekt | 574.300/300.000/100.000/0.000/-300.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 574 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.7; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.010 m2
10104315160132xxxxxxx | Půdorys 1.PP | Kus | 0 | 10104315160132xxxxxxx | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/315.0000/315.0000/160.0000/1/307.5000/307.5000/0/90.0/0/0/1.0000/315.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/0/50.00/50.00/160.00/100.00/90.00/0/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.02.30090 | A1 | 6774Obj0000043148 | Objekt | 485.000/307.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.22; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.030 m2
10106315160195xxxxxx0 | Půdorys 1.PP | Kus | 0.226 | 10106315160195xxxxxx0 | UEBERGANG ASYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/160.0000/1/226.1000/0/77.5000/0/0/0/0/450.0000/315.0000/1/ | 41/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/450.00/50.00/50.00/160.00/315.00/0/226.10/-55.00/-55.00/155.00/0/51.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 450 | 315 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30091 | A1 | 6774Obj0000043184 | Objekt | 226.100/300.000/255.000/0.000/-300.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 226 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.5; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
4110456045050501603150226-55-551 | Půdorys 1.PP | Kus | 1.016 | 4110456045050501603150226-55-551 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/1015.6000/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/1015.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 0.960 m2 | IT.02.30092 | A1 | 6774Obj0000043198 | Objekt | 1015.600/177.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 0.96 | 1016 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.290 m2
 | Půdorys 1.PP | Kus | 0 |  | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/270.0/315.0000/315.0000/160.0000/1/230.0000/230.0000/0/90.0/0/270.0/1.0000/315.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/315.00/100.00/90.00/270.00/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.02.30093 | A1 | 6774Obj0000043280 | Objekt | 330.000/230.000/177.500/0.000/-100.000/-177.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
2010416016x50503151x90315xxx0 | Půdorys 1.PP | Kus | 0 | 2010416016x50503151x90315xxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/270.0/315.0000/315.0000/160.0000/1/230.0000/230.0000/0/90.0/0/270.0/1.0000/315.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/315.00/100.00/90.00/270.00/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.02.30094 | A1 | 6774Obj0000043362 | Objekt | 330.000/230.000/177.500/0.000/-100.000/-177.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
2010416016x50503151x90315xxx0 | Půdorys 1.PP | Kus | 0.9 | 2010416016x50503151x90315xxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/900.0000/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/900.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.02.30095 | A1 | 6774Obj0000043376 | Objekt | 900.000/177.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1 | 900 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.140 m2
101043151609xxxxxxx0 | Půdorys 1.PP | Kus | 0.115 | 101043151609xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/114.6774/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/114.68/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.02.30096 | A1 | 6774Obj0000043390 | Objekt | 114.677/177.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1 | 115 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
10104315160115xxxxxx0 | Půdorys 1.PP | Kus | 0 | 10104315160115xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/90.0/315.0000/315.0000/160.0000/1/212.6346/88.0761/0/45.0/0/90.0/1.0000/315.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/315.00/100.00/45.00/90.00/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.02.30097 | A1 | 6774Obj0000043472 | Objekt | 283.345/158.787/177.500/0.000/-100.000/-177.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
2010416016x50503151x45315xxx0 | Půdorys 1.PP | Kus | 0.393 | 2010416016x50503151x45315xxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/392.8282/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/392.83/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.02.30098 | A1 | 6774Obj0000043486 | Objekt | 392.828/177.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1 | 393 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
10104315160393xxxxxx0 | Půdorys 1.PP | Kus | 0 | 10104315160393xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/90.0/315.0000/315.0000/160.0000/1/212.6346/88.0761/0/45.0/0/90.0/1.0000/315.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/315.00/100.00/45.00/90.00/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.02.30099 | A1 | 6774Obj0000043568 | Objekt | 283.345/158.787/177.500/0.000/-100.000/-177.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
2010416016x50503151x45315xxx0 | Půdorys 1.PP | Kus | 0.115 | 2010416016x50503151x45315xxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/114.5280/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/114.53/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.02.30100 | A1 | 6774Obj0000043582 | Objekt | 114.528/177.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1 | 115 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
macro | Půdorys 1.PP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/-1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.02.30101 | A1 | 6774Obj0000043596 | Objekt | 13160.735/2826.711/-417.500/12850.735/2701.711/-542.500/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2022/11/04; N_FREI_68: SPIRO POTRUBÍ
 | Půdorys 1.PP | Kus | 0.46 |  | T-STCK. GERADE | 20 | 1016 | 3/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/1/460.0000/0/0/0/0/0/1.0000/160.0000/160.0000/1/230.0000/230.0000/0/90.0/0/0/160.0000/160.0000/160.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/160.00/160.00/50.00/50.00/50.00/50.00/160.00/0/0/0/460.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30102 | A1 | 6774Obj0000043652 | Objekt | 460.000/230.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 460 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.34; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
701041601601601605050505016x046x | Půdorys 1.PP | Kus | 0.165 | 701041601601601605050505016x046x | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/165.3000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/35.00/100.00/160.00/125.00/125.00/165.30/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 125 | 125 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30103 | A1 | 6774Obj0000043674 | Objekt | 165.300/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 165 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.35; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
50105160125351x160125125165-18-1 | Půdorys 1.PP | Kus | 0.106 | 50105160125351x160125125165-18-1 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/106.4571/125.0000/125.0000/2/106.4571/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/106.46/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.106 m | IT.02.30104 | A1 | 6774Obj0000043677 | Objekt | 106.457/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.106 | 106 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.069 m2
15204125125106xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15204125125106xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30105 | A1 | 6774Obj0000043680 | Objekt | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012519xxxxxx | Půdorys 1.PP | Kus | 0.46 | 252x125012519xxxxxx | T-STCK. SCHRÄG | 20 | 1016 | 3/0/0/0/180.0/0/0/200.0000/200.0000/160.0000/1/460.0000/-25.0000/0/0/0/0/1.0000/250.0000/160.0000/1/230.0000/250.0000/0/90.0/0/0/160.0000/160.0000/160.0000/1/ | 71/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/250.00/160.00/160.00/50.00/50.00/50.00/50.00/160.00/0/0/0/460.00/-50.00/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x160 | 250 | 160 | 200 | 0.000 | 0 | 1.000 m2 | IT.02.30106 | A1 | 6774Obj0000043736 | Objekt | 460.000/250.000/100.000/0.000/-170.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 460 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.6; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
711042x2501601605050505016x0460- | Půdorys 1.PP | Kus | 0.165 | 711042x2501601605050505016x0460- | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/1/165.3000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/35.00/100.00/160.00/125.00/125.00/165.30/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 125 | 125 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30107 | A1 | 6774Obj0000043758 | Objekt | 165.300/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 165 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
macro | Půdorys 1.PP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.02.30108 | A1 | 6774Obj0000043772 | Objekt | 16981.035/2848.611/-417.500/16671.035/2723.611/-542.500/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2022/11/04; N_FREI_68: SPIRO POTRUBÍ
 | Půdorys 1.PP | Kus | 0.42 |  | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/200.0000/160.0000/1/419.5682/0/0/0/0/0/1.0000/200.0000/160.0000/1/ | 10/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/160.00/419.57/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x160 | 200 | 160 | 200 | 0.000 | 0 | 1.000 m2 | IT.02.30109 | A1 | 6774Obj0000043786 | Objekt | 419.568/120.000/100.000/0.000/-120.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 420 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
101062x16042xxxxxxx | Půdorys 1.PP | Kus | 0.023 | 101062x16042xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/22.9178/125.0000/125.0000/2/22.9178/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/22.92/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.023 m | IT.02.30110 | A1 | 6774Obj0000043789 | Objekt | 22.918/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.023 | 23 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.015 m2
1520512512523xxxxxx0 | Půdorys 1.PP | Kus | 0.46 | 1520512512523xxxxxx0 | T-STCK. SCHRÄG | 20 | 1016 | 3/0/0/0/180.0/0/180.0/200.0000/200.0000/160.0000/1/460.0000/20.0000/0/0/0/180.0/1.0000/160.0000/160.0000/1/230.0000/250.0000/0/90.0/0/180.0/160.0000/160.0000/160.0000/1/ | 71/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/160.00/160.00/160.00/50.00/50.00/50.00/50.00/160.00/0/0/180.00/460.00/40.00/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x160 | 160 | 160 | 200 | 0.000 | 0 | 1.000 m2 | IT.02.30111 | A1 | 6774Obj0000043845 | Objekt | 460.000/250.000/100.000/0.000/-120.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 460 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.8; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
711042x1601601605050505016x04604 | Půdorys 1.PP | Kus | 1.5 | 711042x1601601605050505016x04604 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/200.0000/160.0000/1/1500.0000/0/0/0/0/0/1.0000/200.0000/160.0000/1/ | 10/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/160.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x160 | 200 | 160 | 200 | 0.000 | 0 | 1.080 m2 | IT.02.30112 | A1 | 6774Obj0000043859 | Objekt | 1500.000/120.000/100.000/0.000/-120.000/-100.000/0.000/0.000/0.000/1.000 | 1.08 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.560 m2
101062x16015xxxxxxx0 | Půdorys 1.PP | Kus | 0.196 | 101062x16015xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/196.0864/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/196.09/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30113 | A1 | 6774Obj0000043873 | Objekt | 196.086/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 196 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
10104160160196xxxxxx0 | Půdorys 1.PP | Kus | 0.46 | 10104160160196xxxxxx0 | T-STCK. GERADE | 20 | 1016 | 3/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/1/460.0000/0/0/0/0/0/1.0000/160.0000/160.0000/1/230.0000/230.0000/0/90.0/0/0/160.0000/160.0000/160.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/160.00/160.00/50.00/50.00/50.00/50.00/160.00/0/0/0/460.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30114 | A1 | 6774Obj0000043929 | Objekt | 460.000/230.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 460 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.5; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
701041601601601605050505016x046x | Půdorys 1.PP | Kus | 0.135 | 701041601601601605050505016x046x | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/135.0000/0/0/0/0/0/0/160.0000/120.0000/1/ | 50/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/160.00/160.00/35.00/100.00/160.00/120.00/160.00/135.00/0/0/-20.00/-20.00/53.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 120 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30115 | A1 | 6774Obj0000043951 | Objekt | 135.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 135 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.23; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); K_LISTVALUE_ISO: 1.000 m2
50216160160351x160120160135x-20- | Půdorys 1.PP | Kus | 0.165 | 50216160160351x160120160135x-20- | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/1/165.3000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/35.00/100.00/160.00/125.00/125.00/165.30/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 125 | 125 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30116 | A1 | 6774Obj0000043973 | Objekt | 165.300/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 165 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.6; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
50105160125351x160125125165-18-1 | Půdorys 1.PP | Kus | 0.063 | 50105160125351x160125125165-18-1 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/62.5000/125.0000/125.0000/2/62.5000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/62.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.063 m | IT.02.30117 | A1 | 6774Obj0000043976 | Objekt | 62.500/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.063 | 63 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.040 m2
1520512512563xxxxxx0 | Půdorys 1.PP | Kus | 0 | 1520512512563xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30118 | A1 | 6774Obj0000043979 | Objekt | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012519xxxxxx | Půdorys 1.PP | Kus | 0.105 | 252x125012519xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/104.6143/125.0000/125.0000/2/104.6143/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/104.61/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.105 m | IT.02.30119 | A1 | 6774Obj0000043982 | Objekt | 104.614/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.105 | 105 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.067 m2
15205125125105xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15205125125105xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/269.6/125.0000/125.0000/125.0000/2/30.0285/3.6604/0/13.9/0/269.6/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/269.60/0/125.00/1.00/13.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30120 | A1 | 6774Obj0000043985 | Objekt | 45.043/64.330/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125114xxxxx0 | Půdorys 1.PP | Kus | 0 | 252x1250125114xxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/89.6/125.0000/125.0000/125.0000/2/30.0285/3.6604/0/13.9/0/89.6/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/89.60/0/125.00/1.00/13.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30121 | A1 | 6774Obj0000043988 | Objekt | 45.043/64.330/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125114xxxxx0 | Půdorys 1.PP | Kus | 0.103 | 252x1250125114xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/103.3368/125.0000/125.0000/2/103.3368/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/103.34/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.103 m | IT.02.30122 | A1 | 6774Obj0000043991 | Objekt | 103.337/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.103 | 103 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.067 m2
15205125125103xxxxxx0 | Půdorys 1.PP | Kus | 0.035 | 15205125125103xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/34.9000/125.0000/125.0000/2/34.9000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/34.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.035 m | IT.02.30123 | A1 | 6774Obj0000043994 | Objekt | 34.900/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.035 | 35 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.022 m2
macro | Půdorys 1.PP | Kus | 0.26 | macro | ABL Regler konst. EN mit Antrieb | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/260.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.02.30124 | A1 | 6774Obj0000044008 | Objekt | 9123.138/3137.779/-410.500/8863.138/3012.779/-535.500/0.000/0.000/0.000/1.000 | 1 | 260 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/13; N_FREI_68: SPIRO POTRUBÍ
 | Půdorys 1.PP | Kus | 0 |  | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30125 | A1 | 6774Obj0000044011 | Objekt | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012519xxxxxx | Půdorys 1.PP | Kus | 1.5 | 252x125012519xxxxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/250.0000/160.0000/1/1500.0000/0/0/0/0/0/1.0000/250.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/160.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x160 | 250 | 160 | 250 | 0.000 | 0 | 1.230 m2 | IT.02.30126 | A1 | 6774Obj0000044025 | Objekt | 1500.000/145.000/100.000/0.000/-145.000/-100.000/0.000/0.000/0.000/1.000 | 1.23 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.11; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.710 m2
1010425016015xxxxxxx0 | Půdorys 1.PP | Kus | 0.46 | 1010425016015xxxxxxx0 | T-STCK. GERADE | 20 | 1016 | 3/0/0/0/180.0/0/0/250.0000/250.0000/160.0000/1/460.0000/0/0/0/0/0/1.0000/250.0000/160.0000/1/230.0000/275.0000/0/90.0/0/0/160.0000/160.0000/160.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/160.00/160.00/50.00/50.00/50.00/50.00/160.00/0/0/0/460.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x160 | 250 | 160 | 250 | 0.000 | 0 | 1.000 m2 | IT.02.30127 | A1 | 6774Obj0000044081 | Objekt | 460.000/275.000/100.000/0.000/-145.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 460 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
701042502501601605050505016x046x | Půdorys 1.PP | Kus | 0.14 | 701042502501601605050505016x046x | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/250.0000/160.0000/1/140.0000/0/0/0/0/0/1.0000/250.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/160.00/140.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x160 | 250 | 160 | 250 | 0.000 | 0 | 1.000 m2 | IT.02.30128 | A1 | 6774Obj0000044095 | Objekt | 140.000/145.000/100.000/0.000/-145.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 140 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
1010425016014xxxxxxx | Půdorys 1.PP | Kus | 0.165 | 1010425016014xxxxxxx | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/1/165.3000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/35.00/100.00/160.00/125.00/160.00/165.30/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 125 | 125 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30129 | A1 | 6774Obj0000044117 | Objekt | 165.300/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 165 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
50105160125351x160125160165-18-1 | Půdorys 1.PP | Kus | 0.54 | 50105160125351x160125160165-18-1 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/250.0000/160.0000/1/539.6717/0/0/0/0/0/1.0000/250.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/160.00/539.67/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x160 | 250 | 160 | 250 | 0.000 | 0 | 1.000 m2 | IT.02.30130 | A1 | 6774Obj0000044131 | Objekt | 539.672/145.000/100.000/0.000/-145.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 540 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
macro | Půdorys 1.PP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.02.30131 | A1 | 6774Obj0000044145 | Objekt | 20581.035/2933.611/-417.500/20271.035/2808.611/-542.500/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2022/11/04; N_FREI_68: SPIRO POTRUBÍ
 | Půdorys 1.PP | Kus | 0.061 |  | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/60.9364/125.0000/125.0000/2/60.9364/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/60.94/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.061 m | IT.02.30132 | A1 | 6774Obj0000044148 | Objekt | 60.936/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.061 | 61 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.039 m2
1520512512561xxxxxx0 | Půdorys 1.PP | Kus | 1.103 | 1520512512561xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1102.5000/125.0000/125.0000/2/1102.5000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/1102.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.103 m | IT.02.30133 | A1 | 6774Obj0000044151 | Objekt | 1102.500/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1.103 | 1103 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.710 m2
 | Půdorys 1.PP | Kus | 0 |  | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30134 | A1 | 6774Obj0000044154 | Objekt | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
macro | Půdorys 1.PP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.02.30135 | A1 | 6774Obj0000044168 | Objekt | 5164.365/2897.471/-417.500/5039.365/2587.471/-542.500/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2022/11/03; N_FREI_68: SPIRO POTRUBÍ
 | Půdorys 1.PP | Kus | 0.215 |  | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/215.0000/0/0/0/0/180.0/1.0000/160.0000/160.0000/2/107.5000/125.0000/0/90.0/0/180.0/125.0000/125.0000/125.0000/2/ | 75/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/125.00/0/180.00/215.00/0/125.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.02.30136 | A1 | 6774Obj0000044172 | Objekt | 215.000/125.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 215 | __ISO | 0.04 | 0,041 W/m.K
752051601601250215012509xxxx | Půdorys 1.PP | Kus | 0.078 | 752051601601250215012509xxxx | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/78.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 30/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/0/0/160.00/125.00/0/78.00/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 125 | 125 | 160 | 0.000 | 0 | 1.0 | IT.02.30137 | A1 | 6774Obj0000044175 | Objekt | 78.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 78 | __ISO | 0.04 | 0,041 W/m.K
30205160125x160125078-18-18-18-1 | Půdorys 1.PP | Kus | 0.113 | 30205160125x160125078-18-18-18-1 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/112.5000/125.0000/125.0000/2/112.5000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/112.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.113 m | IT.02.30138 | A1 | 6774Obj0000044178 | Objekt | 112.500/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.113 | 113 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.072 m2
15206125125113xxxxxx0 | Půdorys 1.PP | Kus | 0.619 | 15206125125113xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/618.9000/125.0000/125.0000/2/618.9000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/618.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.619 m | IT.02.30139 | A1 | 6774Obj0000044181 | Objekt | 618.900/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.619 | 619 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.399 m2
15206125125619xxxxxx0 | Půdorys 1.PP | Kus | 0.029 | 15206125125619xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/28.7641/125.0000/125.0000/2/28.7641/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/28.76/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.029 m | IT.02.30140 | A1 | 6774Obj0000044184 | Objekt | 28.764/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.029 | 29 | __ISO | 0.04 | 0,041 W/m.K
1520612512529xxxxxx0 | Půdorys 1.PP | Kus | 0.085 | 1520612512529xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/85.4000/125.0000/125.0000/2/85.4000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/85.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.085 m | IT.02.30141 | A1 | 6774Obj0000044187 | Objekt | 85.400/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.085 | 85 | __ISO | 0.04 | 0,041 W/m.K
1520512512585xxxxxx0 | Půdorys 1.PP | Kus | 1.581 | 1520512512585xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1580.8739/160.0000/160.0000/2/1580.8739/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/1580.87/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.581 m | IT.02.30142 | A1 | 6774Obj0000044190 | Objekt | 1580.874/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1.581 | 1581 | __ISO | 0.04 | 0,041 W/m.K
 | Půdorys 1.PP | Kus | 0 |  | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/18.1125/1.0285/0/6.5/0/180.0/160.0000/160.0000/160.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/180.00/0/160.00/1.00/6.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.02.30143 | A1 | 6774Obj0000044193 | Objekt | 27.169/80.514/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16017xxxxx0 | Půdorys 1.PP | Kus | 0.538 | 252x16x16017xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/538.3508/160.0000/160.0000/2/538.3508/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/538.35/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.538 m | IT.02.30144 | A1 | 6774Obj0000044196 | Objekt | 538.351/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.538 | 538 | __ISO | 0.04 | 0,041 W/m.K
15206160160538xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15206160160538xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/18.1125/1.0285/0/6.5/0/0/160.0000/160.0000/160.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/0/0/160.00/1.00/6.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.02.30145 | A1 | 6774Obj0000044199 | Objekt | 27.169/80.514/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16017xxxxx0 | Půdorys 1.PP | Kus | 1.584 | 252x16x16017xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1584.2376/160.0000/160.0000/2/1584.2376/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/1584.24/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.584 m | IT.02.30146 | A1 | 6774Obj0000044202 | Konstrukce v aktuální hladině | 1584.238/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1.584 | 1584 | __ISO | 0.04 | 0,041 W/m.K
 | Půdorys 1.PP | Kus | 1.5 |  | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/1500.0000/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 0.960 m2 | IT.02.30147 | A1 | 6774Obj0000044216 | Objekt | 1500.000/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.96 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160
1010416016015xxxxxxx0 | Půdorys 1.PP | Kus | 0.089 | 1010416016015xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/88.8878/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/88.89/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30148 | A1 | 6774Obj0000044230 | Objekt | 88.888/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 89 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160
1010416016089xxxxxx0 | Půdorys 1.PP | Kus | 0 | 1010416016089xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/1/183.3013/49.1154/0/30.0/0/180.0/1.0000/160.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/160.00/100.00/30.00/180.00/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30149 | A1 | 6774Obj0000044312 | Objekt | 233.301/135.718/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160
2010416016x50501601x3016xxxx | Půdorys 1.PP | Kus | 0.052 | 2010416016x50501601x3016xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/51.8587/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/51.86/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30150 | A1 | 6774Obj0000044326 | Objekt | 51.859/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 52 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160
1010416016052xxxxxx0 | Půdorys 1.PP | Kus | 0 | 1010416016052xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/1/183.3013/49.1154/0/30.0/0/0/1.0000/160.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/160.00/100.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30151 | A1 | 6774Obj0000044408 | Objekt | 233.301/135.718/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160
2010416016x50501601x3016xxxx | Půdorys 1.PP | Kus | 1.5 | 2010416016x50501601x3016xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/1500.0000/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 0.960 m2 | IT.02.30152 | A1 | 6774Obj0000044422 | Objekt | 1500.000/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.96 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160
1010416016015xxxxxxx0 | Půdorys 1.PP | Kus | 0.089 | 1010416016015xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/88.9558/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/88.96/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30153 | A1 | 6774Obj0000044436 | Objekt | 88.956/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 89 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160
1010416016089xxxxxx0 | Půdorys 1.PP | Kus | 0.136 | 1010416016089xxxxxx0 | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/125.0000/125.0000/2/135.7689/-0.0039/3.1512/0/0/0/0/160.0000/160.0000/1/ | 50/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/125.00/160.00/50.00/50.00/125.00/160.00/0/135.77/17.50/17.50/20.65/14.35/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 160 | 160 | 125 | 0.000 | 0 | 1.000 m2 | IT.02.30154 | A1 | 6774Obj0000044458 | Objekt | 135.769/79.996/83.151/0.000/-80.004/-76.849/0.000/0.000/0.000/1.000 | 1 | 136 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); K_LISTVALUE_ISO: 1.000 m2
50216125160505012516x13618182114 | Půdorys 1.PP | Kus | 0.059 | 50216125160505012516x13618182114 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/59.4232/125.0000/125.0000/2/59.4232/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/59.42/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.059 m | IT.02.30155 | A1 | 6774Obj0000044461 | Objekt | 59.423/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.059 | 59 | __ISO | 0.04 | 0,041 W/m.K
1520612512559xxxxxx0 | Půdorys 1.PP | Kus | 0 | 1520612512559xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/26.8419/2.9160/0/12.4/0/270.0/125.0000/125.0000/125.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/12.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30156 | A1 | 6774Obj0000044464 | Objekt | 40.263/63.958/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
