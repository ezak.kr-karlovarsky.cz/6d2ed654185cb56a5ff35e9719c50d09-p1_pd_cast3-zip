Properties of the parts of a building model (IFC2X3), part 5 of 51

# IfcFlowFitting (2887)
Name | In | Jednotka | Délka (m) | Označení | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_DIM | L_BES_DIM_A2 | L_BES_DIM_B2 | L_BES_DIM_A | K_VOLSTROM | K_MLH_GOST = K_MLD_GOST | K_LISTVALUE | Kód prvku | Třída reakce na oheň | Allright_Stavebni_dil_ID | Název_objektu | K_EBT_BOX_WC | Plocha | L_BES_LAENGE | K_INTERNAL_ISO | Tloušťka (m) | Součinitel tepelné vodivost
252x1250125115xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3512 | A1 | 6772Obj0000143012 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125115xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3515 | A1 | 6772Obj0000143027 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125115xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3518 | A1 | 6772Obj0000143042 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125143xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125143xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/351.9/125.0000/125.0000/125.0000/2/85.0901/33.4321/0/42.9/0/351.9/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/351.90/0/125.00/1.00/42.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3520 | A1 | 6772Obj0000143052 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125143xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125143xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/174.0/125.0000/125.0000/125.0000/2/85.0901/33.4321/0/42.9/0/174.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/174.00/0/125.00/1.00/42.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3523 | A1 | 6772Obj0000143067 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125115xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3525 | A1 | 6772Obj0000143077 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125115xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3527 | A1 | 6772Obj0000143087 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125115xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3530 | A1 | 6772Obj0000143102 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125115xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3533 | A1 | 6772Obj0000143117 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125115xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3536 | A1 | 6772Obj0000143132 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125115xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3539 | A1 | 6772Obj0000143147 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125115xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3542 | A1 | 6772Obj0000143162 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125115xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3545 | A1 | 6772Obj0000143177 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x125012516xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012516xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/348.9/125.0000/125.0000/125.0000/2/108.2532/62.5000/0/60.0/0/348.9/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/348.90/0/125.00/1.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3548 | A1 | 6772Obj0000143192 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x125012516xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012516xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/174.4/125.0000/125.0000/125.0000/2/108.2532/62.5000/0/60.0/0/174.4/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/174.40/0/125.00/1.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3550 | A1 | 6772Obj0000143202 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125115xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3553 | A1 | 6772Obj0000143242 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125115xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3556 | A1 | 6772Obj0000143257 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125115xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3559 | A1 | 6772Obj0000143272 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125115xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3562 | A1 | 6772Obj0000143287 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125115xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3565 | A1 | 6772Obj0000143302 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125115xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3567 | A1 | 6772Obj0000143312 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125115xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/289.7/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/289.7/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/289.70/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3570 | A1 | 6772Obj0000143327 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125115xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/110.3/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/110.3/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/110.30/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3572 | A1 | 6772Obj0000143337 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x125012513xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012513xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3575 | A1 | 6772Obj0000143352 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x125012513xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012513xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3577 | A1 | 6772Obj0000143362 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125115xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/64.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/64.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/64.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3580 | A1 | 6772Obj0000143377 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125115xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/243.2/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/243.2/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/243.20/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3582 | A1 | 6772Obj0000143387 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125115xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/136.4/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/136.4/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/136.40/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3585 | A1 | 6772Obj0000143427 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125115xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/317.4/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/317.4/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/317.40/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3588 | A1 | 6772Obj0000143442 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x125012519xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/349.7/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/349.7/125.0000/125.0000/125.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/349.70/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3591 | A1 | 6772Obj0000143457 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x125012519xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3593 | A1 | 6772Obj0000143467 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125115xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/327.3/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/327.3/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/327.30/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3596 | A1 | 6772Obj0000143482 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125115xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/148.2/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/148.2/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/148.20/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3598 | A1 | 6772Obj0000143492 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125142xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125142xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/9.2/125.0000/125.0000/125.0000/2/82.8275/31.3805/0/41.5/0/9.2/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/9.20/0/125.00/1.00/41.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3600 | A1 | 6772Obj0000143502 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125142xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125142xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/186.9/125.0000/125.0000/125.0000/2/82.8275/31.3805/0/41.5/0/186.9/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/186.90/0/125.00/1.00/41.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3603 | A1 | 6772Obj0000143517 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x16x160145xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/0/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | TA.02.3606 | A1 | 6772Obj0000143532 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
252x16x160145xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/180.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/180.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | TA.02.3608 | A1 | 6772Obj0000143542 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
252x125012519xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/195.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/195.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/195.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | TA.02.3611 | A1 | 6772Obj0000143562 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x125012513xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x125012513xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/88.7/125.0000/125.0000/125.0000/2/7.4133/0.2200/0/3.4/0/88.7/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/88.70/0/125.00/1.00/3.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | TA.02.3613 | A1 | 6772Obj0000143572 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125112xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125112xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.4/125.0000/125.0000/125.0000/2/25.1347/2.5531/0/11.6/0/90.4/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.40/0/125.00/1.00/11.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | TA.02.3615 | A1 | 6772Obj0000143582 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x125012519xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/225.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/225.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/225.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | TA.02.3618 | A1 | 6772Obj0000143627 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1x01x19xxxxxx | Půdorys 1.PP | Stk | 0 | 252x1x01x19xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/180.0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/180.00/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 1.0 | TA.02.3621 | A1 | 6772Obj0000143898 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN100
252x1x01x13xxxxxx | Půdorys 1.PP | Stk | 0 | 252x1x01x13xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/22.3/100.0000/100.0000/100.0000/2/50.0000/13.3975/0/30.0/0/22.3/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/22.30/0/100.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 1.0 | TA.02.3623 | A1 | 6772Obj0000143908 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN100
252x1x01x13xxxxxx | Půdorys 1.PP | Stk | 0 | 252x1x01x13xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/199.6/100.0000/100.0000/100.0000/2/50.0000/13.3975/0/30.0/0/199.6/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/199.60/0/100.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 1.0 | TA.02.3625 | A1 | 6772Obj0000143918 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN100
252x1250125115xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/293.4/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/293.4/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/293.40/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3656 | A1 | 6772Obj0000144444 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125115xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/114.1/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/114.1/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/114.10/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3658 | A1 | 6772Obj0000144454 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
2010456056x50501601x22xxxx | Půdorys 1.PP | m2 | 0 | 2010456056x50501601x22xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/0/560.0000/560.0000/160.0000/1/238.1272/46.0716/0/21.9/0/0/1.0000/560.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/0/50.00/50.00/160.00/100.00/21.90/0/1.00/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 560 | 160 | 560 | 0.000 | 0 | 1.000 m2 | TA.02.3111 | A1 | 6772Obj0000001148 | Koleno | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.56 m; Výška: 0.16 m
2010456056x50501601x9016xxxx | Půdorys 1.PP | m2 | 0 | 2010456056x50501601x9016xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/180.0/560.0000/560.0000/160.0000/1/430.0000/430.0000/0/90.0/0/180.0/1.0000/560.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/0/50.00/50.00/160.00/100.00/90.00/180.00/1.00/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 560 | 160 | 560 | 0.000 | 0 | 1.640 m2 | TA.02.3157 | A1 | 6772Obj0000001351 | Koleno | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 2.240 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.56 m; Výška: 0.16 m
2010456056x50501601x9016xxxx | Půdorys 1.PP | m2 | 0 | 2010456056x50501601x9016xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/180.0/560.0000/560.0000/160.0000/1/430.0000/430.0000/0/90.0/0/180.0/1.0000/560.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/0/50.00/50.00/160.00/100.00/90.00/180.00/1.00/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 560 | 160 | 560 | 0.000 | 0 | 1.640 m2 | TA.02.3158 | A1 | 6772Obj0000001355 | Koleno | NEMSOK - K_POSITION: L.7; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 2.240 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.56 m; Výška: 0.16 m
2010516016x50505601x9056xxxx | Půdorys 1.PP | m2 | 0 | 2010516016x50505601x9056xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/270.0/560.0000/560.0000/160.0000/1/230.0000/230.0000/0/90.0/0/270.0/1.0000/560.0000/160.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/560.00/100.00/90.00/270.00/0/560.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 560 | 160 | 560 | 0.000 | 0 | 1.000 m2 | TA.02.3159 | A1 | 6772Obj0000001359 | Koleno | NEMSOK - K_POSITION: L.7; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.080 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.56 m; Výška: 0.16 m
20104315315050501601x9016xxxx | Půdorys 1.PP | m2 | 0 | 20104315315050501601x9016xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/0/315.0000/315.0000/160.0000/1/307.5000/307.5000/0/90.0/0/0/1.0000/315.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/0/50.00/50.00/160.00/100.00/90.00/0/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | TA.02.3192 | A1 | 6772Obj0000001580 | Koleno | NEMSOK - K_POSITION: L.23; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.030 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.315 m; Výška: 0.16 m
20104315315050501601x9016xxxx | Půdorys 1.PP | m2 | 0 | 20104315315050501601x9016xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/180.0/315.0000/315.0000/160.0000/1/307.5000/307.5000/0/90.0/0/180.0/1.0000/315.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/0/50.00/50.00/160.00/100.00/90.00/180.00/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | TA.02.3197 | A1 | 6772Obj0000001597 | Koleno | NEMSOK - K_POSITION: L.19; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.030 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.315 m; Výška: 0.16 m
201055x5x050501601x9016xxxx | Půdorys 1.PP | m2 | 0 | 201055x5x050501601x9016xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/180.0/500.0000/500.0000/160.0000/1/400.0000/400.0000/0/90.0/0/180.0/1.0000/500.0000/160.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/500.00/0/50.00/50.00/160.00/100.00/90.00/180.00/1.00/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 500x160 | 500 | 160 | 500 | 0.000 | 0 | 1.380 m2 | TA.02.3198 | A1 | 6772Obj0000001601 | Koleno | NEMSOK - K_POSITION: L.22; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.810 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.5 m; Výška: 0.16 m
201065x5x050501601x9016xxxx | Půdorys 1.PP | m2 | 0 | 201065x5x050501601x9016xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/180.0/500.0000/500.0000/160.0000/1/400.0000/400.0000/0/90.0/0/180.0/1.0000/500.0000/160.0000/1/ | 20/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/500.00/0/50.00/50.00/160.00/100.00/90.00/180.00/1.00/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 500x160 | 500 | 160 | 500 | 0.000 | 0 | 1.380 m2 | TA.02.3199 | A1 | 6772Obj0000001603 | Koleno | NEMSOK - K_POSITION: L.15; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.810 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.5 m; Výška: 0.16 m
201044x4x050503x1x903xxxx0 | Půdorys 1.PP | m2 | 0 | 201044x4x050503x1x903xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/180.0/400.0000/400.0000/300.0000/1/350.0000/350.0000/0/90.0/0/180.0/1.0000/400.0000/300.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/400.00/0/50.00/50.00/300.00/100.00/90.00/180.00/0/300.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x300 | 400 | 300 | 400 | 0.000 | 0 | 1.240 m2 | TA.02.3200 | A1 | 6772Obj0000001605 | Koleno | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 300; K_LISTVALUE_ISO: 1.630 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.4 m; Výška: 0.3 m
2010616016x50505601x9xxxx0 | Půdorys 1.PP | m2 | 0 | 2010616016x50505601x9xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/270.0/560.0000/560.0000/160.0000/1/230.0000/230.0000/0/90.0/0/270.0/1.0000/560.0000/160.0000/1/ | 20/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/560.00/100.00/90.00/270.00/1.00/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 560 | 160 | 560 | 0.000 | 0 | 1.210 m2 | TA.02.3201 | A1 | 6772Obj0000001613 | Koleno | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.210 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.56 m; Výška: 0.16 m
20104315315050501601x9016xxxx | Půdorys 1.PP | m2 | 0 | 20104315315050501601x9016xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/180.0/315.0000/315.0000/160.0000/1/307.5000/307.5000/0/90.0/0/180.0/0/315.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/0/50.00/50.00/160.00/100.00/90.00/180.00/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | TA.02.3212 | A1 | 6772Obj0000001648 | Koleno | NEMSOK - K_POSITION: L.28; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.030 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.315 m; Výška: 0.16 m
201044x4x050503x1x903xxxx0 | Půdorys 1.PP | m2 | 0 | 201044x4x050503x1x903xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/270.0/400.0000/400.0000/300.0000/1/300.0000/300.0000/0/90.0/0/270.0/1.0000/400.0000/300.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/300.00/300.00/0/50.00/50.00/400.00/100.00/90.00/270.00/0/400.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x300 | 400 | 300 | 400 | 0.000 | 0 | 1.020 m2 | TA.02.3214 | A1 | 6772Obj0000001654 | Koleno | 570.000/350.000/170.000/0.000/-220.000/-170.000/0.000/0.000/0.000/1.000 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 300; K_LISTVALUE_ISO: 1.360 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.4 m; Výška: 0.3 m
2010516016x50505601x9056xxxx | Půdorys 1.PP | m2 | 0 | 2010516016x50505601x9056xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/270.0/560.0000/560.0000/160.0000/1/230.0000/230.0000/0/90.0/0/270.0/260.0000/560.0000/160.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/560.00/100.00/90.00/270.00/0/560.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 560 | 160 | 560 | 0.000 | 0 | 1.000 m2 | TA.02.3217 | A1 | 6772Obj0000001668 | Koleno | NEMSOK - K_POSITION: L.5; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.010 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.56 m; Výška: 0.16 m
20104315315050501601x9016xxxx | Půdorys 1.PP | m2 | 0 | 20104315315050501601x9016xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/0/315.0000/315.0000/160.0000/1/307.5000/307.5000/0/90.0/0/0/1.0000/315.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/0/50.00/50.00/160.00/100.00/90.00/0/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | TA.02.3219 | A1 | 6772Obj0000001686 | Koleno | NEMSOK - K_POSITION: L.22; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.030 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.315 m; Výška: 0.16 m
2010416016x50501601x4516xxxx | Půdorys 1.PP | m2 | 0 | 2010416016x50501601x4516xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/1/212.6346/88.0761/0/45.0/0/270.0/1.0000/160.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/160.00/100.00/45.00/270.00/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3220 | A1 | 6772Obj0000001689 | Koleno | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.16 m; Výška: 0.16 m
2010416016x50501601x4516xxxx | Půdorys 1.PP | m2 | 0 | 2010416016x50501601x4516xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/1/212.6346/88.0761/0/45.0/0/270.0/1.0000/160.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/160.00/100.00/45.00/270.00/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3222 | A1 | 6772Obj0000001691 | Koleno | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.16 m; Výška: 0.16 m
201052x2x050501601x9xxxx0 | Půdorys 1.PP | m2 | 0 | 201052x2x050501601x9xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/0/200.0000/200.0000/160.0000/1/250.0000/250.0000/0/90.0/0/0/1.0000/200.0000/160.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/0/50.00/50.00/160.00/100.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x160 | 200 | 160 | 200 | 0.000 | 0 | 1.000 m2 | TA.02.3225 | A1 | 6772Obj0000001827 | Koleno | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.2 m; Výška: 0.16 m
201052x2x050501601x9xxxx0 | Půdorys 1.PP | m2 | 0 | 201052x2x050501601x9xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/180.0/200.0000/200.0000/160.0000/1/250.0000/250.0000/0/90.0/0/180.0/1.0000/200.0000/160.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/0/50.00/50.00/160.00/100.00/90.00/180.00/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x160 | 200 | 160 | 200 | 0.000 | 0 | 1.000 m2 | TA.02.3226 | A1 | 6772Obj0000001857 | Koleno | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.2 m; Výška: 0.16 m
2010556056x50501601x22xxxx | Půdorys 1.PP | m2 | 0 | 2010556056x50501601x22xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/180.0/560.0000/560.0000/160.0000/1/238.1272/46.0716/0/21.9/0/180.0/1.0000/560.0000/160.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/0/50.00/50.00/160.00/100.00/21.90/180.00/1.00/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 560 | 160 | 560 | 0.000 | 0 | 1.000 m2 | TA.02.3257 | A1 | 6772Obj0000031395 | Koleno | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.56 m; Výška: 0.16 m
2010456056x50501601x9xxxx0 | Půdorys 1.PP | m2 | 0 | 2010456056x50501601x9xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/0/560.0000/560.0000/160.0000/1/430.0000/430.0000/0/90.0/0/0/1.0000/560.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/0/50.00/50.00/160.00/100.00/90.00/0/1.00/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 560 | 160 | 560 | 0.000 | 0 | 1.640 m2 | TA.02.3286 | A1 | 6772Obj0000059884 | Koleno | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 2.240 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.56 m; Výška: 0.16 m
2010456056x50501601x9xxxx0 | Půdorys 1.PP | m2 | 0 | 2010456056x50501601x9xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/0/560.0000/560.0000/160.0000/1/430.0000/430.0000/0/90.0/0/0/1.0000/560.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/0/50.00/50.00/160.00/100.00/90.00/0/1.00/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 560 | 160 | 560 | 0.000 | 0 | 1.640 m2 | TA.02.3311 | A1 | 6772Obj0000139765 | Koleno | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 2.240 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.56 m; Výška: 0.16 m
2010456056x50501601x9016xxxx | Půdorys 1.PP | m2 | 0 | 2010456056x50501601x9016xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/180.0/560.0000/560.0000/160.0000/1/430.0000/430.0000/0/90.0/0/180.0/1.0000/560.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/0/50.00/50.00/160.00/100.00/90.00/180.00/1.00/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 560 | 160 | 560 | 0.000 | 0 | 1.640 m2 | TA.02.3313 | A1 | 6772Obj0000139795 | Koleno | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 2.240 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.56 m; Výška: 0.16 m
2010416016x50501601x4516xxxx | Půdorys 1.PP | m2 | 0 | 2010416016x50501601x4516xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/1/212.6346/88.0761/0/45.0/0/180.0/1.0000/160.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/160.00/100.00/45.00/180.00/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3317 | A1 | 6772Obj0000139900 | Koleno | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.16 m; Výška: 0.16 m
2010416016x50501601x4516xxxx | Půdorys 1.PP | m2 | 0 | 2010416016x50501601x4516xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/1/212.6346/88.0761/0/45.0/0/0/1.0000/160.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/160.00/100.00/45.00/0/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3318 | A1 | 6772Obj0000139915 | Koleno | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.16 m; Výška: 0.16 m
2010416016x50501601x4516xxxx | Půdorys 1.PP | m2 | 0 | 2010416016x50501601x4516xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/1/212.6346/88.0761/0/45.0/0/0/1.0000/160.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/160.00/100.00/45.00/0/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3320 | A1 | 6772Obj0000139945 | Koleno | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.16 m; Výška: 0.16 m
2010416016x50501601x4516xxxx | Půdorys 1.PP | m2 | 0 | 2010416016x50501601x4516xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/1/212.6346/88.0761/0/45.0/0/180.0/1.0000/160.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/160.00/100.00/45.00/180.00/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3322 | A1 | 6772Obj0000139975 | Koleno | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.16 m; Výška: 0.16 m
2010416016x50501601x4516xxxx | Půdorys 1.PP | m2 | 0 | 2010416016x50501601x4516xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/1/212.6346/88.0761/0/45.0/0/90.0/1.0000/160.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/160.00/100.00/45.00/90.00/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3370 | A1 | 6772Obj0000140840 | Koleno | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.16 m; Výška: 0.16 m
2010416016x50501601x4516xxxx | Půdorys 1.PP | m2 | 0 | 2010416016x50501601x4516xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/1/212.6346/88.0761/0/45.0/0/90.0/1.0000/160.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/160.00/100.00/45.00/90.00/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3372 | A1 | 6772Obj0000140870 | Koleno | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.16 m; Výška: 0.16 m
201045x5x050501601x9xxxx0 | Půdorys 1.PP | m2 | 0 | 201045x5x050501601x9xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/180.0/500.0000/500.0000/160.0000/1/400.0000/400.0000/0/90.0/0/180.0/1.0000/500.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/500.00/0/50.00/50.00/160.00/100.00/90.00/180.00/1.00/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 500x160 | 500 | 160 | 500 | 0.000 | 0 | 1.380 m2 | TA.02.3382 | A1 | 6772Obj0000140985 | Koleno | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.810 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.5 m; Výška: 0.16 m
2010416016x50503151x9xxxx0 | Půdorys 1.PP | m2 | 0 | 2010416016x50503151x9xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/270.0/315.0000/315.0000/160.0000/1/230.0000/230.0000/0/90.0/0/270.0/1.0000/315.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/315.00/100.00/90.00/270.00/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | TA.02.3384 | A1 | 6772Obj0000141112 | Koleno | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.315 m; Výška: 0.16 m
2010416016x50503151x9xxxx0 | Půdorys 1.PP | m2 | 0 | 2010416016x50503151x9xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/270.0/315.0000/315.0000/160.0000/1/230.0000/230.0000/0/90.0/0/270.0/1.0000/315.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/315.00/100.00/90.00/270.00/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | TA.02.3385 | A1 | 6772Obj0000141127 | Koleno | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.315 m; Výška: 0.16 m
2010416016x50503151x4516xxxx | Půdorys 1.PP | m2 | 0 | 2010416016x50503151x4516xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/90.0/315.0000/315.0000/160.0000/1/212.6346/88.0761/0/45.0/0/90.0/1.0000/315.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/315.00/100.00/45.00/90.00/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | TA.02.3387 | A1 | 6772Obj0000141187 | Koleno | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.315 m; Výška: 0.16 m
2010416016x50503151x4516xxxx | Půdorys 1.PP | m2 | 0 | 2010416016x50503151x4516xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/90.0/315.0000/315.0000/160.0000/1/212.6346/88.0761/0/45.0/0/90.0/1.0000/315.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/315.00/100.00/45.00/90.00/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | TA.02.3389 | A1 | 6772Obj0000141217 | Koleno | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.315 m; Výška: 0.16 m
2010416016x50501601x3xxxx0 | Půdorys 1.PP | m2 | 0 | 2010416016x50501601x3xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/1/183.3013/49.1154/0/30.0/0/180.0/1.0000/160.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/160.00/100.00/30.00/180.00/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3403 | A1 | 6772Obj0000141685 | Koleno | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.16 m; Výška: 0.16 m
2010416016x50501601x3xxxx0 | Půdorys 1.PP | m2 | 0 | 2010416016x50501601x3xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/1/183.3013/49.1154/0/30.0/0/0/1.0000/160.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/160.00/100.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3405 | A1 | 6772Obj0000141715 | Koleno | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.16 m; Výška: 0.16 m
201062x2x050501601x15xxxx | Půdorys 1.PP | m2 | 0 | 201062x2x050501601x15xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/0/200.0000/200.0000/160.0000/1/150.0601/19.7558/0/15.0/0/0/1.0000/200.0000/160.0000/1/ | 20/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/0/50.00/50.00/160.00/100.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x160 | 200 | 160 | 200 | 0.000 | 0 | 1.000 m2 | TA.02.3415 | A1 | 6772Obj0000141840 | Koleno | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.2 m; Výška: 0.16 m
201062x2x050501601x15xxxx | Půdorys 1.PP | m2 | 0 | 201062x2x050501601x15xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/180.0/200.0000/200.0000/160.0000/1/150.0601/19.7558/0/15.0/0/180.0/1.0000/200.0000/160.0000/1/ | 20/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/0/50.00/50.00/160.00/100.00/15.00/180.00/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x160 | 200 | 160 | 200 | 0.000 | 0 | 1.000 m2 | TA.02.3417 | A1 | 6772Obj0000141870 | Koleno | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.2 m; Výška: 0.16 m
2010425025x50501601x15xxxx | Půdorys 1.PP | m2 | 0 | 2010425025x50501601x15xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/0/250.0000/250.0000/160.0000/1/156.5306/20.6076/0/15.0/0/0/1.0000/250.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/0/50.00/50.00/160.00/100.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x160 | 250 | 160 | 250 | 0.000 | 0 | 1.000 m2 | TA.02.3420 | A1 | 6772Obj0000142020 | Koleno | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.25 m; Výška: 0.16 m
2010425025x50501601x15xxxx | Půdorys 1.PP | m2 | 0 | 2010425025x50501601x15xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/180.0/250.0000/250.0000/160.0000/1/156.5306/20.6076/0/15.0/0/180.0/1.0000/250.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/0/50.00/50.00/160.00/100.00/15.00/180.00/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x160 | 250 | 160 | 250 | 0.000 | 0 | 1.000 m2 | TA.02.3422 | A1 | 6772Obj0000142050 | Koleno | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.25 m; Výška: 0.16 m
2010425025x50501601x9xxxx0 | Půdorys 1.PP | m2 | 0 | 2010425025x50501601x9xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/0/250.0000/250.0000/160.0000/1/275.0000/275.0000/0/90.0/0/0/1.0000/250.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/0/50.00/50.00/160.00/100.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x160 | 250 | 160 | 250 | 0.000 | 0 | 1.000 m2 | TA.02.3425 | A1 | 6772Obj0000142095 | Koleno | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.25 m; Výška: 0.16 m
