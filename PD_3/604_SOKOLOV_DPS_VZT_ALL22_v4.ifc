Properties of the parts of a building model (IFC2X3), part 21 of 51

# IfcFlowFitting (2887)
Name | In | Jednotka | Délka (m) | Označení | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_DIM | L_BES_DIM_A2 | L_BES_DIM_B2 | L_BES_DIM_A | K_VOLSTROM | K_MLH_GOST = K_MLD_GOST | K_LISTVALUE | Kód prvku | Třída reakce na oheň | Allright_Stavebni_dil_ID | Název_objektu | K_EBT_BOX_WC | Plocha | L_BES_LAENGE | K_INTERNAL_ISO | Tloušťka (m) | Součinitel tepelné vodivost
252x16x16013xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16013xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/270.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.00/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30339 | A | 6782Obj0798482139 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
252x16x16019xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16019xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/180.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/180.00/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | TA.03.30340 | A | 6782Obj0798482149 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
7520416016016x26x13x9xxxx | Půdorys 1.NP | Stk | 0.26 | 7520416016016x26x13x9xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/260.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/130.0000/130.0000/0/90.0/0/0/160.0000/160.0000/160.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/160.00/0/0/260.00/0/130.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | TA.03.30341 | A | 6782Obj0798482155 | Potrubní tvarovka |  |  | 260 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
252x16x160115xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x16x160115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/41.4110/5.4519/0/15.0/0/0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/0/0/160.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | TA.03.30342 | A | 6782Obj0798482165 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
252x16x160115xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x16x160115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/41.4110/5.4519/0/15.0/0/180.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/180.00/0/160.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | TA.03.30343 | A | 6782Obj0798482175 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
252x16x16019xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16019xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/180.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/180.00/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | TA.03.30344 | A | 6782Obj0798482190 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
252x125012513xxxxxx | Půdorys 1.NP | Stk | 0 | 252x125012513xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | TA.03.30345 | A | 6782Obj0798482240 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN125
252x125012513xxxxxx | Půdorys 1.NP | Stk | 0 | 252x125012513xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | TA.03.30346 | A | 6782Obj0798482250 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN125
252x1x01x145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1x01x145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/231.7/100.0000/100.0000/100.0000/2/70.7107/29.2893/0/45.0/0/231.7/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/231.70/0/100.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | TA.03.30347 | A | 6782Obj0798482271 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN100
302041x1xx1x1x0440-x-03xx | Půdorys 1.NP | Stk | 0.044 | 302041x1xx1x1x0440-x-03xx | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/1.0000/100.0000/100.0000/2/44.0000/-0.1273/0.0314/0/0/0/100.0000/100.0000/100.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/0/0/100.00/100.00/0/44.00/0.13/-0.13/0.03/-0.03/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | TA.03.30348 | A | 6782Obj0798482276 | Potrubní tvarovka |  |  | 44 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN100
252x1x01x145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1x01x145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/41.8/100.0000/100.0000/100.0000/2/70.7107/29.2893/0/45.0/0/41.8/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/41.80/0/100.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | TA.03.30349 | A | 6782Obj0798482286 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN100
252041x01x19xxxxxx | Půdorys 1.NP | Stk | 0 | 252041x01x19xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/100.0000/100.0000/100.0000/2/70.7107/29.2893/0/45.0/0/0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/0/0/100.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 1.0 | TA.03.30350 | A | 6782Obj0798482467 | Potrubní tvarovka | 150.000/100.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | NEMSOK - K_POSITION: L.1; Podlaží: Nadzemní podlaží 1.NP; Průměr: DN100
30204160125x160125078-18-18-18-1 | Půdorys 1.NP | Stk | 0.078 | 30204160125x160125078-18-18-18-1 | UE RUND AS | 20 | 31 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/2/112.0000/0/12.5000/0/0/0/100.0000/100.0000/100.0000/2/ | 31/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/100.00/0/0/160.00/100.00/0/112.00/-30.00/-30.00/-17.50/-30.00/30.00/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN160 | 100 | 100 | 160 | 0.000 | 0 | 1.0 | TA.03.30351 | A | 6782Obj0798482472 | Potrubní tvarovka | 78.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 |  | 112 | NEMSOK - K_POSITION: L.1; Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
252x1x01x19xxxxxx | Půdorys 1.NP | Stk | 0 | 252x1x01x19xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/0/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 1.0 | TA.03.30352 | A | 6782Obj0798482482 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN100
252x1x01x145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1x01x145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/100.0000/100.0000/100.0000/2/70.7107/29.2893/0/45.0/0/270.0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/270.00/0/100.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 1.0 | TA.03.30353 | A | 6782Obj0798482492 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN100
3020431525x031525x156-33-33-33-3 | Půdorys 1.NP | Stk | 0.156 | 3020431525x031525x156-33-33-33-3 | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/1.0000/315.0000/315.0000/2/95.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/250.00/0/0/315.00/250.00/0/95.00/-32.50/-32.50/-32.50/-32.50/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/70.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN315 | 250 | 250 | 315 | 0.000 | 0 | 1.0 | TA.03.30354 | A | 6782Obj0798482761 | Potrubní tvarovka | 156.300/157.500/157.500/0.000/-157.500/-157.500/0.000/0.000/0.000/1.000 |  | 95 | NEMSOK - K_POSITION: L.1; Podlaží: Nadzemní podlaží 1.NP; Průměr: DN315
252x16x160185xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x16x160185xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/150.8/160.0000/160.0000/160.0000/2/159.3912/146.0551/0/85.0/0/150.8/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/150.80/0/160.00/1.00/85.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30355 | A | 6782Obj0798482869 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
252x16x160185xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x16x160185xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/357.2/160.0000/160.0000/160.0000/2/159.3912/146.0551/0/85.0/0/357.2/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/357.20/0/160.00/1.00/85.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30356 | A | 6782Obj0798482879 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
752042502501250215017x9xxxx | Půdorys 1.NP | Stk | 0.215 | 752042502501250215017x9xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/0/250.0000/250.0000/250.0000/2/215.0000/0/0/0/0/0/125.0000/250.0000/250.0000/2/107.5000/170.0000/0/90.0/0/0/125.0000/125.0000/125.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/125.00/0/0/215.00/0/170.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | TA.03.30357 | A | 6782Obj0798486173 | Potrubní tvarovka |  |  | 215 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN250
252x25x25019xxxxxx | Půdorys 1.NP | Stk | 0 | 252x25x25019xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/250.0000/250.0000/250.0000/2/250.0000/250.0000/0/90.0/0/180.0/250.0000/250.0000/250.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/180.00/0/250.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | TA.03.30358 | A | 6782Obj0798486193 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN250
252x1250125145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30359 | A | 6782Obj0798486203 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN125
252x1250125145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30360 | A | 6782Obj0798486207 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN125
252x16x16019xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16019xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/180.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/180.00/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30361 | A | 6782Obj0798486215 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
7520416016016x26x13x9xxxx | Půdorys 1.NP | Stk | 0.26 | 7520416016016x26x13x9xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/260.0000/0/0/0/0/180.0/160.0000/160.0000/160.0000/2/130.0000/130.0000/0/90.0/0/180.0/160.0000/160.0000/160.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/160.00/0/180.00/260.00/0/130.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30362 | A | 6782Obj0798486219 | Potrubní tvarovka |  |  | 260 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
30204160125x160125078-18-18-18-1 | Půdorys 1.NP | Stk | 0.078 | 30204160125x160125078-18-18-18-1 | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/78.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/0/0/160.00/125.00/0/78.00/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN160 | 125 | 125 | 160 | 0.000 | 0 | 1.0 | TA.03.30363 | A | 6782Obj0798486221 | Potrubní tvarovka |  |  | 78 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
252x125012519xxxxxx | Půdorys 1.NP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30364 | A | 6782Obj0798486225 | Potrubní tvarovka | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | NEMSOK - K_POSITION: L.1; Podlaží: Nadzemní podlaží 1.NP; Průměr: DN125
252x16x16019xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16019xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/270.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.00/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30365 | A | 6782Obj0798486231 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
25204125012519xxxxxx | Půdorys 1.NP | Stk | 0 | 25204125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | TA.03.30366 | A | 6782Obj0798488787 | Potrubní tvarovka | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | NEMSOK - K_POSITION: L.1; Podlaží: Nadzemní podlaží 1.NP; Průměr: DN125
252x25x250115xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x25x250115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/250.0000/250.0000/250.0000/2/66.3890/8.9761/0/15.4/0/0/250.0000/250.0000/250.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/0/0/250.00/1.00/15.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | TA.03.30367 | A | 6782Obj0798488797 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN250
252x25x250115xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x25x250115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/250.0000/250.0000/250.0000/2/66.3890/8.9761/0/15.4/0/180.0/250.0000/250.0000/250.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/180.00/0/250.00/1.00/15.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | TA.03.30368 | A | 6782Obj0798488807 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN250
7520625025025x38x19x9xxxx | Půdorys 1.NP | Stk | 0.38 | 7520625025025x38x19x9xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/180.0/250.0000/250.0000/250.0000/2/190.0000/-190.0000/0/270.0/0/180.0/250.0000/250.0000/250.0000/2/190.0000/190.0000/0/90.0/0/180.0/250.0000/250.0000/250.0000/2/ | 75/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/250.00/0/180.00/380.00/0/190.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | TA.03.30369 | A | 6782Obj0798488823 | Potrubní tvarovka |  |  | 380 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN250
3020625016x025016x154-45-45-45-4 | Půdorys 1.NP | Stk | 0.154 | 3020625016x025016x154-45-45-45-4 | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/250.0000/250.0000/250.0000/2/154.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 30/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/160.00/0/0/250.00/160.00/0/154.00/-45.00/-45.00/-45.00/-45.00/30.00/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 160 | 160 | 250 | 0.000 | 0 | 1.0 | TA.03.30370 | A | 6782Obj0798488828 | Potrubní tvarovka |  |  | 154 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN250
252x16x160115xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x16x160115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/41.4110/5.4519/0/15.0/0/180.0/160.0000/160.0000/160.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/180.00/0/160.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30371 | A | 6782Obj0798488838 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
252x16x160115xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x16x160115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/41.4110/5.4519/0/15.0/0/0/160.0000/160.0000/160.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/0/0/160.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30372 | A | 6782Obj0798488848 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
3120625025x025025x60-xx3xx | Půdorys 1.NP | Stk | 0.06 | 3120625025x025025x60-xx3xx | UE RUND AS | 20 | 31 | 2/0/0/0/180.0/0/0/1.0000/250.0000/250.0000/2/60.0000/0.0061/0/0/0/0/250.0000/250.0000/250.0000/2/ | 31/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/0/0/250.00/250.00/0/60.00/-0.01/0.01/0/0/30.00/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | TA.03.30373 | A | 6782Obj0798488863 | Potrubní tvarovka |  |  | 60 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN250
252x1250125136xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1250125136xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/350.6/125.0000/125.0000/125.0000/2/74.0016/24.2590/0/36.3/0/350.6/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/350.60/0/125.00/1.00/36.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | TA.03.30374 | A | 6782Obj0798488873 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN125
252x1250125154xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1250125154xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/335.3/125.0000/125.0000/125.0000/2/101.3830/51.8803/0/54.2/0/335.3/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/335.30/0/125.00/1.00/54.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | TA.03.30375 | A | 6782Obj0798488883 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN125
25204125012519xxxxxx | Půdorys 1.NP | Stk | 0 | 25204125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | TA.03.30376 | A | 6782Obj0798488980 | Potrubní tvarovka | 162.380/93.750/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | NEMSOK - K_POSITION: L.1; Podlaží: Nadzemní podlaží 1.NP; Průměr: DN125
252x1250125145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/302.9/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/302.9/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/302.90/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30377 | A | 6782Obj0798488995 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN125
252x1250125145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/132.5/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/132.5/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/132.50/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30378 | A | 6782Obj0798489005 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN125
20104315315050501601x3xxxx0 | Půdorys 1.NP | m2 | 0 | 20104315315050501601x3xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/180.0/315.0000/315.0000/160.0000/1/222.0513/59.4985/0/30.0/0/180.0/1.0000/315.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/0/50.00/50.00/160.00/100.00/30.00/180.00/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | TA.03.30379 | A | 6782Obj0798489961 | Potrubní tvarovka | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.315 m; Výška: 0.16 m
20104315315050501601x3xxxx0 | Půdorys 1.NP | m2 | 0 | 20104315315050501601x3xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/0/315.0000/315.0000/160.0000/1/222.0513/59.4985/0/30.0/0/0/1.0000/315.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/0/50.00/50.00/160.00/100.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | TA.03.30380 | A | 6782Obj0798489991 | Potrubní tvarovka | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.315 m; Výška: 0.16 m
7520525025025x38x19x9xxxx | Půdorys 1.NP | Stk | 0.38 | 7520525025025x38x19x9xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/0/250.0000/250.0000/250.0000/2/190.0000/-190.0000/0/270.0/0/0/1.0000/250.0000/250.0000/2/190.0000/190.0000/0/90.0/0/0/250.0000/250.0000/250.0000/2/ | 75/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/250.00/0/0/380.00/0/190.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | TA.03.30381 | A | 6782Obj0798490007 | Potrubní tvarovka | 380.000/190.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 380 | NEMSOK - K_POSITION: L.1; Podlaží: Nadzemní podlaží 1.NP; Průměr: DN250
252x16x16019xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16019xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/0/160.0000/160.0000/160.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/0/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30382 | A | 6782Obj0798490067 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
252x16x160145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/270.0/160.0000/160.0000/160.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30383 | A | 6782Obj0798490077 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
252x16x160145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30384 | A | 6782Obj0798490087 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
252x1x01x19xxxxxx | Půdorys 1.NP | Stk | 0 | 252x1x01x19xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/0/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | TA.03.30385 | A | 6782Obj0798490102 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN100
3020425025x025025x6xx03xx | Půdorys 1.NP | Stk | 0.06 | 3020425025x025025x6xx03xx | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/1.0000/250.0000/250.0000/2/60.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/0/0/250.00/250.00/0/60.00/0/0/0/0/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | TA.03.30386 | A | 6782Obj0798490117 | Potrubní tvarovka |  |  | 60 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN250
252x1x01x16xxxxxx | Půdorys 1.NP | Stk | 0 | 252x1x01x16xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/174.0/100.0000/100.0000/100.0000/2/86.6025/50.0000/0/60.0/0/174.0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/174.00/0/100.00/1.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | TA.03.30387 | A | 6782Obj0798490157 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN100
252x1x01x16xxxxxx | Půdorys 1.NP | Stk | 0 | 252x1x01x16xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/357.0/100.0000/100.0000/100.0000/2/86.6025/50.0000/0/60.0/0/357.0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/357.00/0/100.00/1.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | TA.03.30388 | A | 6782Obj0798490167 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN100
252x2x02x16xxxxxx | Půdorys 1.NP | Stk | 0 | 252x2x02x16xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/200.0000/200.0000/200.0000/2/173.2051/100.0000/0/60.0/0/0/200.0000/200.0000/200.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/0/0/200.00/1.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30389 | A | 6782Obj0798491172 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN200
302042x2xx2x2x01120-x-03xx | Půdorys 1.NP | Stk | 0.112 | 302042x2xx2x2x01120-x-03xx | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/2/112.0000/-0.0766/0.1816/0/0/0/200.0000/200.0000/200.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/0/0/200.00/200.00/0/112.00/0.08/-0.08/0.18/-0.18/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30390 | A | 6782Obj0798491177 | Potrubní tvarovka |  |  | 112 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN200
252x2x02x16xxxxxx | Půdorys 1.NP | Stk | 0 | 252x2x02x16xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/200.0000/200.0000/200.0000/2/173.2051/100.0000/0/60.0/0/180.0/200.0000/200.0000/200.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/180.00/0/200.00/1.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30391 | A | 6782Obj0798491187 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN200
252x16x16013xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16013xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/345.7/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/345.7/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/345.70/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30392 | A | 6782Obj0798491227 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
252x16x16013xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16013xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/167.6/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/167.6/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/167.60/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30393 | A | 6782Obj0798491237 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
252x16x16013xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16013xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/290.0/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/290.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/290.00/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// |  | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30394 | A | 6782Obj0798491257 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
252x16x16013xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16013xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/112.8/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/112.8/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/112.80/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// |  | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30395 | A | 6782Obj0798491267 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
252x25x250115xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x25x250115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/250.0000/250.0000/250.0000/2/64.7048/8.5185/0/15.0/0/90.0/250.0000/250.0000/250.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/90.00/0/250.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | TA.03.30396 | A | 6782Obj0798491282 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN250
252x25x250115xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x25x250115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/250.0000/250.0000/250.0000/2/64.7048/8.5185/0/15.0/0/270.0/250.0000/250.0000/250.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/270.00/0/250.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | TA.03.30397 | A | 6782Obj0798491292 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN250
252x16x16013xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16013xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.2/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/90.2/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.20/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30398 | A | 6782Obj0798491312 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
252x16x16013xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16013xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.2/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/270.2/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.20/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30399 | A | 6782Obj0798491322 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
252x1x01x19xxxxxx | Půdorys 1.NP | Stk | 0 | 252x1x01x19xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/147.9/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/147.9/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/147.90/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | TA.03.30400 | A | 6782Obj0798492348 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN100
252x1x01x177xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1x01x177xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/100.0000/100.0000/100.0000/2/97.4761/77.6750/0/77.1/0/0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/0/0/100.00/1.00/77.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | TA.03.30401 | A | 6782Obj0798492358 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN100
252x16x16019xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16019xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/0/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30402 | A | 6782Obj0798492389 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
252x25x25019xxxxxx | Půdorys 1.NP | Stk | 0 | 252x25x25019xxxxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/0/250.0000/250.0000/250.0000/2/380.0000/0/0/0/0/0/1.0000/250.0000/250.0000/2/190.0000/190.0000/0/90.0/0/0/250.0000/250.0000/250.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/250.00/0/0/380.00/0/190.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | TA.03.30403 | A | 6782Obj0798492581 | Potrubní tvarovka | 375.000/250.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 380 | NEMSOK - K_POSITION: L.1; Podlaží: Nadzemní podlaží 1.NP; Průměr: DN250
7520425025016x26x17509xxxx | Půdorys 1.NP | Stk | 0.26 | 7520425025016x26x17509xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/0/250.0000/250.0000/250.0000/2/260.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/130.0000/175.0000/0/90.0/0/0/160.0000/160.0000/160.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/160.00/0/0/260.00/0/175.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | TA.03.30404 | A | 6782Obj0798492612 | Potrubní tvarovka |  |  | 260 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN250
252x16x16013xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16013xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/270.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.00/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30405 | A | 6782Obj0798492622 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
252x16x16013xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16013xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30406 | A | 6782Obj0798492632 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
302042x25x02x25x103252525253xx | Půdorys 1.NP | Stk | 0.103 | 302042x25x02x25x103252525253xx | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/2/103.3000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/250.00/0/0/200.00/250.00/0/103.30/25.00/25.00/25.00/25.00/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 250 | 250 | 200 | 0.000 | 0 | 1.0 | TA.03.30407 | A | 6782Obj0798492647 | Potrubní tvarovka |  |  | 103 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN200
252x2x02x145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x2x02x145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/168.2/200.0000/200.0000/200.0000/2/141.4214/58.5786/0/45.0/0/168.2/200.0000/200.0000/200.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/168.20/0/200.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30408 | A | 6782Obj0798492667 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN200
302042x2xx2x2x0112-x-x3xx | Půdorys 1.NP | Stk | 0.112 | 302042x2xx2x2x0112-x-x3xx | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/2/112.0000/0.0399/-0.1415/0/0/0/200.0000/200.0000/200.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/0/0/200.00/200.00/0/112.00/-0.04/0.04/-0.14/0.14/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30409 | A | 6782Obj0798492672 | Potrubní tvarovka |  |  | 112 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN200
252x2x02x145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x2x02x145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/351.6/200.0000/200.0000/200.0000/2/141.4214/58.5786/0/45.0/0/351.6/200.0000/200.0000/200.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/351.60/0/200.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30410 | A | 6782Obj0798492682 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN200
252x16x16013xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16013xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/329.7/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/329.7/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/329.70/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30411 | A | 6782Obj0798492707 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
252x16x16013xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16013xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/153.2/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/153.2/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/153.20/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30412 | A | 6782Obj0798492717 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
252x16x160115xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x16x160115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/294.7/160.0000/160.0000/160.0000/2/41.4110/5.4519/0/15.0/0/294.7/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/294.70/0/160.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30413 | A | 6782Obj0798492732 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
252x16x160115xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x16x160115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/115.5/160.0000/160.0000/160.0000/2/41.4110/5.4519/0/15.0/0/115.5/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/115.50/0/160.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30414 | A | 6782Obj0798492742 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
502162505x701x250250250352125125 | Půdorys 1.NP | m2 | 0.352 | 502162505x701x250250250352125125 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/1.0000/250.0000/250.0000/2/250.0000/0/0/0/0/0/0/500.0000/250.0000/1/ | 50/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/250.00/500.00/70.00/100.00/250.00/250.00/250.00/250.00/125.00/125.00/0/0/57.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN250 | 500 | 250 | 250 | 0.000 | 0 | 1.000 m2 | TA.03.30415 | A | 6782Obj0798492758 | Potrubní tvarovka | 351.500/250.000/125.000/0.000/-250.000/-125.000/0.000/0.000/0.000/1.000 |  | 250 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: DN250
501051x1x351x2x1x1x222x-50-503xx | Půdorys 1.NP | m2 | 0.222 | 501051x1x351x2x1x1x222x-50-503xx | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/100.0000/100.0000/200.0000/1/221.6000/0/0/0/0/0/0/100.0000/100.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/35.00/100.00/200.00/100.00/100.00/221.60/0/0/-50.00/-50.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 100x200 | 100 | 100 | 100 | 0.000 | 0 | 1.000 m2 | TA.03.30095 | A1 | 6782Obj0798479601 | Objekt |  |  | 222 | NEMSOK - K_POSITION: L.64; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.1 m; Výška: 0.2 m
501051x1x351x2x1x1x222x-50-503xx | Půdorys 1.NP | m2 | 0.222 | 501051x1x351x2x1x1x222x-50-503xx | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/100.0000/100.0000/200.0000/1/221.6000/0/0/0/0/0/0/100.0000/100.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/35.00/100.00/200.00/100.00/100.00/221.60/0/0/-50.00/-50.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 100x200 | 100 | 100 | 100 | 0.000 | 0 | 1.000 m2 | TA.03.30109 | A1 | 6782Obj0798479642 | Objekt |  |  | 222 | NEMSOK - K_POSITION: L.64; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.1 m; Výška: 0.2 m
50105125125351x126125125136x-1-1 | Půdorys 1.NP | m2 | 0.136 | 50105125125351x126125125136x-1-1 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/1.0000/125.0000/126.0000/1/135.9000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/35.00/100.00/126.00/125.00/125.00/135.90/0/0/-0.50/-0.50/29.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 125x126 | 125 | 125 | 125 | 0.000 | 0 | 1.000 m2 | TA.03.30006 | A1 | 6782Obj0798479203 | Objekt |  |  | 136 | NEMSOK - K_POSITION: L.21; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 126; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.125 m; Výška: 0.126 m
50105125125351x2x1251252xx-38-38 | Půdorys 1.NP | m2 | 0.2 | 50105125125351x2x1251252xx-38-38 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/125.0000/125.0000/200.0000/1/200.0000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/35.00/100.00/200.00/125.00/125.00/200.00/0/0/-37.50/-37.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 125x200 | 125 | 125 | 125 | 0.000 | 0 | 1.000 m2 | TA.03.30008 | A1 | 6782Obj0798479241 | Objekt |  |  | 200 | NEMSOK - K_POSITION: L.23; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.125 m; Výška: 0.2 m
50105125125351x2x1251252xx-38-38 | Půdorys 1.NP | m2 | 0.2 | 50105125125351x2x1251252xx-38-38 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/125.0000/125.0000/200.0000/1/200.0000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/35.00/100.00/200.00/125.00/125.00/200.00/0/0/-37.50/-37.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 125x200 | 125 | 125 | 125 | 0.000 | 0 | 1.000 m2 | TA.03.30009 | A1 | 6782Obj0798479242 | Objekt |  |  | 200 | NEMSOK - K_POSITION: L.23; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.125 m; Výška: 0.2 m
50105125125351x2x1251252xx-38-38 | Půdorys 1.NP | m2 | 0.2 | 50105125125351x2x1251252xx-38-38 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/125.0000/125.0000/200.0000/1/200.0000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/35.00/100.00/200.00/125.00/125.00/200.00/0/0/-37.50/-37.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 125x200 | 125 | 125 | 125 | 0.000 | 0 | 1.000 m2 | TA.03.30010 | A1 | 6782Obj0798479243 | Objekt |  |  | 200 | NEMSOK - K_POSITION: L.23; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.125 m; Výška: 0.2 m
50105125125351x2x1251252xx-38-38 | Půdorys 1.NP | m2 | 0.2 | 50105125125351x2x1251252xx-38-38 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/125.0000/125.0000/200.0000/1/200.0000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/35.00/100.00/200.00/125.00/125.00/200.00/0/0/-37.50/-37.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 125x200 | 125 | 125 | 125 | 0.000 | 0 | 1.000 m2 | TA.03.30011 | A1 | 6782Obj0798479244 | Objekt |  |  | 200 | NEMSOK - K_POSITION: L.23; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.125 m; Výška: 0.2 m
50105125125351x2x1251252xx-38-38 | Půdorys 1.NP | m2 | 0.2 | 50105125125351x2x1251252xx-38-38 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/125.0000/125.0000/200.0000/1/200.0000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/35.00/100.00/200.00/125.00/125.00/200.00/0/0/-37.50/-37.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 125x200 | 125 | 125 | 125 | 0.000 | 0 | 1.000 m2 | TA.03.30012 | A1 | 6782Obj0798479245 | Objekt |  |  | 200 | NEMSOK - K_POSITION: L.23; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.125 m; Výška: 0.2 m
50105125125351x2x1251252xx-38-38 | Půdorys 1.NP | m2 | 0.2 | 50105125125351x2x1251252xx-38-38 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/125.0000/125.0000/200.0000/1/200.0000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/35.00/100.00/200.00/125.00/125.00/200.00/0/0/-37.50/-37.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 125x200 | 125 | 125 | 125 | 0.000 | 0 | 1.000 m2 | TA.03.30016 | A1 | 6782Obj0798479270 | Objekt |  |  | 200 | NEMSOK - K_POSITION: L.6; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.125 m; Výška: 0.2 m
50105125125351x2x1251252xx-38-38 | Půdorys 1.NP | m2 | 0.2 | 50105125125351x2x1251252xx-38-38 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/125.0000/125.0000/200.0000/1/200.0000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/35.00/100.00/200.00/125.00/125.00/200.00/0/0/-37.50/-37.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 125x200 | 125 | 125 | 125 | 0.000 | 0 | 1.000 m2 | TA.03.30053 | A1 | 6782Obj0798479432 | Objekt |  |  | 200 | NEMSOK - K_POSITION: L.23; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.125 m; Výška: 0.2 m
50105125125351x2x1251252xx-38-38 | Půdorys 1.NP | m2 | 0.2 | 50105125125351x2x1251252xx-38-38 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/125.0000/125.0000/200.0000/1/200.0000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/35.00/100.00/200.00/125.00/125.00/200.00/0/0/-37.50/-37.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 125x200 | 125 | 125 | 125 | 0.000 | 0 | 1.000 m2 | TA.03.30067 | A1 | 6782Obj0798479452 | Objekt |  |  | 200 | NEMSOK - K_POSITION: L.23; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.125 m; Výška: 0.2 m
50105125125351x2x1251252xx-38-38 | Půdorys 1.NP | m2 | 0.2 | 50105125125351x2x1251252xx-38-38 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/125.0000/125.0000/200.0000/1/200.0000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/35.00/100.00/200.00/125.00/125.00/200.00/0/0/-37.50/-37.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 125x200 | 125 | 125 | 125 | 0.000 | 0 | 1.000 m2 | TA.03.30068 | A1 | 6782Obj0798479453 | Objekt |  |  | 200 | NEMSOK - K_POSITION: L.23; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.125 m; Výška: 0.2 m
