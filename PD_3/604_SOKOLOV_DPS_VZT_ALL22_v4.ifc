Properties of the parts of a building model (IFC2X3), part 7 of 51

# IfcFlowFitting (2887)
Name | In | Jednotka | Délka (m) | Označení | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_DIM | L_BES_DIM_A2 | L_BES_DIM_B2 | L_BES_DIM_A | K_VOLSTROM | K_MLH_GOST = K_MLD_GOST | K_LISTVALUE | Kód prvku | Třída reakce na oheň | Allright_Stavebni_dil_ID | Název_objektu | K_EBT_BOX_WC | Plocha | L_BES_LAENGE | K_INTERNAL_ISO | Tloušťka (m) | Součinitel tepelné vodivost
41104450560505031516x36955550-15 | Půdorys 1.PP | m2 | 0.369 | 41104450560505031516x36955550-15 | UEBERGANG ASYM. | 20 | 41 | 2/0/0/0/180.0/0/0/1.0000/450.0000/315.0000/1/368.5000/0/77.5000/0/0/0/0/560.0000/160.0000/1/ | 41/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/560.00/50.00/50.00/315.00/160.00/0/368.50/55.00/55.00/0/-155.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x315 | 560 | 160 | 450 | 0.000 | 0 | 1.000 m2 | TA.02.3161 | A1 | 6772Obj0000001365 | Přechodka |  |  | 369 | NEMSOK - K_POSITION: L.11; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 315; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.45 m; Výška: 0.315 m
4110456045050501603150226-55-551 | Půdorys 1.PP | m2 | 0.226 | 4110456045050501603150226-55-551 | UEBERGANG ASYM. | 20 | 41 | 2/0/0/0/180.0/0/0/1.0000/560.0000/160.0000/1/226.1000/0/77.5000/0/0/0/0/450.0000/315.0000/1/ | 41/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/450.00/50.00/50.00/160.00/315.00/0/226.10/-55.00/-55.00/155.00/0/51.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 450 | 315 | 560 | 0.000 | 0 | 1.000 m2 | TA.02.3383 | A1 | 6772Obj0000141052 | Přechodka |  |  | 226 | NEMSOK - K_POSITION: L.5; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.56 m; Výška: 0.16 m
4110456071050501602x036015x0403x | Půdorys 1.PP | m2 | 0.36 | 4110456071050501602x036015x0403x | UEBERGANG ASYM. | 20 | 41 | 2/0/0/0/180.0/0/0/560.0000/560.0000/160.0000/1/359.8000/-75.0000/-20.0000/0/0/0/0/710.0000/200.0000/1/ | 41/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/710.00/50.00/50.00/160.00/200.00/0/359.80/150.00/0/0/40.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 710 | 200 | 560 | 0.000 | 0 | 1.000 m2 | TA.02.3630 | A1 | 6772Obj0000144015 | Přechodka |  | 1 | 360 | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.56 m; Výška: 0.16 m
4110471056050502x16x360-15x0-403 | Půdorys 1.PP | m2 | 0.36 | 4110471056050502x16x360-15x0-403 | UEBERGANG ASYM. | 20 | 41 | 2/0/0/0/180.0/0/0/1.0000/710.0000/200.0000/1/359.8000/75.0000/20.0000/0/0/0/0/560.0000/160.0000/1/ | 41/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/710.00/560.00/50.00/50.00/200.00/160.00/0/359.80/-150.00/0/0/-40.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 710x200 | 560 | 160 | 710 | 0.000 | 0 | 1.000 m2 | TA.02.3631 | A1 | 6772Obj0000144060 | Přechodka |  | 1 | 360 | NEMSOK - K_POSITION: L.9; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.71 m; Výška: 0.2 m
41104710560505025016x125-75-750- | Půdorys 1.PP | m2 | 0.125 | 41104710560505025016x125-75-750- | UEBERGANG ASYM. | 20 | 41 | 2/0/0/0/180.0/0/0/1.0000/710.0000/250.0000/1/125.0000/0/45.0000/0/0/0/0/560.0000/160.0000/1/ | 41/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/710.00/560.00/50.00/50.00/250.00/160.00/0/125.00/-75.00/-75.00/0/-90.00/74.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 710x250 | 560 | 160 | 710 | 0.000 | 0 | 1.000 m2 | TA.02.3634 | A1 | 6772Obj0000144126 | Přechodka |  |  | 125 | NEMSOK - K_POSITION: L.7; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 250; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.71 m; Výška: 0.25 m
41104710560505025016x125-75-750- | Půdorys 1.PP | m2 | 0.125 | 41104710560505025016x125-75-750- | UEBERGANG ASYM. | 20 | 41 | 2/0/0/0/180.0/0/0/1.0000/710.0000/250.0000/1/125.0000/0/45.0000/0/0/0/0/560.0000/160.0000/1/ | 41/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/710.00/560.00/50.00/50.00/250.00/160.00/0/125.00/-75.00/-75.00/0/-90.00/74.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 710x250 | 560 | 160 | 710 | 0.000 | 0 | 1.000 m2 | TA.02.3635 | A1 | 6772Obj0000144128 | Přechodka |  |  | 125 | NEMSOK - K_POSITION: L.10; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 250; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.71 m; Výška: 0.25 m
411048x315505015016x5x-485x105xx | Půdorys 1.PP | m2 | 0.5 | 411048x315505015016x5x-485x105xx | UEBERGANG ASYM. | 20 | 41 | 2/0/0/0/180.0/0/0/1.0000/800.0000/150.0000/1/500.0000/242.5000/-5.0000/0/0/0/0/315.0000/160.0000/1/ | 41/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/800.00/315.00/50.00/50.00/150.00/160.00/0/500.00/-485.00/0/0/10.00/50.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 800x150 | 315 | 160 | 800 | 0.000 | 0 | 1.320 m2 | TA.02.3638 | A1 | 6772Obj0000144170 | Přechodka |  | 1.32 | 500 | NEMSOK - K_POSITION: L.11; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 150; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.8 m; Výška: 0.15 m
411048x315505015016x55x-48501047 | Půdorys 1.PP | m2 | 0.55 | 411048x315505015016x55x-48501047 | UEBERGANG ASYM. | 20 | 41 | 2/0/0/0/180.0/0/0/1.0000/800.0000/150.0000/1/550.0000/-242.5000/-5.0000/0/0/0/0/315.0000/160.0000/1/ | 41/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/800.00/315.00/50.00/50.00/150.00/160.00/0/550.00/0/-485.00/0/10.00/47.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 800x150 | 315 | 160 | 800 | 0.000 | 0 | 1.390 m2 | TA.02.3639 | A1 | 6772Obj0000144177 | Přechodka |  | 1.39 | 550 | NEMSOK - K_POSITION: L.14; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 150; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.8 m; Výška: 0.15 m
4110431531550501604x03xx02405xx | Půdorys 1.PP | m2 | 0.3 | 4110431531550501604x03xx02405xx | UEBERGANG ASYM. | 20 | 41 | 2/0/0/0/180.0/0/0/315.0000/315.0000/160.0000/1/300.0000/0/-120.0000/0/0/0/0/315.0000/400.0000/1/ | 41/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/50.00/50.00/160.00/400.00/0/300.00/0/0/0/240.00/50.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 400 | 315 | 0.000 | 0 | 1.000 m2 | TA.02.3640 | A1 | 6772Obj0000144209 | Přechodka |  | 1 | 300 | NEMSOK - K_POSITION: L.5; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.315 m; Výška: 0.16 m
4110431531550504x16x265-x0-24055 | Půdorys 1.PP | m2 | 0.265 | 4110431531550504x16x265-x0-24055 | UEBERGANG ASYM. | 20 | 41 | 2/0/0/0/180.0/0/0/1.0000/315.0000/400.0000/1/265.0000/0.0260/120.0000/0/0/0/0/315.0000/160.0000/1/ | 41/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/50.00/50.00/400.00/160.00/0/265.00/-0.03/0.03/0/-240.00/55.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x400 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | TA.02.3641 | A1 | 6772Obj0000144227 | Přechodka |  | 1 | 265 | NEMSOK - K_POSITION: L.9; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.315 m; Výška: 0.4 m
51216125160505012516x14218171125 | Půdorys 1.PP | m2 | 0.142 | 51216125160505012516x14218171125 | UEBERGANG ECK/RU AS | 20 | 51 | 2/0/0/0/180.0/0/0/1.0000/125.0000/125.0000/2/142.4000/-0.0388/-7.0000/0/0/0/0/160.0000/160.0000/1/ | 51/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/125.00/160.00/50.00/50.00/125.00/160.00/0/142.40/17.54/17.46/10.50/24.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 160 | 160 | 125 | 0.000 | 0 | 1.000 m2 | TA.02.3058 | A1 | 6772Obj0000000958 | Přechodka |  |  | 142 | NEMSOK - K_POSITION: L.12; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: DN125; Šířka: 0.16 m; Výška: 0.16 m
51216125160505012516x14217181125 | Půdorys 1.PP | m2 | 0.142 | 51216125160505012516x14217181125 | UEBERGANG ECK/RU AS | 20 | 51 | 2/0/0/0/180.0/0/0/1.0000/125.0000/125.0000/2/142.4000/0.0388/-7.0000/0/0/0/0/160.0000/160.0000/1/ | 51/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/125.00/160.00/50.00/50.00/125.00/160.00/0/142.40/17.46/17.54/10.50/24.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 160 | 160 | 125 | 0.000 | 0 | 1.000 m2 | TA.02.3059 | A1 | 6772Obj0000000962 | Přechodka |  |  | 142 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: DN125; Šířka: 0.16 m; Výška: 0.16 m
51216125160505012516x14217181125 | Půdorys 1.PP | m2 | 0.142 | 51216125160505012516x14217181125 | UEBERGANG ECK/RU AS | 20 | 51 | 2/0/0/0/180.0/0/0/1.0000/125.0000/125.0000/2/142.4000/0.0388/-7.0000/0/0/0/0/160.0000/160.0000/1/ | 51/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/125.00/160.00/50.00/50.00/125.00/160.00/0/142.40/17.46/17.54/10.50/24.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 160 | 160 | 125 | 0.000 | 0 | 1.000 m2 | TA.02.3061 | A1 | 6772Obj0000000970 | Přechodka |  |  | 142 | NEMSOK - K_POSITION: L.14; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: DN125; Šířka: 0.16 m; Výška: 0.16 m
51216125160505012516x14218171125 | Půdorys 1.PP | m2 | 0.142 | 51216125160505012516x14218171125 | UEBERGANG ECK/RU AS | 20 | 51 | 2/0/0/0/180.0/0/0/1.0000/125.0000/125.0000/2/142.4000/-0.0388/-7.0000/0/0/0/0/160.0000/160.0000/1/ | 51/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/125.00/160.00/50.00/50.00/125.00/160.00/0/142.40/17.54/17.46/10.50/24.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 160 | 160 | 125 | 0.000 | 0 | 1.000 m2 | TA.02.3062 | A1 | 6772Obj0000000974 | Přechodka |  |  | 142 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: DN125; Šířka: 0.16 m; Výška: 0.16 m
51216125160505012516x13018171818 | Půdorys 1.PP | m2 | 0.13 | 51216125160505012516x13018171818 | UEBERGANG ECK/RU AS | 20 | 51 | 2/0/0/0/180.0/0/0/1.0000/125.0000/125.0000/2/130.4000/-0.0319/0/0/0/0/0/160.0000/160.0000/1/ | 51/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/125.00/160.00/50.00/50.00/125.00/160.00/0/130.40/17.53/17.47/17.50/17.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 160 | 160 | 125 | 0.000 | 0 | 1.000 m2 | TA.02.3094 | A1 | 6772Obj0000001082 | Přechodka |  |  | 130 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: DN125; Šířka: 0.16 m; Výška: 0.16 m
51216125160505012516x13017181818 | Půdorys 1.PP | m2 | 0.13 | 51216125160505012516x13017181818 | UEBERGANG ECK/RU AS | 20 | 51 | 2/0/0/0/180.0/0/0/1.0000/125.0000/125.0000/2/130.4000/0.0319/0/0/0/0/0/160.0000/160.0000/1/ | 51/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/125.00/160.00/50.00/50.00/125.00/160.00/0/130.40/17.47/17.53/17.50/17.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 160 | 160 | 125 | 0.000 | 0 | 1.000 m2 | TA.02.3096 | A1 | 6772Obj0000001086 | Přechodka |  |  | 130 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: DN125; Šířka: 0.16 m; Výška: 0.16 m
50216125160505012516x13618172114 | Půdorys 1.PP | m2 | 0.136 | 50216125160505012516x13618172114 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/1.0000/125.0000/125.0000/2/135.7689/-0.0039/3.1512/0/0/0/0/160.0000/160.0000/1/ | 50/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/125.00/160.00/50.00/50.00/125.00/160.00/0/135.77/17.50/17.50/20.65/14.35/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 160 | 160 | 125 | 0.000 | 0 | 1.000 m2 | TA.02.3041 | A1 | 6772Obj0000000851 | Přechodka |  |  | 136 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
50105160125351x160125125165-18-1 | Půdorys 1.PP | m2 | 0.165 | 50105160125351x160125125165-18-1 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/165.3000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/35.00/100.00/160.00/125.00/125.00/165.30/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 125 | 125 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3042 | A1 | 6772Obj0000000855 | Přechodka |  |  | 165 | NEMSOK - K_POSITION: L.35; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.16 m; Výška: 0.16 m
50105160125351x160125125165-18-1 | Půdorys 1.PP | m2 | 0.165 | 50105160125351x160125125165-18-1 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/1/165.3000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/35.00/100.00/160.00/125.00/125.00/165.30/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 125 | 125 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3065 | A1 | 6772Obj0000000990 | Přechodka |  |  | 165 | NEMSOK - K_POSITION: L.37; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.16 m; Výška: 0.16 m
50216125160351x12516012516518181 | Půdorys 1.PP | m2 | 0.165 | 50216125160351x12516012516518181 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/165.3000/0/0/0/0/0/0/160.0000/160.0000/1/ | 50/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/125.00/160.00/35.00/100.00/125.00/160.00/125.00/165.30/17.50/17.50/17.50/17.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 160 | 160 | 125 | 120.000 | 0 | 1.000 m2 | TA.02.3069 | A1 | 6772Obj0000001022 | Přechodka |  |  | 165 | NEMSOK - K_POSITION: L.12; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
50216160160351x160120160135x-20- | Půdorys 1.PP | m2 | 0.135 | 50216160160351x160120160135x-20- | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/135.0000/0/0/0/0/0/0/160.0000/120.0000/1/ | 50/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/160.00/160.00/35.00/100.00/160.00/120.00/160.00/135.00/0/0/-20.00/-20.00/53.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 120 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3090 | A1 | 6772Obj0000001068 | Přechodka |  |  | 135 | NEMSOK - K_POSITION: L.23; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
50105160125351x160125125165-18-1 | Půdorys 1.PP | m2 | 0.165 | 50105160125351x160125125165-18-1 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/1/165.3000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/35.00/100.00/160.00/125.00/125.00/165.30/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 125 | 125 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3098 | A1 | 6772Obj0000001090 | Přechodka |  |  | 165 | NEMSOK - K_POSITION: L.40; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.16 m; Výška: 0.16 m
50105160125351x160125125165-18-1 | Půdorys 1.PP | m2 | 0.165 | 50105160125351x160125125165-18-1 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/1/165.3000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/35.00/100.00/160.00/125.00/125.00/165.30/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 125 | 125 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3104 | A1 | 6772Obj0000001102 | Přechodka |  |  | 165 | NEMSOK - K_POSITION: L.43; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.16 m; Výška: 0.16 m
50105160125351x160125125165-18-1 | Půdorys 1.PP | m2 | 0.165 | 50105160125351x160125125165-18-1 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/1/165.3000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/35.00/100.00/160.00/125.00/125.00/165.30/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 125 | 125 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3106 | A1 | 6772Obj0000001106 | Přechodka |  |  | 165 | NEMSOK - K_POSITION: L.45; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.16 m; Výška: 0.16 m
50105160125351x160125125165-18-1 | Půdorys 1.PP | m2 | 0.165 | 50105160125351x160125125165-18-1 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/1/165.3000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/35.00/100.00/160.00/125.00/125.00/165.30/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 125 | 125 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3109 | A1 | 6772Obj0000001118 | Přechodka |  |  | 165 | NEMSOK - K_POSITION: L.50; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.16 m; Výška: 0.16 m
50105160125351x160125125165-18-1 | Půdorys 1.PP | m2 | 0.165 | 50105160125351x160125125165-18-1 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/1000.0000/160.0000/160.0000/1/165.3000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/35.00/100.00/160.00/125.00/125.00/165.30/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 125 | 125 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3114 | A1 | 6772Obj0000001156 | Přechodka |  |  | 165 | NEMSOK - K_POSITION: L.8; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.16 m; Výška: 0.16 m
50216160160351x160120160135x-20- | Půdorys 1.PP | m2 | 0.135 | 50216160160351x160120160135x-20- | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/135.0000/0/0/0/0/0/0/160.0000/120.0000/1/ | 50/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/160.00/160.00/35.00/100.00/160.00/120.00/160.00/135.00/0/0/-20.00/-20.00/53.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 120 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3120 | A1 | 6772Obj0000001167 | Přechodka |  |  | 135 | NEMSOK - K_POSITION: L.23; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
50105160125351x160125125165-18-1 | Půdorys 1.PP | m2 | 0.165 | 50105160125351x160125125165-18-1 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/1/165.3000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/35.00/100.00/160.00/125.00/125.00/165.30/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 125 | 125 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3135 | A1 | 6772Obj0000001214 | Přechodka |  |  | 165 | NEMSOK - K_POSITION: L.45; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.16 m; Výška: 0.16 m
50216160160351x160120160135x-20- | Půdorys 1.PP | m2 | 0.135 | 50216160160351x160120160135x-20- | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/135.0000/0/0/0/0/0/0/160.0000/120.0000/1/ | 50/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/160.00/160.00/35.00/100.00/160.00/120.00/160.00/135.00/0/0/-20.00/-20.00/53.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 120 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3140 | A1 | 6772Obj0000001232 | Přechodka |  |  | 135 | NEMSOK - K_POSITION: L.23; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
50105160125351x160125160165-18-1 | Půdorys 1.PP | m2 | 0.165 | 50105160125351x160125160165-18-1 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/1/165.3000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/35.00/100.00/160.00/125.00/160.00/165.30/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 125 | 125 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3168 | A1 | 6772Obj0000001397 | Přechodka |  |  | 165 | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.16 m; Výška: 0.16 m
50105160125351x160125125165-18-1 | Půdorys 1.PP | m2 | 0.165 | 50105160125351x160125125165-18-1 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/1/165.3000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/35.00/100.00/160.00/125.00/125.00/165.30/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 125 | 125 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3169 | A1 | 6772Obj0000001399 | Přechodka |  |  | 165 | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.16 m; Výška: 0.16 m
50216160160351x160120160135x-20- | Půdorys 1.PP | m2 | 0.135 | 50216160160351x160120160135x-20- | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/135.0000/0/0/0/0/0/0/160.0000/120.0000/1/ | 50/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/160.00/160.00/35.00/100.00/160.00/120.00/160.00/135.00/0/0/-20.00/-20.00/53.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 120 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3177 | A1 | 6772Obj0000001444 | Přechodka |  |  | 135 | NEMSOK - K_POSITION: L.23; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
50216160160351x160120160135x-20- | Půdorys 1.PP | m2 | 0.135 | 50216160160351x160120160135x-20- | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/135.0000/0/0/0/0/0/0/160.0000/120.0000/1/ | 50/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/160.00/160.00/35.00/100.00/160.00/120.00/160.00/135.00/0/0/-20.00/-20.00/53.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 120 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3178 | A1 | 6772Obj0000001462 | Přechodka |  |  | 135 | NEMSOK - K_POSITION: L.23; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
50105160125351x160125125165-18-1 | Půdorys 1.PP | m2 | 0.165 | 50105160125351x160125125165-18-1 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/1/165.3000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/35.00/100.00/160.00/125.00/125.00/165.30/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 125 | 125 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3183 | A1 | 6772Obj0000001500 | Přechodka |  |  | 165 | NEMSOK - K_POSITION: L.44; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.16 m; Výška: 0.16 m
50105160125351x160125125165-18-1 | Půdorys 1.PP | m2 | 0.165 | 50105160125351x160125125165-18-1 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/165.3000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/35.00/100.00/160.00/125.00/125.00/165.30/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 125 | 125 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3195 | A1 | 6772Obj0000001590 | Přechodka |  |  | 165 | NEMSOK - K_POSITION: L.7; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.16 m; Výška: 0.16 m
50105160125351x160125125165-18-1 | Půdorys 1.PP | m2 | 0.165 | 50105160125351x160125125165-18-1 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/165.3000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/35.00/100.00/160.00/125.00/125.00/165.30/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 125 | 125 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3207 | A1 | 6772Obj0000001627 | Přechodka |  |  | 165 | NEMSOK - K_POSITION: L.5; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.16 m; Výška: 0.16 m
50105160125351x160125125165-18-1 | Půdorys 1.PP | m2 | 0.165 | 50105160125351x160125125165-18-1 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/1/165.3000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/35.00/100.00/160.00/125.00/125.00/165.30/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 125 | 125 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3242 | A1 | 6772Obj0000002152 | Přechodka |  |  | 165 | NEMSOK - K_POSITION: L.6; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.16 m; Výška: 0.16 m
50105160125351x160125125165-18-1 | Půdorys 1.PP | m2 | 0.165 | 50105160125351x160125125165-18-1 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/1/165.3000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/35.00/100.00/160.00/125.00/125.00/165.30/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 125 | 125 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3293 | A1 | 6772Obj0000060026 | Přechodka |  |  | 165 | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.16 m; Výška: 0.16 m
401065604x50501603x0239-80-80707 | Půdorys 1.PP | m2 | 0.239 | 401065604x50501603x0239-80-80707 | UEBERGANG SYM. | 20 | 40 | 2/0/0/0/180.0/0/0/1.0000/560.0000/160.0000/1/238.5641/0/-0/0/0/0/0/400.0000/300.0000/1/ | 40/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/50.00/50.00/160.00/300.00/0/238.56/-80.00/-80.00/70.00/70.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 400 | 300 | 560 | 0.000 | 0 | 1.000 m2 | TA.02.3203 | A1 | 6772Obj0000001617 | Přechodka |  |  | 239 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.56 m; Výška: 0.16 m
401044x450505071071x742525x3xx | Půdorys 1.PP | m2 | 0.074 | 401044x450505071071x742525x3xx | UEBERGANG SYM. | 20 | 40 | 2/0/0/0/180.0/0/0/1.0000/400.0000/710.0000/1/74.3000/0/-0/0/0/0/0/450.0000/710.0000/1/ | 40/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/450.00/50.00/50.00/710.00/710.00/0/74.30/25.00/25.00/0/0/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// |  | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x710 | 450 | 710 | 400 | 0.000 | 0 | 1.000 m2 | TA.02.3636 | A1 | 6772Obj0000144131 | Přechodka |  |  | 74 | NEMSOK - K_POSITION: L.5; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 710; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.4 m; Výška: 0.71 m
401044x450505071071x752525x3xx | Půdorys 1.PP | m2 | 0.075 | 401044x450505071071x752525x3xx | UEBERGANG SYM. | 20 | 40 | 2/0/0/0/180.0/0/0/1.0000/400.0000/710.0000/1/75.0000/0/-0/0/0/0/0/450.0000/710.0000/1/ | 40/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/450.00/50.00/50.00/710.00/710.00/0/75.00/25.00/25.00/0/0/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// |  | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x710 | 450 | 710 | 400 | 0.000 | 0 | 1.000 m2 | TA.02.3637 | A1 | 6772Obj0000144133 | Přechodka |  |  | 75 | NEMSOK - K_POSITION: L.8; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 710; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.4 m; Výška: 0.71 m
101055604xxxxxxxx | Půdorys 1.PP | Kus | 0.746 | 101055604xxxxxxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/746.0000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/746.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 1.430 m2 | PO.02.30113 | A1 | 6772Obj0000160330 | Objekt | 746.000/300.000/220.000/0.000/-300.000/-220.000/0.000/0.000/0.000/1.000 | 1.43 | 746 | __ISO | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.56 m; Výška: 0.4 m; Teplonosná látka: -
101055604x746xxxxxx0 | Půdorys 1.PP | Kus | 0.596 | 101055604x746xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/400.0000/560.0000/1/596.0000/0/0/0/0/0/1.0000/400.0000/560.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/560.00/596.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x560 | 400 | 560 | 400 | 0.000 | 0 | 1.140 m2 | PO.02.30114 | A1 | 6772Obj0000160344 | Objekt | 596.000/220.000/300.000/0.000/-220.000/-300.000/0.000/0.000/0.000/1.000 | 1.14 | 596 | __ISO | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 560; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.4 m; Výška: 0.56 m; Teplonosná látka: -
201051x01xx50502251x45225xxx0 | Půdorys 1.PP | m2 | 0 | 201051x01xx50502251x45225xxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/180.0/1000.0000/1000.0000/225.0000/1/509.6194/211.0913/0/45.0/0/180.0/1.0000/1000.0000/225.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/1000.00/1000.00/0/50.00/50.00/225.00/100.00/45.00/180.00/2.00/225.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 30/SB 30/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1000x225 | 1000 | 225 | 1000 | 0.000 | 0 | 2.490 m2 | TA.02.30004 | A1 | 6772Obj0000135441 | Objekt | NEMSOK - K_POSITION: L.28; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 225; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.001 m; Výška: 0.00225 m
201051x01xx50502251x45225xxx0 | Půdorys 1.PP | m2 | 0 | 201051x01xx50502251x45225xxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/0/1000.0000/1000.0000/225.0000/1/509.6194/211.0913/0/45.0/0/0/1.0000/1000.0000/225.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/1000.00/1000.00/0/50.00/50.00/225.00/100.00/45.00/0/2.00/225.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 30/SB 30/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1000x225 | 1000 | 225 | 1000 | 0.000 | 0 | 2.490 m2 | TA.02.30005 | A1 | 6772Obj0000135471 | Objekt | NEMSOK - K_POSITION: L.30; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 225; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.001 m; Výška: 0.00225 m
201051x01xx50502251x90225xxx0 | Půdorys 1.PP | m2 | 0 | 201051x01xx50502251x90225xxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/180.0/1000.0000/1000.0000/225.0000/1/650.0000/650.0000/0/90.0/0/180.0/1.0000/1000.0000/225.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/1000.00/1000.00/0/50.00/50.00/225.00/100.00/90.00/180.00/2.00/225.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 30/SB 30/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1000x225 | 1000 | 225 | 1000 | 0.000 | 0 | 4.710 m2 | TA.02.30006 | A1 | 6772Obj0000135501 | Objekt | NEMSOK - K_POSITION: L.32; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 225; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.001 m; Výška: 0.00225 m
411051x056050502254x0451-340-1x8 | Půdorys 1.PP | m2 | 0.451 | 411051x056050502254x0451-340-1x8 | UEBERGANG ASYM. | 20 | 41 | 2/0/0/0/180.0/0/0/1.0000/1000.0000/225.0000/1/451.1000/120.0192/-0/0/0/0/0/560.0000/400.0000/1/ | 41/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/1000.00/560.00/50.00/50.00/225.00/400.00/0/451.10/-340.02/-99.98/87.50/87.50/44.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 30/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1000x225 | 560 | 400 | 1000 | 0.000 | 0 | 1.380 m2 | TA.02.30103 | A1 | 6772Obj0000144483 | Objekt |  | 1.38 | 451 | NEMSOK - K_POSITION: L.18; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 225; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.0056 m; Výška: 0.004 m
50105250224351x4x224224287-13-13 | Půdorys 1.PP | m2 | 0.287 | 50105250224351x4x224224287-13-13 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/250.0000/250.0000/400.0000/1/287.4000/0/0/0/0/0/0/224.0000/224.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/224.00/35.00/100.00/400.00/224.00/224.00/287.40/-13.00/-13.00/-88.00/-88.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x400 | 224 | 224 | 250 | 0.000 | 0 | 1.000 m2 | TA.02.30026 | A1 | 6772Obj0000136531 | Objekt |  |  | 287 | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.00224 m; Výška: 0.00224 m
50105250224351x4x224224287-13-13 | Půdorys 1.PP | m2 | 0.287 | 50105250224351x4x224224287-13-13 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/1.0000/250.0000/400.0000/1/150.0000/0/0/0/0/0/0/224.0000/224.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/224.00/35.00/100.00/400.00/224.00/224.00/150.00/-13.00/-13.00/-88.00/-88.00/80.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x400 | 224 | 224 | 250 | 0.000 | 0 | 1.000 m2 | TA.02.30041 | A1 | 6772Obj0000136819 | Objekt | 287.400/125.000/200.000/0.000/-125.000/-200.000/0.000/0.000/0.000/1.000 |  | 150 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.00224 m; Výška: 0.00224 m
411054x56050505604x0377808x-1603 | Půdorys 1.PP | m2 | 0.377 | 411054x56050505604x0377808x-1603 | UEBERGANG ASYM. | 20 | 41 | 2/0/0/0/180.0/0/0/400.0000/400.0000/560.0000/1/377.1000/0/80.0000/0/0/0/0/560.0000/400.0000/1/ | 41/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/560.00/50.00/50.00/560.00/400.00/0/377.10/80.00/80.00/0/-160.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x560 | 560 | 400 | 400 | 0.000 | 0 | 1.000 m2 | TA.02.30009 | A1 | 6772Obj0000135567 | Objekt |  |  | 377 | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 560; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.0056 m; Výška: 0.004 m
201044x4x050505601x9056xxxx | Půdorys 1.PP | m2 | 0 | 201044x4x050505601x9056xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/0/400.0000/400.0000/560.0000/1/350.0000/350.0000/0/90.0/0/0/1.0000/400.0000/560.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/400.00/0/50.00/50.00/560.00/100.00/90.00/0/0/560.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x560 | 400 | 560 | 400 | 0.000 | 0 | 1.700 m2 | TA.02.30018 | A1 | 6772Obj0000136232 | Objekt | NEMSOK - K_POSITION: L.28; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 560; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.004 m; Výška: 0.0056 m
2010456056x50504x1x904xxxx0 | Půdorys 1.PP | m2 | 0 | 2010456056x50504x1x904xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/90.0/400.0000/400.0000/560.0000/1/430.0000/430.0000/0/90.0/0/90.0/1.0000/400.0000/560.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/0/50.00/50.00/400.00/100.00/90.00/90.00/1.00/400.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x560 | 400 | 560 | 400 | 0.000 | 0 | 2.180 m2 | TA.02.30019 | A1 | 6772Obj0000136262 | Objekt | NEMSOK - K_POSITION: L.30; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 560; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.004 m; Výška: 0.0056 m
201044x4x050505601x9056xxxx | Půdorys 1.PP | m2 | 0 | 201044x4x050505601x9056xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/180.0/400.0000/400.0000/560.0000/1/350.0000/350.0000/0/90.0/0/90.0/1.0000/560.0000/400.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/400.00/0/50.00/50.00/560.00/100.00/90.00/180.00/0/560.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x560 | 560 | 400 | 400 | 0.000 | 0 | 1.700 m2 | TA.02.30020 | A1 | 6772Obj0000136292 | Objekt | NEMSOK - K_POSITION: L.32; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 560; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.0056 m; Výška: 0.004 m
201054x4x050505601x4556xxxx | Půdorys 1.PP | m2 | 0 | 201054x4x050505601x4556xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/0/400.0000/400.0000/560.0000/1/297.4874/123.2233/0/45.0/0/0/1.0000/400.0000/560.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/400.00/0/50.00/50.00/560.00/100.00/45.00/0/0/560.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x560 | 400 | 560 | 400 | 0.000 | 0 | 1.000 m2 | TA.02.30073 | A1 | 6772Obj0000137873 | Objekt | NEMSOK - K_POSITION: L.27; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 560; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.004 m; Výška: 0.0056 m
201054x4x050505601x4556xxxx | Půdorys 1.PP | m2 | 0 | 201054x4x050505601x4556xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/0/400.0000/400.0000/560.0000/1/297.4874/123.2233/0/45.0/0/0/1.0000/400.0000/560.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/400.00/0/50.00/50.00/560.00/100.00/45.00/0/0/560.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x560 | 400 | 560 | 400 | 0.000 | 0 | 1.000 m2 | TA.02.30074 | A1 | 6772Obj0000137903 | Objekt | NEMSOK - K_POSITION: L.29; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 560; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.004 m; Výška: 0.0056 m
411054x56050505604x0377016x-1603 | Půdorys 1.PP | m2 | 0.377 | 411054x56050505604x0377016x-1603 | UEBERGANG ASYM. | 20 | 41 | 2/0/0/0/180.0/0/0/400.0000/400.0000/560.0000/1/377.1000/80.0000/80.0000/0/0/0/0/560.0000/400.0000/1/ | 41/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/560.00/50.00/50.00/560.00/400.00/0/377.10/0/160.00/0/-160.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x560 | 560 | 400 | 400 | 0.000 | 0 | 1.000 m2 | TA.02.30075 | A1 | 6772Obj0000137910 | Objekt |  |  | 377 | NEMSOK - K_POSITION: L.30; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 560; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.0056 m; Výška: 0.004 m
201044x4x050505601x9056xxxx | Půdorys 1.PP | m2 | 0 | 201044x4x050505601x9056xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/0/400.0000/400.0000/560.0000/1/300.0000/300.0000/0/90.0/0/90.0/1.0000/560.0000/400.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/400.00/0/50.00/50.00/560.00/50.00/90.00/0/0/560.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x560 | 560 | 400 | 400 | 0.000 | 0 | 1.550 m2 | TA.02.30081 | A1 | 6772Obj0000139340 | Objekt | 570.000/350.000/300.000/0.000/-220.000/-300.000/0.000/0.000/0.000/1.000 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 560; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.0056 m; Výška: 0.004 m
20105355355050505601x9056xxxx | Půdorys 1.PP | m2 | 0 | 20105355355050505601x9056xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/270.0/560.0000/560.0000/355.0000/1/327.5000/327.5000/0/90.0/0/270.0/1.0000/560.0000/355.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/355.00/355.00/0/50.00/50.00/560.00/100.00/90.00/270.00/0/560.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 560x355 | 560 | 355 | 560 | 0.000 | 0 | 1.490 m2 | TA.02.30001 | A1 | 6772Obj0000000574 | Objekt | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.0056 m; Výška: 0.00355 m
2010556056x50503551x90355xxx0 | Půdorys 1.PP | m2 | 0 | 2010556056x50503551x90355xxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/0/560.0000/560.0000/355.0000/1/430.0000/430.0000/0/90.0/0/0/1.0000/560.0000/355.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/0/50.00/50.00/355.00/100.00/90.00/0/1.00/355.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 560x355 | 560 | 355 | 560 | 0.000 | 0 | 2.080 m2 | TA.02.30002 | A1 | 6772Obj0000000576 | Objekt | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.0056 m; Výška: 0.00355 m
20105355355050505601x9056xxxx | Půdorys 1.PP | m2 | 0 | 20105355355050505601x9056xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/270.0/560.0000/560.0000/355.0000/1/327.5000/327.5000/0/90.0/0/270.0/1.0000/560.0000/355.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/355.00/355.00/0/50.00/50.00/560.00/100.00/90.00/270.00/0/560.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 560x355 | 560 | 355 | 560 | 0.000 | 0 | 1.490 m2 | TA.02.30003 | A1 | 6772Obj0000000581 | Objekt | NEMSOK - K_POSITION: L.7; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.0056 m; Výška: 0.00355 m
4110456056050503554x0163x9373xx | Půdorys 1.PP | m2 | 0.163 | 4110456056050503554x0163x9373xx | UEBERGANG ASYM. | 20 | 41 | 2/0/0/0/180.0/0/0/1.0000/560.0000/355.0000/1/163.2000/0/-14.0000/0/0/0/0/560.0000/400.0000/1/ | 41/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/50.00/50.00/355.00/400.00/0/163.20/0/0/8.50/36.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x355 | 560 | 400 | 560 | 0.000 | 0 | 1.000 m2 | TA.02.30025 | A1 | 6772Obj0000136525 | Objekt |  |  | 163 | NEMSOK - K_POSITION: L.53; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.0056 m; Výška: 0.004 m
201054x4x050505601x9056xxxx | Půdorys 1.PP | m2 | 0 | 201054x4x050505601x9056xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/90.0/560.0000/560.0000/400.0000/1/350.0000/350.0000/0/90.0/0/90.0/0/560.0000/400.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/400.00/0/50.00/50.00/560.00/100.00/90.00/90.00/0/560.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 1.700 m2 | TA.02.30007 | A1 | 6772Obj0000135545 | Objekt | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.0056 m; Výška: 0.004 m
2010556056x50504x1x904xxxx0 | Půdorys 1.PP | m2 | 0 | 2010556056x50504x1x904xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/0/560.0000/560.0000/400.0000/1/430.0000/430.0000/0/90.0/0/90.0/1.0000/400.0000/560.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/0/50.00/50.00/400.00/100.00/90.00/0/1.00/400.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 400 | 560 | 560 | 0.000 | 0 | 2.180 m2 | TA.02.30008 | A1 | 6772Obj0000135560 | Objekt | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.004 m; Výška: 0.0056 m
2010556056x50504x1x904xxxx0 | Půdorys 1.PP | m2 | 0 | 2010556056x50504x1x904xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/0/560.0000/560.0000/400.0000/1/430.0000/430.0000/0/90.0/0/0/1500.0000/560.0000/400.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/0/50.00/50.00/400.00/100.00/90.00/0/1.00/400.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 2.180 m2 | TA.02.30010 | A1 | 6772Obj0000135638 | Objekt | NEMSOK - K_POSITION: L.8; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.0056 m; Výška: 0.004 m
7010456056025025xx04xx45x1x1x90 | Půdorys 1.PP | m2 | 0.45 | 7010456056025025xx04xx45x1x1x90 | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/0/560.0000/560.0000/400.0000/1/450.0000/0/0/0/0/0/1.0000/560.0000/400.0000/1/225.0000/380.0000/0/90.0/0/0/250.0000/250.0000/400.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/250.00/250.00/0/0/0/0/400.00/0/0/0/450.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 1.000 m2 | TA.02.30021 | A1 | 6772Obj0000136342 | Objekt |  |  | 450 | NEMSOK - K_POSITION: L.35; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.0056 m; Výška: 0.004 m
4110456056050504x3550178x0-453xx | Půdorys 1.PP | m2 | 0.178 | 4110456056050504x3550178x0-453xx | UEBERGANG ASYM. | 20 | 41 | 2/0/0/0/180.0/0/0/560.0000/560.0000/400.0000/1/177.9000/0/22.5000/0/0/0/0/560.0000/355.0000/1/ | 41/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/50.00/50.00/400.00/355.00/0/177.90/0/0/0/-45.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 355 | 560 | 0.000 | 0 | 1.000 m2 | TA.02.30022 | A1 | 6772Obj0000136349 | Objekt |  |  | 178 | NEMSOK - K_POSITION: L.36; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.0056 m; Výška: 0.00355 m
2010456056x50504x1x904xxxx0 | Půdorys 1.PP | m2 | 0 | 2010456056x50504x1x904xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/0/560.0000/560.0000/400.0000/1/430.0000/430.0000/0/90.0/0/0/1.0000/560.0000/400.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/0/50.00/50.00/400.00/100.00/90.00/0/1.00/400.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 2.180 m2 | TA.02.30023 | A1 | 6772Obj0000136446 | Objekt | NEMSOK - K_POSITION: L.43; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.0056 m; Výška: 0.004 m
7010456056025025xx04xx45x1x1x90 | Půdorys 1.PP | m2 | 0.45 | 7010456056025025xx04xx45x1x1x90 | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/0/560.0000/560.0000/400.0000/1/450.0000/0/0/0/0/0/1.0000/560.0000/400.0000/1/225.0000/380.0000/0/90.0/0/0/250.0000/250.0000/400.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/250.00/250.00/0/0/0/0/400.00/0/0/0/450.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 1.000 m2 | TA.02.30024 | A1 | 6772Obj0000136481 | Objekt |  |  | 450 | NEMSOK - K_POSITION: L.45; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.0056 m; Výška: 0.004 m
411055601x050504x225048222022x-1 | Půdorys 1.PP | m2 | 0.482 | 411055601x050504x225048222022x-1 | UEBERGANG ASYM. | 20 | 41 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/481.7000/-220.0000/87.5000/0/0/0/0/1000.0000/225.0000/1/ | 41/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/1000.00/50.00/50.00/400.00/225.00/0/481.70/440.00/0/0/-175.00/49.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 30/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 1000 | 225 | 560 | 0.000 | 0 | 1.600 m2 | TA.02.30044 | A1 | 6772Obj0000136860 | Objekt | 481.700/520.389/220.000/0.000/-519.611/-220.000/0.000/0.000/0.000/1.000 |  | 482 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.001 m; Výška: 0.00225 m
2010556056x50504x1x904xxxx0 | Půdorys 1.PP | m2 | 0 | 2010556056x50504x1x904xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/180.0/560.0000/560.0000/400.0000/1/430.0000/430.0000/0/90.0/0/180.0/125.0000/560.0000/400.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/0/50.00/50.00/400.00/100.00/90.00/180.00/1.00/400.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 2.180 m2 | TA.02.30067 | A1 | 6772Obj0000137404 | Objekt | NEMSOK - K_POSITION: L.24; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.0056 m; Výška: 0.004 m
201054x4x050505601x9056xxxx | Půdorys 1.PP | m2 | 0 | 201054x4x050505601x9056xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/90.0/560.0000/560.0000/400.0000/1/350.0000/350.0000/0/90.0/0/90.0/1.0000/560.0000/400.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/400.00/0/50.00/50.00/560.00/100.00/90.00/90.00/0/560.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// |  | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 1.700 m2 | TA.02.30068 | A1 | 6772Obj0000137724 | Objekt | NEMSOK - K_POSITION: L.16; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.0056 m; Výška: 0.004 m
201054x4x050505601x9056xxxx | Půdorys 1.PP | m2 | 0 | 201054x4x050505601x9056xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/270.0/560.0000/560.0000/400.0000/1/350.0000/350.0000/0/90.0/0/90.0/1.0000/560.0000/400.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/400.00/0/50.00/50.00/560.00/100.00/90.00/270.00/0/560.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// |  | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 1.700 m2 | TA.02.30069 | A1 | 6772Obj0000137739 | Objekt | NEMSOK - K_POSITION: L.17; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.0056 m; Výška: 0.004 m
2010556056x50504x1x904xxxx0 | Půdorys 1.PP | m2 | 0 | 2010556056x50504x1x904xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/0/560.0000/560.0000/400.0000/1/430.0000/430.0000/0/90.0/0/0/1.0000/560.0000/400.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/0/50.00/50.00/400.00/100.00/90.00/0/1.00/400.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 2.180 m2 | TA.02.30070 | A1 | 6772Obj0000137784 | Objekt | NEMSOK - K_POSITION: L.20; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.0056 m; Výška: 0.004 m
