Properties of the parts of a building model (IFC2X3), part 26 of 51

# IfcFlowFitting (2887)
Name | In | Jednotka | Délka (m) | Označení | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_DIM | L_BES_DIM_A2 | L_BES_DIM_B2 | L_BES_DIM_A | K_VOLSTROM | K_MLH_GOST = K_MLD_GOST | K_LISTVALUE | Kód prvku | Třída reakce na oheň | Allright_Stavebni_dil_ID | Název_objektu | K_EBT_BOX_WC | Plocha | L_BES_LAENGE | K_INTERNAL_ISO | Tloušťka (m) | Součinitel tepelné vodivost
152042x2x79xxxxxx0 | Půdorys 1.NP | Kus | 0.2 | 152042x2x79xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/200.0000/160.0000/160.0000/2/200.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/200.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 0.200 m | IT.03.30069 | B | 6784Obj0000010578 | Objekt | 200.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.2 | 200 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.151 m2
152041601602xxxxxxx0 | Půdorys 1.NP | Kus | 0.2 | 152041601602xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/200.0000/160.0000/160.0000/2/200.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/200.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 0.200 m | IT.03.30070 | B | 6784Obj0000010581 | Objekt | 200.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.2 | 200 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.151 m2
152041601602xxxxxxx0 | Půdorys 1.NP | Kus | 0 | 152041601602xxxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/138.5641/80.0000/0/60.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | IT.03.30071 | B | 6784Obj0000010584 | Objekt | 207.846/120.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16016xxxxxx | Půdorys 1.NP | Kus | 0.22 | 252x16x16016xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/220.3991/160.0000/160.0000/2/220.3991/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/220.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 0.220 m | IT.03.30072 | B | 6784Obj0000010587 | Objekt | 220.399/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.22 | 220 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.166 m2
1520416016022xxxxxxx | Půdorys 1.NP | Kus | 0 | 1520416016022xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/138.5641/80.0000/0/60.0/0/270.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.00/0/160.00/1.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | IT.03.30073 | B | 6784Obj0000010590 | Objekt | 207.846/120.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16016xxxxxx | Půdorys 1.NP | Kus | 0.154 | 252x16x16016xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/154.0621/160.0000/160.0000/2/154.0621/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/154.06/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 0.154 m | IT.03.30074 | B | 6784Obj0000010593 | Objekt | 154.062/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.154 | 154 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.116 m2
15204160160154xxxxxx0 | Půdorys 1.NP | Kus | 0.08 | 15204160160154xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/80.1033/160.0000/160.0000/2/80.1033/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/80.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 0.080 m | IT.03.30075 | B | 6784Obj0000010596 | Objekt | 80.103/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.08 | 80 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.060 m2
152041601608xxxxxxx | Půdorys 1.NP | Kus | 0 | 152041601608xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/138.5641/80.0000/0/60.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | IT.03.30076 | B | 6784Obj0000010599 | Objekt | 207.846/120.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16016xxxxxx | Půdorys 1.NP | Kus | 0.22 | 252x16x16016xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/220.3991/160.0000/160.0000/2/220.3991/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/220.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 0.220 m | IT.03.30077 | B | 6784Obj0000010602 | Objekt | 220.399/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.22 | 220 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.166 m2
1520416016022xxxxxxx | Půdorys 1.NP | Kus | 0 | 1520416016022xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/138.5641/80.0000/0/60.0/0/270.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.00/0/160.00/1.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | IT.03.30078 | B | 6784Obj0000010605 | Objekt | 207.846/120.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16016xxxxxx | Půdorys 1.NP | Kus | 0.08 | 252x16x16016xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/80.0552/160.0000/160.0000/2/80.0552/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/80.06/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 0.080 m | IT.03.30079 | B | 6784Obj0000010608 | Objekt | 80.055/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.08 | 80 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.060 m2
152041601608xxxxxxx | Půdorys 1.NP | Kus | 0.26 | 152041601608xxxxxxx | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/260.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/130.0000/130.0000/0/90.0/0/0/160.0000/160.0000/160.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/160.00/0/0/260.00/0/130.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | IT.03.30080 | B | 6784Obj0000010612 | Objekt | 260.000/130.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 260 | __ISO | 0.04 | 0,041 W/m.K
7520416016016x26x13x9xxxx | Půdorys 1.NP | Kus | 0.039 | 7520416016016x26x13x9xxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/39.1931/160.0000/160.0000/2/39.1931/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/39.19/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 0.039 m | IT.03.30081 | B | 6784Obj0000010615 | Objekt | 39.193/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.039 | 39 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.030 m2
1520416016039xxxxxx0 | Půdorys 1.NP | Kus | 0 | 1520416016039xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/41.4110/5.4519/0/15.0/0/0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/0/0/160.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | IT.03.30082 | B | 6784Obj0000010618 | Objekt | 62.117/82.726/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x160115xxxxx0 | Půdorys 1.NP | Kus | 0.056 | 252x16x160115xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/55.6497/160.0000/160.0000/2/55.6497/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/55.65/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 0.056 m | IT.03.30083 | B | 6784Obj0000010621 | Objekt | 55.650/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.056 | 56 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.042 m2
1520416016056xxxxxx0 | Půdorys 1.NP | Kus | 0 | 1520416016056xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/41.4110/5.4519/0/15.0/0/180.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/180.00/0/160.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | IT.03.30084 | B | 6784Obj0000010624 | Objekt | 62.117/82.726/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x160115xxxxx0 | Půdorys 1.NP | Kus | 0.039 | 252x16x160115xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/39.0606/160.0000/160.0000/2/39.0606/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/39.06/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 0.039 m | IT.03.30085 | B | 6784Obj0000010627 | Objekt | 39.061/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.039 | 39 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.029 m2
1520416016039xxxxxx0 | Půdorys 1.NP | Kus | 0.185 | 1520416016039xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/184.8006/160.0000/160.0000/2/184.8006/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/184.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 0.185 m | IT.03.30086 | B | 6784Obj0000010630 | Objekt | 184.801/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.185 | 185 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.139 m2
15204160160185xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15204160160185xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/180.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/180.00/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | IT.03.30087 | B | 6784Obj0000010633 | Objekt | 240.000/160.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16019xxxxxx | Půdorys 1.NP | Kus | 0.06 | 252x16x16019xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/59.8924/160.0000/160.0000/2/59.8924/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/59.89/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 0.060 m | IT.03.30088 | B | 6784Obj0000010636 | Objekt | 59.892/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.06 | 60 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.045 m2
152041601606xxxxxxx | Půdorys 1.NP | Kus | 0.345 | 152041601606xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/344.8006/160.0000/160.0000/2/344.8006/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/344.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 0.345 m | IT.03.30089 | B | 6784Obj0000010639 | Objekt | 344.801/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.345 | 345 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.260 m2
15204160160345xxxxxx0 | Půdorys 1.NP | Kus | 0.078 | 15204160160345xxxxxx0 | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/78.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/0/0/160.00/125.00/0/78.00/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 125 | 125 | 160 | 120.000 | 0 | 1.0 | IT.03.30090 | B | 6784Obj0000010642 | Objekt | 78.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 78 | __ISO | 0.04 | 0,041 W/m.K
30204160125x160125078-18-18-18-1 | Půdorys 1.NP | Kus | 0.215 | 30204160125x160125078-18-18-18-1 | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/215.0000/0/0/0/0/180.0/1.0000/160.0000/160.0000/2/107.5000/125.0000/0/90.0/0/180.0/125.0000/125.0000/125.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/125.00/0/180.00/215.00/0/125.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | IT.03.30091 | B | 6784Obj0000010646 | Objekt | 215.000/125.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 215 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
752041601601250215012509xxxx | Půdorys 1.NP | Kus | 0.324 | 752041601601250215012509xxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/324.0000/125.0000/125.0000/2/324.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/324.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 0.324 m | IT.03.30092 | B | 6784Obj0000010649 | Objekt | 324.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.324 | 324 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.209 m2
15204125125324xxxxxx0 | Půdorys 1.NP | Kus | 0.142 | 15204125125324xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/142.2000/160.0000/160.0000/2/142.2000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/142.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 0.142 m | IT.03.30093 | B | 6784Obj0000010652 | Objekt | 142.200/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.142 | 142 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.107 m2
15204160160142xxxxxx0 | Půdorys 1.NP | Kus | 0.138 | 15204160160142xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/137.5000/125.0000/125.0000/2/137.5000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/137.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 0.138 m | IT.03.30094 | B | 6784Obj0000010655 | Objekt | 137.500/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.138 | 138 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.089 m2
15204125125138xxxxxx0 | Půdorys 1.NP | Kus | 0.04 | 15204125125138xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/40.0000/125.0000/125.0000/2/40.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/40.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 0.040 m | IT.03.30095 | B | 6784Obj0000010658 | Objekt | 40.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.04 | 40 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.026 m2
152041251254xxxxxxx | Půdorys 1.NP | Kus | 0.138 | 152041251254xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/137.5000/125.0000/125.0000/2/137.5000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/137.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 0.138 m | IT.03.30096 | B | 6784Obj0000010661 | Objekt | 137.500/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.138 | 138 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.089 m2
15204125125138xxxxxx0 | Půdorys 1.NP | Kus | 0.348 | 15204125125138xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/347.6732/125.0000/125.0000/2/347.6732/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/347.67/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 0.348 m | IT.03.30097 | B | 6784Obj0000010664 | Objekt | 347.673/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.348 | 348 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.224 m2
15204125125348xxxxxx0 | Půdorys 1.NP | Kus | 0.108 | 15204125125348xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/107.6561/125.0000/125.0000/2/107.6561/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/107.66/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 0.108 m | IT.03.30098 | B | 6784Obj0000010667 | Objekt | 107.656/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.108 | 108 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.069 m2
15204125125108xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15204125125108xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | IT.03.30099 | B | 6784Obj0000010670 | Objekt | 93.750/70.873/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012513xxxxxx | Půdorys 1.NP | Kus | 0.182 | 252x125012513xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/181.8342/125.0000/125.0000/2/181.8342/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/181.83/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 0.182 m | IT.03.30100 | B | 6784Obj0000010673 | Objekt | 181.834/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.182 | 182 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.117 m2
15204125125182xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15204125125182xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | IT.03.30101 | B | 6784Obj0000010676 | Objekt | 93.750/70.873/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012513xxxxxx | Půdorys 1.NP | Kus | 0.108 | 252x125012513xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/107.7141/125.0000/125.0000/2/107.7141/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/107.71/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 0.108 m | IT.03.30102 | B | 6784Obj0000010679 | Objekt | 107.714/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.108 | 108 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.069 m2
15204125125108xxxxxx0 | Půdorys 1.NP | Kus | 0.316 | 15204125125108xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/315.8152/125.0000/125.0000/2/315.8152/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/315.82/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 0.316 m | IT.03.30103 | B | 6784Obj0000010682 | Objekt | 315.815/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.316 | 316 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.203 m2
10152041x1x2xxxxxxx0 | Půdorys 1.NP | Kus | 0.02 | 10152041x1x2xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/19.9000/100.0000/100.0000/2/19.9000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/19.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 0.020 m | IT.03.30104 | B | 6784Obj0000010714 | Objekt | 19.900/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.02 | 20 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.011 m2
macro | Půdorys 1.NP | Kus | 0.2 | macro | Absperrklappe elektrisch NAK-E | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/-1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/100.00/100.00/200.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30105 | B | 6784Obj0000010728 | Objekt | 36160.544/-9175.131/3115.000/36035.544/-9375.131/3015.000/0.000/0.000/0.000/1.000 | 1 | 200 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_DP_EBT: 0.00; K_DATE: 2023/01/04; N_FREI_68: SPIRO POTRUBÍ
10152042x2x31xxxxxxx | Půdorys 1.NP | Kus | 0.215 | 10152042x2x31xxxxxxx | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/0/250.0000/250.0000/250.0000/2/215.0000/0/0/0/0/0/125.0000/250.0000/250.0000/2/107.5000/170.0000/0/90.0/0/0/125.0000/125.0000/125.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/125.00/0/0/215.00/0/170.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | IT.03.30106 | B | 6784Obj0000010752 | Objekt | 215.000/170.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 1 | 215 | __ISO | 0.04 | 0,041 W/m.K
152042x2x45xxxxxx0 | Půdorys 1.NP | Kus | 1.45 | 152042x2x45xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1450.0000/250.0000/250.0000/2/1450.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/1450.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.450 m | IT.03.30107 | B | 6784Obj0000010758 | Konstrukce v aktuální hladině | 1450.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 1.45 | 1450 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 1.503 m2
15204250250145xxxxxxx | Půdorys 1.NP | Kus | 0 | 15204250250145xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/250.0000/250.0000/250.0000/2/250.0000/250.0000/0/90.0/0/180.0/250.0000/250.0000/250.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/180.00/0/250.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | IT.03.30108 | B | 6784Obj0000010761 | Objekt | 375.000/250.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x25x25019xxxxxx | Půdorys 1.NP | Kus | 0.578 | 252x25x25019xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/577.9000/250.0000/250.0000/2/577.9000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/577.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.578 m | IT.03.30109 | B | 6784Obj0000010767 | Objekt | 577.900/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 0.578 | 578 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.599 m2
15204250250578xxxxxx0 | Půdorys 1.NP | Kus | 0.06 | 15204250250578xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/60.0000/125.0000/125.0000/2/60.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.060 m | IT.03.30110 | B | 6784Obj0000010770 | Objekt | 60.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.06 | 60 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.039 m2
152041251256xxxxxxx | Půdorys 1.NP | Kus | 0 | 152041251256xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.03.30111 | B | 6784Obj0000010773 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125145xxxxx0 | Půdorys 1.NP | Kus | 0.341 | 252x1250125145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/340.5812/125.0000/125.0000/2/340.5812/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/340.58/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.341 m | IT.03.30112 | B | 6784Obj0000010776 | Objekt | 340.581/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.341 | 341 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.219 m2
15204125125341xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15204125125341xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.03.30113 | B | 6784Obj0000010779 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125145xxxxx0 | Půdorys 1.NP | Kus | 0.352 | 252x1250125145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/352.2000/125.0000/125.0000/2/352.2000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/352.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.352 m | IT.03.30114 | B | 6784Obj0000010782 | Objekt | 352.200/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.352 | 352 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.227 m2
15204125125352xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15204125125352xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/180.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/180.00/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30115 | B | 6784Obj0000010785 | Objekt | 240.000/160.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16019xxxxxx | Půdorys 1.NP | Kus | 0.595 | 252x16x16019xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/595.2000/160.0000/160.0000/2/595.2000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/595.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.595 m | IT.03.30116 | B | 6784Obj0000010788 | Objekt | 595.200/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.595 | 595 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.449 m2
15204160160595xxxxxx0 | Půdorys 1.NP | Kus | 0.26 | 15204160160595xxxxxx0 | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/260.0000/0/0/0/0/180.0/160.0000/160.0000/160.0000/2/130.0000/130.0000/0/90.0/0/180.0/160.0000/160.0000/160.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/160.00/0/180.00/260.00/0/130.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30117 | B | 6784Obj0000010792 | Objekt | 260.000/130.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 260 | __ISO | 0.04 | 0,041 W/m.K
7520416016016x26x13x9xxxx | Půdorys 1.NP | Kus | 0.078 | 7520416016016x26x13x9xxxx | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/78.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/0/0/160.00/125.00/0/78.00/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN160 | 125 | 125 | 160 | 0.000 | 0 | 1.0 | IT.03.30118 | B | 6784Obj0000010795 | Objekt | 78.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 78 | __ISO | 0.04 | 0,041 W/m.K
30204160125x160125078-18-18-18-1 | Půdorys 1.NP | Kus | 0.178 | 30204160125x160125078-18-18-18-1 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/178.3000/125.0000/125.0000/2/178.3000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/178.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.178 m | IT.03.30119 | B | 6784Obj0000010798 | Objekt | 178.300/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.178 | 178 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.115 m2
15204125125178xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15204125125178xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.03.30120 | B | 6784Obj0000010801 | Objekt | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
252x125012519xxxxxx | Půdorys 1.NP | Kus | 0.261 | 252x125012519xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/260.9000/125.0000/125.0000/2/260.9000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/260.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.261 m | IT.03.30121 | B | 6784Obj0000010804 | Objekt | 260.900/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.261 | 261 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.168 m2
macro | Půdorys 1.NP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/-1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/160.00/160.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 |  | DN160 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30122 | B | 6784Obj0000010824 | Objekt | 38695.994/-5185.000/3110.000/38535.994/-5495.000/2950.000/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/11; N_FREI_68: POZINK
macro | Půdorys 1.NP | Kus | 0.25 | macro | Absperrklappe elektrisch NAK-E | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/-1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/250.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30123 | B | 6784Obj0000010838 | Objekt | 37648.493/-5730.042/3092.456/37492.243/-5980.042/2967.456/0.000/0.000/0.000/1.000 | 1 | 250 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_DP_EBT: 0.00; K_DATE: 2023/01/11; N_FREI_68: POZINK
15204250250781xxxxxx0 | Půdorys 1.NP | Kus | 0.1 | 15204250250781xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/160.0000/160.0000/2/100.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.100 m | IT.03.30124 | B | 6784Obj0000010844 | Objekt | 100.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.1 | 100 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.075 m2
macro | Půdorys 1.NP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/-1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/160.00/160.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 |  | DN160 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30125 | B | 6784Obj0000010858 | Objekt | 39522.393/-8101.500/3155.000/39212.393/-8261.500/2995.000/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/04; N_FREI_68: SPIRO POTRUBÍ
 | Půdorys 1.NP | Kus | 0.067 |  | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/67.4930/160.0000/160.0000/2/67.4930/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/67.49/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.068 m | IT.03.30126 | B | 6784Obj0000010861 | Objekt | 67.493/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.068 | 67 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.051 m2
1520416016067xxxxxx0 | Půdorys 1.NP | Kus | 0.017 | 1520416016067xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/17.3000/160.0000/160.0000/2/17.3000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/17.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.017 m | IT.03.30127 | B | 6784Obj0000010864 | Objekt | 17.300/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.017 | 17 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.013 m2
1520416016017xxxxxx0 | Půdorys 1.NP | Kus | 0.3 | 1520416016017xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/300.0000/160.0000/160.0000/2/300.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/300.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.300 m | IT.03.30128 | B | 6784Obj0000010867 | Objekt | 300.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.3 | 300 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.226 m2
152041601603xxxxxxx0 | Půdorys 1.NP | Kus | 0 | 152041601603xxxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/180.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/180.00/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30129 | B | 6784Obj0000010870 | Objekt | 240.000/160.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16019xxxxxx | Půdorys 1.NP | Kus | 0 | 252x16x16019xxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30130 | B | 6784Obj0000010873 | Objekt | 120.000/90.718/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16013xxxxxx | Půdorys 1.NP | Kus | 0.004 | 252x16x16013xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/4.2563/160.0000/160.0000/2/4.2563/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/4.26/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.004 m | IT.03.30131 | B | 6784Obj0000010876 | Objekt | 4.256/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.004 | 4 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.003 m2
152041601604xxxxxx0 | Půdorys 1.NP | Kus | 0 | 152041601604xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/270.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.00/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30132 | B | 6784Obj0000010879 | Objekt | 120.000/90.718/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16013xxxxxx | Půdorys 1.NP | Kus | 2.26 | 252x16x16013xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/2260.0000/160.0000/160.0000/2/2260.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/2260.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 2.260 m | IT.03.30133 | B | 6784Obj0000010882 | Objekt | 2260.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 2.26 | 2260 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 1.704 m2
15204160160226xxxxxxx | Půdorys 1.NP | Kus | 0 | 15204160160226xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/180.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/180.00/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | IT.03.30134 | B | 6784Obj0000010885 | Objekt | 240.000/160.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
3120425016x025016x154-45-450-903 | Půdorys 1.NP | Kus | 0.017 | 3120425016x025016x154-45-450-903 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/17.0000/250.0000/250.0000/2/17.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/17.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.017 m | IT.03.30135 | B | 6784Obj0000010895 | Objekt | 17.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 0.017 | 17 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.018 m2
302042x25x02x25x99252525253xx | Půdorys 1.NP | Kus | 0.215 | 302042x25x02x25x99252525253xx | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/0/250.0000/250.0000/250.0000/2/215.0000/0/0/0/0/0/125.0000/250.0000/250.0000/2/107.5000/170.0000/0/90.0/0/0/125.0000/125.0000/125.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/125.00/0/0/215.00/0/170.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | IT.03.30136 | B | 6784Obj0000010902 | Objekt | 215.000/170.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 1 | 215 | __ISO | 0.04 | 0,041 W/m.K
752042502501250215017x9xxxx | Půdorys 1.NP | Kus | 0.215 | 752042502501250215017x9xxxx | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/180.0/250.0000/250.0000/250.0000/2/215.0000/0/0/0/0/180.0/125.0000/250.0000/250.0000/2/107.5000/170.0000/0/90.0/0/180.0/125.0000/125.0000/125.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/125.00/0/180.00/215.00/0/170.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | IT.03.30137 | B | 6784Obj0000010906 | Objekt | 215.000/170.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 1 | 215 | __ISO | 0.04 | 0,041 W/m.K
152042x2x58xxxxxx0 | Půdorys 1.NP | Kus | 0.6 | 152042x2x58xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/600.0000/250.0000/250.0000/2/600.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/600.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.600 m | IT.03.30138 | B | 6784Obj0000010915 | Objekt | 600.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 0.6 | 600 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.622 m2
152042502506xxxxxxx0 | Půdorys 1.NP | Kus | 0.006 | 152042502506xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/5.5156/250.0000/250.0000/2/5.5156/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/5.52/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.005 m | IT.03.30139 | B | 6784Obj0000010918 | Objekt | 5.516/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 0.005 | 6 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.006 m2
152042502506xxxxxx0 | Půdorys 1.NP | Kus | 0 | 152042502506xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/250.0000/250.0000/250.0000/2/66.3890/8.9761/0/15.4/0/0/250.0000/250.0000/250.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/0/0/250.00/1.00/15.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | IT.03.30140 | B | 6784Obj0000010921 | Objekt | 99.584/129.488/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x25x250115xxxxx0 | Půdorys 1.NP | Kus | 0.196 | 252x25x250115xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/195.9953/250.0000/250.0000/2/195.9953/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/196.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.196 m | IT.03.30141 | B | 6784Obj0000010924 | Objekt | 195.995/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 0.196 | 196 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.203 m2
15204250250196xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15204250250196xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/250.0000/250.0000/250.0000/2/66.3890/8.9761/0/15.4/0/180.0/250.0000/250.0000/250.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/180.00/0/250.00/1.00/15.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | IT.03.30142 | B | 6784Obj0000010927 | Objekt | 99.584/129.488/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x25x250115xxxxx0 | Půdorys 1.NP | Kus | 0.006 | 252x25x250115xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/5.7025/250.0000/250.0000/2/5.7025/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/5.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.006 m | IT.03.30143 | B | 6784Obj0000010930 | Objekt | 5.702/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 0.006 | 6 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.006 m2
152042502506xxxxxx0 | Půdorys 1.NP | Kus | 0.704 | 152042502506xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/704.0000/250.0000/250.0000/2/704.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/704.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.704 m | IT.03.30144 | B | 6784Obj0000010933 | Objekt | 704.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 0.704 | 704 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.730 m2
15206250250704xxxxxx0 | Půdorys 1.NP | Kus | 0.38 | 15206250250704xxxxxx0 | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/180.0/250.0000/250.0000/250.0000/2/190.0000/-190.0000/0/270.0/0/180.0/250.0000/250.0000/250.0000/2/190.0000/190.0000/0/90.0/0/180.0/250.0000/250.0000/250.0000/2/ | 75/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/250.00/0/180.00/380.00/0/190.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | IT.03.30145 | B | 6784Obj0000010937 | Objekt | 315.000/190.000/125.000/0.000/-190.000/-125.000/0.000/0.000/0.000/1.000 | 1 | 380 | __ISO | 0.04 | 0,041 W/m.K
7520625025025x38x19x9xxxx | Půdorys 1.NP | Kus | 0.154 | 7520625025025x38x19x9xxxx | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/250.0000/250.0000/250.0000/2/154.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 30/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/160.00/0/0/250.00/160.00/0/154.00/-45.00/-45.00/-45.00/-45.00/30.00/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 160 | 160 | 250 | 0.000 | 0 | 1.0 | IT.03.30146 | B | 6784Obj0000010940 | Objekt | 154.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 1 | 154 | __ISO | 0.04 | 0,041 W/m.K
3020625016x025016x154-45-45-45-4 | Půdorys 1.NP | Kus | 0.008 | 3020625016x025016x154-45-45-45-4 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/8.1110/160.0000/160.0000/2/8.1110/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/8.11/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.008 m | IT.03.30147 | B | 6784Obj0000010943 | Objekt | 8.111/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.008 | 8 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.006 m2
152061601608xxxxxx0 | Půdorys 1.NP | Kus | 0 | 152061601608xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/41.4110/5.4519/0/15.0/0/180.0/160.0000/160.0000/160.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/180.00/0/160.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30148 | B | 6784Obj0000010946 | Objekt | 62.117/82.726/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x160115xxxxx0 | Půdorys 1.NP | Kus | 0.116 | 252x16x160115xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/116.2829/160.0000/160.0000/2/116.2829/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/116.28/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.116 m | IT.03.30149 | B | 6784Obj0000010949 | Objekt | 116.283/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.116 | 116 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.088 m2
15206160160116xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15206160160116xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/41.4110/5.4519/0/15.0/0/0/160.0000/160.0000/160.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/0/0/160.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30150 | B | 6784Obj0000010952 | Objekt | 62.117/82.726/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x160115xxxxx0 | Půdorys 1.NP | Kus | 0.008 | 252x16x160115xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/7.7464/160.0000/160.0000/2/7.7464/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/7.75/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.008 m | IT.03.30151 | B | 6784Obj0000010955 | Objekt | 7.746/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.008 | 8 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.006 m2
152061601608xxxxxx0 | Půdorys 1.NP | Kus | 0.229 | 152061601608xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/228.5000/250.0000/250.0000/2/228.5000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/228.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.229 m | IT.03.30152 | B | 6784Obj0000010958 | Objekt | 228.500/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 0.229 | 229 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.237 m2
15206250250229xxxxxx0 | Půdorys 1.NP | Kus | 0.06 | 15206250250229xxxxxx0 | UE RUND AS | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/250.0000/250.0000/2/60.0000/0.0061/0/0/0/0/250.0000/250.0000/250.0000/2/ | 31/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/0/0/250.00/250.00/0/60.00/-0.01/0.01/0/0/30.00/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | IT.03.30153 | B | 6784Obj0000010961 | Objekt | 60.000/125.006/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 1 | 60 | __ISO | 0.04 | 0,041 W/m.K
3120625025x025025x60-xx3xx | Půdorys 1.NP | Kus | 0 | 3120625025x025025x60-xx3xx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | IT.03.30154 | B | 6784Obj0000010964 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
252x1250125145xxxxx0 | Půdorys 1.NP | Kus | 0.12 | 252x1250125145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/120.3954/125.0000/125.0000/2/120.3954/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/120.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 0.120 m | IT.03.30155 | B | 6784Obj0000010967 | Objekt | 120.395/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.12 | 120 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.078 m2
