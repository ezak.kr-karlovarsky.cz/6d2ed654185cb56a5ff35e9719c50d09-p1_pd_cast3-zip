Properties of the parts of a building model (IFC2X3), part 35 of 51

# IfcFlowFitting (2887)
Name | In | Jednotka | Délka (m) | Označení | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_DIM | L_BES_DIM_A2 | L_BES_DIM_B2 | L_BES_DIM_A | K_VOLSTROM | K_MLH_GOST = K_MLD_GOST | K_LISTVALUE | Kód prvku | Třída reakce na oheň | Allright_Stavebni_dil_ID | Název_objektu | K_EBT_BOX_WC | Plocha | L_BES_LAENGE | K_INTERNAL_ISO | Tloušťka (m) | Součinitel tepelné vodivost
152041x1x422xxxxxx0 | Půdorys 1.NP | Kus | 0.412 | 152041x1x422xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/412.0000/100.0000/100.0000/2/412.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/412.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 0.412 m | IT.03.30813 | A2 | 6784Obj0000155440 | Objekt | 412.000/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.412 | 412 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.233 m2
252x1x01x19xxxxxx | Půdorys 1.NP | Kus | 0 | 252x1x01x19xxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/180.0/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/180.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30814 | A2 | 6784Obj0000155446 | Objekt | 169.706/103.431/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x160145xxxxx0 | Půdorys 1.NP | Kus | 0.17 | 252x16x160145xxxxx0 | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/200.0000/1/169.6000/0/0/0/0/0/0/160.0000/160.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/35.00/100.00/200.00/160.00/160.00/169.60/0/0/-20.00/-20.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x200 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.03.30815 | A2 | 6784Obj0000155468 | Objekt | 169.600/80.000/100.000/0.000/-80.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 170 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.106; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
50105160160351x2x16016017x0-20-2 | Půdorys 1.NP | Kus | 0 | 50105160160351x2x16016017x0-20-2 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/225.0/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/225.0/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/225.00/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30816 | A2 | 6784Obj0000155471 | Objekt | 240.000/160.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16019xxxxxx | Půdorys 1.NP | Kus | 0.29 | 252x16x16019xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/289.9138/160.0000/160.0000/2/289.9138/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/289.91/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.290 m | IT.03.30817 | A2 | 6784Obj0000155474 | Objekt | 289.914/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.29 | 290 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.219 m2
1520516016029xxxxxxx | Půdorys 1.NP | Kus | 0 | 1520516016029xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30818 | A2 | 6784Obj0000155477 | Objekt | 169.706/103.431/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x160145xxxxx0 | Půdorys 1.NP | Kus | 0.03 | 252x16x160145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/160.0000/160.0000/2/30.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.030 m | IT.03.30819 | A2 | 6784Obj0000155480 | Objekt | 30.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.023 m2
152041601603xxxxxxx | Půdorys 1.NP | Kus | 0.225 | 152041601603xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/225.1000/160.0000/160.0000/2/225.1000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/225.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.225 m | IT.03.30820 | A2 | 6784Obj0000155483 | Objekt | 225.100/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.225 | 225 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.170 m2
15205160160225xxxxxx0 | Půdorys 1.NP | Kus | 1.5 | 15205160160225xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.950 m2 | IT.03.30821 | A2 | 6784Obj0000155497 | Objekt | 1500.000/245.000/120.000/0.000/-245.000/-120.000/0.000/0.000/0.000/1.000 | 1.95 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 2.430 m2
101044502x15xxxxxxx0 | Půdorys 1.NP | Kus | 1.291 | 101044502x15xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/1290.9098/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/1290.91/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.680 m2 | IT.03.30822 | A2 | 6784Obj0000155511 | Objekt | 1290.910/245.000/120.000/0.000/-245.000/-120.000/0.000/0.000/0.000/1.000 | 1.68 | 1291 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 2.090 m2
101044502x1291xxxxxx0 | Půdorys 1.NP | Kus | 0 | 101044502x1291xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/180.0/450.0000/450.0000/200.0000/1/315.1650/130.5456/0/45.0/0/180.0/1.0000/450.0000/200.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/450.00/0/50.00/50.00/200.00/100.00/45.00/180.00/1.00/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.000 m2 | IT.03.30823 | A2 | 6784Obj0000155593 | Objekt | 488.406/303.787/120.000/0.000/-245.000/-120.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
2010445045x50502x1x452xxxx0 | Půdorys 1.NP | Kus | 0.965 | 2010445045x50502x1x452xxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/965.4000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/965.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.260 m2 | IT.03.30824 | A2 | 6784Obj0000155607 | Objekt | 965.400/245.000/120.000/0.000/-245.000/-120.000/0.000/0.000/0.000/1.000 | 1.26 | 965 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.560 m2
101044502x965xxxxxx0 | Půdorys 1.NP | Kus | 0.4 | 101044502x965xxxxxx0 | T-STCK. GERADE | 20 | 1016 | 3/0/0/0/180.0/0/180.0/400.0000/400.0000/200.0000/1/400.0000/25.0000/0/0/0/180.0/1.0000/450.0000/200.0000/1/200.0000/350.0000/0/90.0/0/180.0/200.0000/200.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/450.00/200.00/200.00/0/50.00/0/0/200.00/0/0/180.00/400.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x200 | 450 | 200 | 400 | 0.000 | 0 | 1.000 m2 | IT.03.30825 | A2 | 6784Obj0000155657 | Objekt | 400.000/350.000/120.000/0.000/-220.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 400 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.44; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
711044x4502x2x05x02xx4x01x1x90 | Půdorys 1.NP | Kus | 0.03 | 711044x4502x2x05x02xx4x01x1x90 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/200.0000/200.0000/2/30.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.030 m | IT.03.30826 | A2 | 6784Obj0000155660 | Objekt | 30.000/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.026 m2
152042x2x3xxxxxxx | Půdorys 1.NP | Kus | 0 | 152042x2x3xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/200.0000/200.0000/200.0000/2/100.0000/26.7949/0/30.0/0/270.0/200.0000/200.0000/200.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/270.00/0/200.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | IT.03.30827 | A2 | 6784Obj0000155663 | Objekt | 150.000/113.397/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x2x02x13xxxxxx | Půdorys 1.NP | Kus | 0.185 | 252x2x02x13xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/184.8204/200.0000/200.0000/2/184.8204/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/184.82/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.185 m | IT.03.30828 | A2 | 6784Obj0000155666 | Objekt | 184.820/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.185 | 185 | __ISO | 0.04 | 0,041 W/m.K
152062x2x185xxxxxx0 | Půdorys 1.NP | Kus | 0 | 152062x2x185xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/200.0000/200.0000/200.0000/2/100.0000/26.7949/0/30.0/0/90.0/200.0000/200.0000/200.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/90.00/0/200.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | IT.03.30829 | A2 | 6784Obj0000155669 | Objekt | 150.000/113.397/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
1x010351x1x28xxxxxx0 | Půdorys 1.NP | Kus | 0.05 | 1x010351x1x28xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/50.0000/100.0000/100.0000/2/50.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 0.050 m | IT.03.30831 | A2 | 6784Obj0000155689 | Konstrukce v aktuální hladině | 50.000/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.05 | 50 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.028 m2
152041x1x5xxxxxxx | Půdorys 1.NP | Kus | 0 | 152041x1x5xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/270.0/100.0000/100.0000/100.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/270.00/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | IT.03.30832 | A2 | 6784Obj0000155692 | Objekt | 150.000/100.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1x01x19xxxxxx | Půdorys 1.NP | Kus | 0.36 | 252x1x01x19xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/360.0000/100.0000/100.0000/2/360.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/360.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 0.360 m | IT.03.30833 | A2 | 6784Obj0000155695 | Objekt | 360.000/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.36 | 360 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.204 m2
macro | Půdorys 1.NP | Kus | 0.31 | macro | Absperrklappe elektrisch NAK-E | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/-1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/100.00/100.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN100 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30834 | A2 | 6784Obj0000155723 | Objekt | 47901.734/28245.000/3160.000/47776.734/27935.000/3060.000/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_DP_EBT: 0.00; K_DATE: 2023/01/09; N_FREI_68: SPIRO POTRUBÍ
10152041x1x31xxxxxxx | Půdorys 1.NP | Kus | 0 | 10152041x1x31xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/0/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | IT.03.30835 | A2 | 6784Obj0000155726 | Objekt | 150.000/100.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1x01x19xxxxxx | Půdorys 1.NP | Kus | 0.05 | 252x1x01x19xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/50.0000/100.0000/100.0000/2/50.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 0.050 m | IT.03.30836 | A2 | 6784Obj0000155729 | Objekt | 50.000/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.05 | 50 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.028 m2
152041x1x5xxxxxxx | Půdorys 1.NP | Kus | 0 | 152041x1x5xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/270.0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/270.00/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | IT.03.30837 | A2 | 6784Obj0000155732 | Objekt | 150.000/100.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1x01x19xxxxxx | Půdorys 1.NP | Kus | 0.36 | 252x1x01x19xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/360.0000/100.0000/100.0000/2/360.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/360.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 0.360 m | IT.03.30838 | A2 | 6784Obj0000155735 | Objekt | 360.000/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.36 | 360 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.204 m2
152041x1x36xxxxxxx | Půdorys 1.NP | Kus | 0.732 | 152041x1x36xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/731.6000/100.0000/100.0000/2/731.6000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/731.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 0.732 m | IT.03.30839 | A2 | 6784Obj0000155738 | Objekt | 731.600/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.732 | 732 | __ISO | 0.04 | 0,041 W/m.K
macro | Půdorys 1.NP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/-1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30840 | A2 | 6784Obj0000155752 | Objekt | 47325.000/26629.000/3172.500/47015.000/26504.000/3047.500/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/10; N_FREI_68: SPIRO POTRUBÍ
 | Půdorys 1.NP | Kus | 0 |  | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.03.30841 | A2 | 6784Obj0000155755 | Objekt | 93.750/70.873/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012513xxxxxx | Půdorys 1.NP | Kus | 0.298 | 252x125012513xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/297.9044/125.0000/125.0000/2/297.9044/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/297.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.298 m | IT.03.30842 | A2 | 6784Obj0000155758 | Objekt | 297.904/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.298 | 298 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.192 m2
15204125125298xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15204125125298xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.03.30843 | A2 | 6784Obj0000155761 | Objekt | 93.750/70.873/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012513xxxxxx | Půdorys 1.NP | Kus | 0.03 | 252x125012513xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.030 m | IT.03.30844 | A2 | 6784Obj0000155764 | Objekt | 30.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.019 m2
macro | Půdorys 1.NP | Kus | 0.28 | macro | Absperrklappe elektrisch NAK-E | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/100.00/100.00/280.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN100 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30845 | A2 | 6784Obj0000155778 | Objekt | 47761.187/12057.968/3160.000/47481.187/11932.968/3060.000/0.000/0.000/0.000/1.000 | 1 | 280 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_DP_EBT: 0.00; K_DATE: 2023/01/10; N_FREI_68: SPIRO POTRUBÍ
10152051x1x28xxxxxxx | Půdorys 1.NP | Kus | 0.3 | 10152051x1x28xxxxxxx | T-STCK. GERADE | 20 | 1016 | 3/0/0/0/180.0/0/180.0/450.0000/450.0000/200.0000/1/300.0000/0/0/0/0/180.0/125.0000/450.0000/200.0000/1/150.0000/325.0000/0/90.0/0/180.0/100.0000/100.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/450.00/100.00/100.00/0/0/0/0/200.00/0/0/180.00/300.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.000 m2 | IT.03.30846 | A2 | 6784Obj0000155826 | Objekt | 300.000/325.000/120.000/0.000/-245.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 300 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.63; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
701044504501x1xxx2xx3x01x1x90 | Půdorys 1.NP | Kus | 0.222 | 701044504501x1xxx2xx3x01x1x90 | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/100.0000/200.0000/1/221.6000/0/0/0/0/0/0/100.0000/100.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/35.00/100.00/200.00/100.00/100.00/221.60/0/0/-50.00/-50.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 100x200 | 100 | 100 | 100 | 0.000 | 0 | 1.000 m2 | IT.03.30847 | A2 | 6784Obj0000155848 | Objekt | 221.600/50.000/100.000/0.000/-50.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 222 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.64; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
501051x1x351x2x1x1x222x-50-503xx | Půdorys 1.NP | Kus | 0.755 | 501051x1x351x2x1x1x222x-50-503xx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/755.3000/100.0000/100.0000/2/755.3000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/755.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 0.755 m | IT.03.30848 | A2 | 6784Obj0000155851 | Objekt | 755.300/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.755 | 755 | __ISO | 0.04 | 0,041 W/m.K
152041x1x755xxxxxx0 | Půdorys 1.NP | Kus | 1.5 | 152041x1x755xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.950 m2 | IT.03.30849 | A2 | 6784Obj0000155865 | Objekt | 1500.000/245.000/120.000/0.000/-245.000/-120.000/0.000/0.000/0.000/1.000 | 1.95 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.18; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200
101044502x15xxxxxxx0 | Půdorys 1.NP | Kus | 1.5 | 101044502x15xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.950 m2 | IT.03.30850 | A2 | 6784Obj0000155879 | Objekt | 1500.000/245.000/120.000/0.000/-245.000/-120.000/0.000/0.000/0.000/1.000 | 1.95 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.19; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200
101044502x15xxxxxxx0 | Půdorys 1.NP | Kus | 0.557 | 101044502x15xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/557.3000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/557.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.000 m2 | IT.03.30851 | A2 | 6784Obj0000155893 | Objekt | 557.300/245.000/120.000/0.000/-245.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 557 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.20; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200
macro | Půdorys 1.NP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/200.00/200.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN200 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30852 | A2 | 6784Obj0000155930 | Objekt | 41940.351/25481.782/3210.000/41740.351/25171.782/3010.000/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/10; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.NP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/-1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/160.00/160.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN160 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30853 | A2 | 6784Obj0000155944 | Objekt | 42835.152/18558.816/2825.106/42675.102/18248.772/2665.071/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/10; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.NP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30854 | A2 | 6784Obj0000155958 | Objekt | 53035.106/5109.500/3322.500/52725.106/4984.500/3197.500/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/12; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.NP | Kus | 0.35 | macro | ZG Klappe | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/-1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/630.00/200.00/350.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 |  | 630x200 | 1 | 1 | 1 | 0.000 | 0 |  | IT.03.30855 | A2 | 6784Obj0000155972 | Objekt | 55459.954/8349.993/3360.000/55109.954/7719.993/3160.000/0.000/0.000/0.000/1.000 | 0 | 350 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1; K_LISTVALUE_ISO: 0.690 m2; K_DWGNAME: ${PROD}l\zentralgeräte\zg klappen\; K_DP_EBT: 0.00; K_DATE: 2023/01/11; N_FREI_68: Blech ST37 verzinkt
macro | Půdorys 1.NP | Kus | 0.35 | macro | ZG Klappe | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/-1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/280.00/200.00/350.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 |  | 280x200 | 1 | 1 | 1 | 0.000 | 0 |  | IT.03.30856 | A2 | 6784Obj0000155986 | Objekt | 52437.606/380.000/3360.000/52157.606/30.000/3160.000/0.000/0.000/0.000/1.000 | 0 | 350 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1; K_LISTVALUE_ISO: 0.450 m2; K_DWGNAME: ${PROD}l\zentralgeräte\zg klappen\; K_DP_EBT: 0.00; K_DATE: 2023/01/11; N_FREI_68: Blech ST37 verzinkt
macro | Půdorys 1.NP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30857 | A2 | 6784Obj0000156000 | Objekt | 52933.506/-2851.810/3010.500/52623.506/-2976.810/2885.500/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/10; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.NP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30858 | A2 | 6784Obj0000156014 | Objekt | 45070.574/5292.993/3172.500/44945.574/4982.993/3047.500/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/10; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.NP | Kus | 0.3 | macro | ZG Klappe | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/300.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30859 | A2 | 6784Obj0000156028 | Objekt | 45070.574/7350.000/3172.500/44945.574/7050.000/3047.500/0.000/0.000/0.000/1.000 | 1 | 300 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\zentralgeräte\zg klappen\; K_DP_EBT: 0.00; K_DATE: 2023/01/11; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.NP | Kus | 0.35 | macro | ZG Klappe | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/-1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/450.00/200.00/350.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 |  | 450x200 | 1 | 1 | 1 | 0.000 | 0 |  | IT.03.30860 | A2 | 6784Obj0000156042 | Objekt | 51248.089/8349.993/3020.000/50898.089/7899.993/2820.000/0.000/0.000/0.000/1.000 | 0 | 350 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.15; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1; K_LISTVALUE_ISO: 0.570 m2; K_DWGNAME: ${PROD}l\zentralgeräte\zg klappen\; K_DP_EBT: 0.00; K_DATE: 2023/01/11; N_FREI_68: Blech ST37 verzinkt
1x01044502x35xxxxxxx | Půdorys 1.NP | Kus | 0.957 | 1x01044502x35xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/957.3000/200.0000/200.0000/2/957.3000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/957.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.957 m | IT.03.30861 | A2 | 6784Obj0000156045 | Objekt | 957.300/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.957 | 957 | __ISO | 0.04 | 0,041 W/m.K
152062x2x957xxxxxx0 | Půdorys 1.NP | Kus | 4.796 | 152062x2x957xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/4796.3000/160.0000/160.0000/2/4796.3000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/4796.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 4.796 m | IT.03.30862 | A2 | 6784Obj0000156048 | Objekt | 4796.300/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 4.796 | 4796 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 3.616 m2
 | Půdorys 1.NP | Kus | 0.273 |  | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/272.9000/125.0000/125.0000/2/272.9000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/272.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.273 m | IT.03.30863 | A2 | 6784Obj0000156051 | Objekt | 272.900/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.273 | 273 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.176 m2
15204125125273xxxxxx0 | Půdorys 1.NP | Kus | 0.143 | 15204125125273xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/142.8613/160.0000/160.0000/2/142.8613/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/142.86/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.143 m | IT.03.30864 | A2 | 6784Obj0000156054 | Objekt | 142.861/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.143 | 143 | __ISO | 0.04 | 0,041 W/m.K
15204160160143xxxxxx0 | Půdorys 1.NP | Kus | 2.482 | 15204160160143xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/2481.6000/125.0000/125.0000/2/2481.6000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/2481.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 2.482 m | IT.03.30865 | A2 | 6784Obj0000156057 | Objekt | 2481.600/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 2.482 | 2482 | __ISO | 0.04 | 0,041 W/m.K
 | Půdorys 1.NP | Kus | 1.042 |  | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/200.0000/1/1042.2000/0/0/0/0/0/1.0000/315.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/200.00/1042.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x200 | 315 | 200 | 315 | 0.000 | 0 | 1.070 m2 | IT.03.30866 | A2 | 6784Obj0000156071 | Objekt | 1042.200/177.500/120.000/0.000/-177.500/-120.000/0.000/0.000/0.000/1.000 | 1.07 | 1042 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.410 m2
101043152x1042xxxxxx0 | Půdorys 1.NP | Kus | 0.25 | 101043152x1042xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/500.0000/200.0000/1/250.0000/0/0/0/0/0/1.0000/500.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/200.00/250.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 500x200 | 500 | 200 | 500 | 0.000 | 0 | 1.000 m2 | IT.03.30867 | A2 | 6784Obj0000156085 | Objekt | 250.000/270.000/120.000/0.000/-270.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 250 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.18; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200
101045x2x25xxxxxxx | Půdorys 1.NP | Kus | 1.5 | 101045x2x25xxxxxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/250.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/250.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x200 | 250 | 200 | 250 | 0.000 | 0 | 1.350 m2 | IT.03.30868 | A2 | 6784Obj0000156099 | Objekt | 1500.000/145.000/120.000/0.000/-145.000/-120.000/0.000/0.000/0.000/1.000 | 1.35 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.830 m2
101052502x15xxxxxxx0 | Půdorys 1.NP | Kus | 1.315 | 101052502x15xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/400.0000/200.0000/1/1315.0000/0/0/0/0/0/1.0000/400.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/200.00/1315.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x200 | 400 | 200 | 400 | 0.000 | 0 | 1.580 m2 | IT.03.30869 | A2 | 6784Obj0000156113 | Objekt | 1315.000/220.000/120.000/0.000/-220.000/-120.000/0.000/0.000/0.000/1.000 | 1.58 | 1315 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.83; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 2.000 m2
101054x2x1315xxxxxx0 | Půdorys 1.NP | Kus | 1.5 | 101054x2x1315xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/200.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x200 | 200 | 200 | 200 | 0.000 | 0 | 1.200 m2 | IT.03.30870 | A2 | 6784Obj0000156127 | Objekt | 1500.000/120.000/120.000/0.000/-120.000/-120.000/0.000/0.000/0.000/1.000 | 1.2 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.38; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.680 m2
101042x2x15xxxxxxx0 | Půdorys 1.NP | Kus | 1.5 | 101042x2x15xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/250.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/250.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x200 | 250 | 200 | 250 | 0.000 | 0 | 1.350 m2 | IT.03.30871 | A2 | 6784Obj0000156141 | Objekt | 1500.000/145.000/120.000/0.000/-145.000/-120.000/0.000/0.000/0.000/1.000 | 1.35 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.15; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.830 m2
101042502x15xxxxxxx0 | Půdorys 1.NP | Kus | 0.271 | 101042502x15xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/270.5000/125.0000/125.0000/2/270.5000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/270.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.271 m | IT.03.30872 | A2 | 6784Obj0000156144 | Objekt | 270.500/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.271 | 271 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.174 m2
15204125125271xxxxxx0 | Půdorys 1.NP | Kus | 0.266 | 15204125125271xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/265.5000/125.0000/125.0000/2/265.5000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/265.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.266 m | IT.03.30873 | A2 | 6784Obj0000156147 | Objekt | 265.500/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.266 | 266 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.171 m2
15204125125266xxxxxx0 | Půdorys 1.NP | Kus | 1.5 | 15204125125266xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/500.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/500.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 500x200 | 500 | 200 | 500 | 0.000 | 0 | 2.100 m2 | IT.03.30874 | A2 | 6784Obj0000156161 | Objekt | 1500.000/270.000/120.000/0.000/-270.000/-120.000/0.000/0.000/0.000/1.000 | 2.1 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.8; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 2.580 m2
101055x2x15xxxxxxx0 | Půdorys 1.NP | Kus | 0 | 101055x2x15xxxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/400.0000/400.0000/200.0000/1/297.4874/123.2233/0/45.0/0/0/1.0000/400.0000/200.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/400.00/0/50.00/50.00/200.00/100.00/45.00/0/1.00/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x200 | 400 | 200 | 400 | 0.000 | 0 | 1.000 m2 | IT.03.30875 | A2 | 6784Obj0000156243 | Objekt | 453.051/278.787/120.000/0.000/-220.000/-120.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
201044x4x050502x1x452xxxx0 | Půdorys 1.NP | Kus | 0.114 | 201044x4x050502x1x452xxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/400.0000/200.0000/1/114.0993/0/0/0/0/0/1.0000/400.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/200.00/114.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x200 | 400 | 200 | 400 | 0.000 | 0 | 1.000 m2 | IT.03.30876 | A2 | 6784Obj0000156257 | Objekt | 114.099/220.000/120.000/0.000/-220.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 114 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
101044x2x114xxxxxx0 | Půdorys 1.NP | Kus | 0 | 101044x2x114xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/180.0/400.0000/400.0000/200.0000/1/297.4874/123.2233/0/45.0/0/180.0/1.0000/400.0000/200.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/400.00/0/50.00/50.00/200.00/100.00/45.00/180.00/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x200 | 400 | 200 | 400 | 0.000 | 0 | 1.000 m2 | IT.03.30877 | A2 | 6784Obj0000156339 | Objekt | 453.051/278.787/120.000/0.000/-220.000/-120.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
201044x4x050502x1x452xxxx0 | Půdorys 1.NP | Kus | 0.62 | 201044x4x050502x1x452xxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/619.9000/160.0000/160.0000/2/619.9000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/619.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.620 m | IT.03.30878 | A2 | 6784Obj0000156342 | Objekt | 619.900/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.62 | 620 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.467 m2
1520616016062xxxxxxx | Půdorys 1.NP | Kus | 0.478 | 1520616016062xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/478.1000/100.0000/100.0000/2/478.1000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/478.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 0.478 m | IT.03.30879 | A2 | 6784Obj0000156345 | Objekt | 478.100/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.478 | 478 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.270 m2
152051x1x478xxxxxx0 | Půdorys 1.NP | Kus | 1.757 | 152051x1x478xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1757.0000/125.0000/125.0000/2/1757.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/1757.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.757 m | IT.03.30880 | A2 | 6784Obj0000156348 | Objekt | 1757.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1.757 | 1757 | __ISO | 0.04 | 0,041 W/m.K
 | Půdorys 1.NP | Kus | 1.5 |  | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.950 m2 | IT.03.30881 | A2 | 6784Obj0000156362 | Objekt | 1500.000/245.000/120.000/0.000/-245.000/-120.000/0.000/0.000/0.000/1.000 | 1.95 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.118; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 2.430 m2
152051x1x259xxxxxxx | Půdorys 1.NP | Kus | 0.881 | 152051x1x259xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/880.6000/100.0000/100.0000/2/880.6000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/880.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 0.881 m | IT.03.30882 | A2 | 6784Obj0000156368 | Objekt | 880.600/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.881 | 881 | __ISO | 0.04 | 0,041 W/m.K
152041x1x881xxxxxx0 | Půdorys 1.NP | Kus | 0.03 | 152041x1x881xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/200.0000/200.0000/2/30.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.030 m | IT.03.30883 | A2 | 6784Obj0000156371 | Objekt | 30.000/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.026 m2
152042x2x3xxxxxxx | Půdorys 1.NP | Kus | 0.303 | 152042x2x3xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/302.8000/160.0000/160.0000/2/302.8000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/302.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.303 m | IT.03.30884 | A2 | 6784Obj0000156374 | Objekt | 302.800/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.303 | 303 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.228 m2
15204160160303xxxxxx0 | Půdorys 1.NP | Kus | 0.451 | 15204160160303xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/451.2000/200.0000/200.0000/2/451.2000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/451.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.451 m | IT.03.30885 | A2 | 6784Obj0000156377 | Objekt | 451.200/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.451 | 451 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.397 m2
152042x2x451xxxxxx0 | Půdorys 1.NP | Kus | 0.219 | 152042x2x451xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/218.7258/160.0000/160.0000/2/218.7258/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/218.73/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.219 m | IT.03.30886 | A2 | 6784Obj0000156380 | Objekt | 218.726/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.219 | 219 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.165 m2
15205160160219xxxxxx0 | Půdorys 1.NP | Kus | 0.507 | 15205160160219xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/507.0000/100.0000/100.0000/2/507.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/507.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 0.507 m | IT.03.30887 | A2 | 6784Obj0000156383 | Objekt | 507.000/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.507 | 507 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.287 m2
152041x1x507xxxxxx0 | Půdorys 1.NP | Kus | 0.061 | 152041x1x507xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/61.4000/160.0000/160.0000/2/61.4000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/61.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.061 m | IT.03.30888 | A2 | 6784Obj0000156386 | Objekt | 61.400/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.061 | 61 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
1520416016061xxxxxx0 | Půdorys 1.NP | Kus | 1.5 | 1520416016061xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/315.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x200 | 315 | 200 | 315 | 0.000 | 0 | 1.550 m2 | IT.03.30889 | A2 | 6784Obj0000156400 | Objekt | 1500.000/177.500/120.000/0.000/-177.500/-120.000/0.000/0.000/0.000/1.000 | 1.55 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.8; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 2.030 m2
101043152x15xxxxxxx0 | Půdorys 1.NP | Kus | 1.443 | 101043152x15xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/280.0000/200.0000/1/1442.9000/0/0/0/0/0/1.0000/280.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/200.00/1442.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 280x200 | 280 | 200 | 280 | 0.000 | 0 | 1.390 m2 | IT.03.30890 | A2 | 6784Obj0000156414 | Objekt | 1442.900/160.000/120.000/0.000/-160.000/-120.000/0.000/0.000/0.000/1.000 | 1.39 | 1443 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.11; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.850 m2
101042802x1443xxxxxx0 | Půdorys 1.NP | Kus | 1.5 | 101042802x1443xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/315.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x200 | 315 | 200 | 315 | 0.000 | 0 | 1.550 m2 | IT.03.30891 | A2 | 6784Obj0000156428 | Objekt | 1500.000/177.500/120.000/0.000/-177.500/-120.000/0.000/0.000/0.000/1.000 | 1.55 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.15; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 2.030 m2
101043152x15xxxxxxx0 | Půdorys 1.NP | Kus | 1.002 | 101043152x15xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/1001.5000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/1001.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.300 m2 | IT.03.30892 | A2 | 6784Obj0000156442 | Objekt | 1001.500/245.000/120.000/0.000/-245.000/-120.000/0.000/0.000/0.000/1.000 | 1.3 | 1002 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.620 m2
101044502x1x2xxxxxx0 | Půdorys 1.NP | Kus | 1.5 | 101044502x1x2xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/200.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x200 | 200 | 200 | 200 | 0.000 | 0 | 1.200 m2 | IT.03.30893 | A2 | 6784Obj0000156456 | Objekt | 1500.000/120.000/120.000/0.000/-120.000/-120.000/0.000/0.000/0.000/1.000 | 1.2 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.38; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.680 m2
101042x2x15xxxxxxx0 | Půdorys 1.NP | Kus | 1.205 | 101042x2x15xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/1/1205.3000/0/0/0/0/0/1.0000/200.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/1205.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x200 | 200 | 200 | 200 | 0.000 | 0 | 0.960 m2 | IT.03.30894 | A2 | 6784Obj0000156470 | Objekt | 1205.300/120.000/120.000/0.000/-120.000/-120.000/0.000/0.000/0.000/1.000 | 0.96 | 1205 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.52; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.350 m2
101052x2x1205xxxxxx0 | Půdorys 1.NP | Kus | 1.5 | 101052x2x1205xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/280.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/280.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 280x200 | 280 | 200 | 280 | 0.000 | 0 | 1.440 m2 | IT.03.30895 | A2 | 6784Obj0000156484 | Objekt | 1500.000/160.000/120.000/0.000/-160.000/-120.000/0.000/0.000/0.000/1.000 | 1.44 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.66; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.920 m2
