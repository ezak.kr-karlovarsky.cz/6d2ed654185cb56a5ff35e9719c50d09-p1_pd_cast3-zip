Properties of the parts of a building model (IFC2X3), part 17 of 51

# IfcFlowFitting (2887)
Name | In | Jednotka | Délka (m) | Označení | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_DIM | L_BES_DIM_A2 | L_BES_DIM_B2 | L_BES_DIM_A | K_VOLSTROM | K_MLH_GOST = K_MLD_GOST | K_LISTVALUE | Kód prvku | Třída reakce na oheň | Allright_Stavebni_dil_ID | Název_objektu | K_EBT_BOX_WC | Plocha | L_BES_LAENGE | K_INTERNAL_ISO | Tloušťka (m) | Součinitel tepelné vodivost
252x1x01x13xxxxxx | Půdorys 1.PP | Kus | 0.057 | 252x1x01x13xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/57.1149/100.0000/100.0000/2/57.1149/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/57.11/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 0.057 m | IT.02.30666 | A1 | 6774Obj0000050081 | Objekt | 57.115/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.057 | 57 | __ISO | 0.04 | 0,041 W/m.K
152041x1x57xxxxxx0 | Půdorys 1.PP | Kus | 0 | 152041x1x57xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/199.6/100.0000/100.0000/100.0000/2/50.0000/13.3975/0/30.0/0/199.6/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/199.60/0/100.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 1.0 | IT.02.30667 | A1 | 6774Obj0000050085 | Objekt | 75.000/56.699/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1x01x13xxxxxx | Půdorys 1.PP | Kus | 0.07 | 252x1x01x13xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/69.5488/100.0000/100.0000/2/69.5488/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/69.55/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 0.070 m | IT.02.30668 | A1 | 6774Obj0000050088 | Objekt | 69.549/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.07 | 70 | __ISO | 0.04 | 0,041 W/m.K
macro | Půdorys 1.PP | Kus | 0.95 | macro | Schalldämpfer | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/-1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/315.00/400.00/950.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 |  | 315x400 | 1 | 1 | 1 | 0.000 | 0 |  | IT.02.30669 | A1 | 6774Obj0000050383 | Objekt | 26199.296/5687.074/-853.924/25884.296/4737.074/-1253.924/0.000/0.000/0.000/1.000 | 0 | 950 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.6; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1; K_DWGNAME: ${PROD}l\einbauteile\schalldaempfer\; K_DP_EBT: 0.00; K_DATE: 2023/01/17; N_FREI_68: Blech ST37 verzinkt
1x01043154x95xxxxxxx | Půdorys 1.PP | Kus | 0.265 | 1x01043154x95xxxxxxx | UEBERGANG ASYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/400.0000/1/265.0000/0.0260/120.0000/0/0/0/0/315.0000/160.0000/1/ | 41/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/50.00/50.00/400.00/160.00/0/265.00/-0.03/0.03/0/-240.00/55.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x400 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.02.30670 | A1 | 6774Obj0000050405 | Objekt | 265.000/177.526/220.000/0.000/-177.500/-220.000/0.000/0.000/0.000/1.000 | 1 | 265 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.9; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
4110431531550504x16x265-x0-24055 | Půdorys 1.PP | Kus | 0.3 | 4110431531550504x16x265-x0-24055 | UEBERGANG ASYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/315.0000/315.0000/160.0000/1/300.0000/0/-120.0000/0/0/0/0/315.0000/400.0000/1/ | 41/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/50.00/50.00/160.00/400.00/0/300.00/0/0/0/240.00/50.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 400 | 315 | 0.000 | 0 | 1.000 m2 | IT.02.30671 | A1 | 6774Obj0000050427 | Objekt | 300.000/177.500/100.000/0.000/-177.500/-340.000/0.000/0.000/0.000/1.000 | 1 | 300 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.5; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160
4110431531550501604x03xx02405xx | Půdorys 1.PP | Kus | 1 | 4110431531550501604x03xx02405xx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/1000.0000/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/1000.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 0.950 m2 | IT.02.30672 | A1 | 6774Obj0000050441 | Objekt | 1000.000/177.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 0.95 | 1000 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
macro | Půdorys 1.PP | Kus | 0.95 | macro | Schalldämpfer | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/-1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/800.00/150.00/950.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/40.00 |  | 800x150 | 1 | 1 | 1 | 0.000 | 0 |  | IT.02.30673 | A1 | 6774Obj0000050455 | Objekt | 24769.996/8787.671/-400.000/23819.996/7987.671/-550.000/0.000/0.000/0.000/1.000 | 0 | 950 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1; K_DWGNAME: ${PROD}l\einbauteile\schalldaempfer\; K_DP_EBT: 0.00; K_DATE: 2023/01/17; N_FREI_68: Blech ST37 verzinkt
1x01048x15095xxxxxxx | Půdorys 1.PP | Kus | 0.5 | 1x01048x15095xxxxxxx | UEBERGANG ASYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/800.0000/150.0000/1/500.0000/242.5000/-5.0000/0/0/0/0/315.0000/160.0000/1/ | 41/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/800.00/315.00/50.00/50.00/150.00/160.00/0/500.00/-485.00/0/0/10.00/50.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 800x150 | 315 | 160 | 800 | 0.000 | 0 | 1.320 m2 | IT.02.30674 | A1 | 6774Obj0000050477 | Objekt | 500.000/420.000/95.000/0.000/-420.000/-105.000/0.000/0.000/0.000/1.000 | 1.32 | 500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.11; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 150
411048x315505015016x5x-485x105xx | Půdorys 1.PP | Kus | 0.55 | 411048x315505015016x5x-485x105xx | UEBERGANG ASYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/800.0000/150.0000/1/550.0000/-242.5000/-5.0000/0/0/0/0/315.0000/160.0000/1/ | 41/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/800.00/315.00/50.00/50.00/150.00/160.00/0/550.00/0/-485.00/0/10.00/47.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 800x150 | 315 | 160 | 800 | 0.000 | 0 | 1.390 m2 | IT.02.30675 | A1 | 6774Obj0000050499 | Objekt | 550.000/420.000/95.000/0.000/-420.000/-105.000/0.000/0.000/0.000/1.000 | 1.39 | 550 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.14; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 150
1010431516xxxxxxx0 | Půdorys 1.PP | Kus | 0 | 1010431516xxxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/180.0/315.0000/315.0000/160.0000/1/307.5000/307.5000/0/90.0/0/180.0/1.0000/315.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/0/50.00/50.00/160.00/100.00/90.00/180.00/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.02.30676 | A1 | 6774Obj0000050600 | Objekt | 485.000/307.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.18; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.030 m2
20104315315050501601x9016xxxx | Půdorys 1.PP | Kus | 0.451 | 20104315315050501601x9016xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/450.9475/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/450.95/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.02.30677 | A1 | 6774Obj0000050614 | Konstrukce v aktuální hladině | 450.947/177.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1 | 451 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
10104315160451xxxxxx0 | Půdorys 1.PP | Kus | 0.301 | 10104315160451xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/301.3852/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/301.39/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.02.30678 | A1 | 6774Obj0000050628 | Objekt | 301.385/177.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1 | 301 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160
10104315160301xxxxxx0 | Půdorys 1.PP | Kus | 0 | 10104315160301xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/180.0/315.0000/315.0000/160.0000/1/222.0513/59.4985/0/30.0/0/180.0/1.0000/315.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/0/50.00/50.00/160.00/100.00/30.00/180.00/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.02.30679 | A1 | 6774Obj0000050710 | Objekt | 310.801/213.218/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160
20104315315050501601x3016xxxx | Půdorys 1.PP | Kus | 0.337 | 20104315315050501601x3016xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/336.6236/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/336.62/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.02.30680 | A1 | 6774Obj0000050724 | Objekt | 336.624/177.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1 | 337 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160
10104315160337xxxxxx0 | Půdorys 1.PP | Kus | 0 | 10104315160337xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/315.0000/315.0000/160.0000/1/222.0513/59.4985/0/30.0/0/0/1.0000/315.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/0/50.00/50.00/160.00/100.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.02.30681 | A1 | 6774Obj0000050806 | Objekt | 310.801/213.218/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160
20104315315050501601x3016xxxx | Půdorys 1.PP | Kus | 0.302 | 20104315315050501601x3016xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/301.6000/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/301.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.02.30682 | A1 | 6774Obj0000050820 | Objekt | 301.600/177.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1 | 302 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160
10104315160302xxxxxx0 | Půdorys 1.PP | Kus | 0.03 | 10104315160302xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.030 m | IT.02.30683 | A1 | 6774Obj0000050823 | Objekt | 30.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.019 m2
152041251253xxxxxxx | Půdorys 1.PP | Kus | 0.46 | 152041251253xxxxxxx | T-STCK. GERADE | 20 | 1016 | 3/0/0/0/180.0/0/180.0/315.0000/315.0000/160.0000/1/460.0000/0/0/0/0/180.0/1.0000/315.0000/160.0000/1/230.0000/307.5000/0/90.0/0/180.0/160.0000/160.0000/160.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/160.00/160.00/50.00/50.00/50.00/50.00/160.00/0/0/180.00/460.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.02.30684 | A1 | 6774Obj0000050879 | Objekt | 460.000/307.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1 | 460 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.20; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
701043153151601605050505016x046x | Půdorys 1.PP | Kus | 0.165 | 701043153151601605050505016x046x | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/1/165.3000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/35.00/100.00/160.00/125.00/125.00/165.30/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 125 | 125 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30685 | A1 | 6774Obj0000050901 | Objekt | 165.300/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 165 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.37; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
50105160125351x160125125165-18-1 | Půdorys 1.PP | Kus | 0 | 50105160125351x160125125165-18-1 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/315.0000/315.0000/160.0000/1/307.5000/307.5000/0/90.0/0/0/1.0000/315.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/0/50.00/50.00/160.00/100.00/90.00/0/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.02.30686 | A1 | 6774Obj0000050983 | Objekt | 485.000/307.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160
20104315315050501601x9016xxxx | Půdorys 1.PP | Kus | 0.19 | 20104315315050501601x9016xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/190.3211/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/190.32/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.02.30687 | A1 | 6774Obj0000050997 | Objekt | 190.321/177.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1 | 190 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160
1010431516019xxxxxxx | Půdorys 1.PP | Kus | 0 | 1010431516019xxxxxxx | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/315.0000/315.0000/160.0000/1/307.5000/307.5000/0/90.0/0/0/1.0000/315.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/0/50.00/50.00/160.00/100.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.02.30688 | A1 | 6774Obj0000051079 | Objekt | 485.000/307.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160
20104315315050501601x9016xxxx | Půdorys 1.PP | Kus | 0.06 | 20104315315050501601x9016xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/60.3498/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/60.35/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.02.30689 | A1 | 6774Obj0000051093 | Objekt | 60.350/177.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1 | 60 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160
macro | Půdorys 1.PP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/-1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.02.30690 | A1 | 6774Obj0000051107 | Objekt | 19179.614/12457.170/-417.297/19054.614/12147.170/-542.297/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2022/11/04; N_FREI_68: SPIRO POTRUBÍ
 | Půdorys 1.PP | Kus | 0.21 |  | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/209.6844/125.0000/125.0000/2/209.6844/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/209.68/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.210 m | IT.02.30691 | A1 | 6774Obj0000051110 | Objekt | 209.684/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.21 | 210 | __ISO | 0.04 | 0,041 W/m.K
1520412512521xxxxxxx | Půdorys 1.PP | Kus | 0 | 1520412512521xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/293.4/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/293.4/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/293.40/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30692 | A1 | 6774Obj0000051113 | Objekt | 48.529/64.630/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125115xxxxx0 | Půdorys 1.PP | Kus | 0.149 | 252x1250125115xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/149.3730/125.0000/125.0000/2/149.3730/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/149.37/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.149 m | IT.02.30693 | A1 | 6774Obj0000051116 | Objekt | 149.373/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.149 | 149 | __ISO | 0.04 | 0,041 W/m.K
15204125125149xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15204125125149xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/114.1/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/114.1/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/114.10/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30694 | A1 | 6774Obj0000051119 | Objekt | 48.529/64.630/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125115xxxxx0 | Půdorys 1.PP | Kus | 0.21 | 252x1250125115xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/209.6785/125.0000/125.0000/2/209.6785/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/209.68/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.210 m | IT.02.30695 | A1 | 6774Obj0000051122 | Objekt | 209.679/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.21 | 210 | __ISO | 0.04 | 0,041 W/m.K
1520412512521xxxxxxx | Půdorys 1.PP | Kus | 1.088 | 1520412512521xxxxxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/1088.1603/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/1088.16/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.030 m2 | IT.02.30696 | A1 | 6774Obj0000051136 | Objekt | 1088.160/177.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1.03 | 1088 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160
 | Půdorys 1.PP | Kus | 0.831 |  | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/830.5468/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/830.55/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.02.30697 | A1 | 6774Obj0000051150 | Objekt | 830.547/177.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1 | 831 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160
15204125125xxxxxxx | Půdorys 1.PP | Kus | 1.431 | 15204125125xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1430.7000/125.0000/125.0000/2/1430.7000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/1430.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.431 m | IT.02.30698 | A1 | 6774Obj0000058064 | Objekt | 1430.700/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1.431 | 1431 | __ISO | 0.04 | 0,041 W/m.K
15204125125419xxxxxx0 | Půdorys 1.PP | Kus | 0.723 | 15204125125419xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/723.0000/125.0000/125.0000/2/723.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/723.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.723 m | IT.02.30466 | A1 | 6774Obj0000046787 | Konstrukce v aktuální hladině | 723.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.723 | 723 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.466 m2
1x01058x5x2xxxxxxx0 | Půdorys 1.PP | Kus | 0 | 1x01058x5x2xxxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/180.0/1000.0000/1000.0000/225.0000/1/650.0000/650.0000/0/90.0/0/180.0/1.0000/1000.0000/225.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/1000.00/1000.00/0/50.00/50.00/225.00/100.00/90.00/180.00/2.00/225.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 30/SB 30/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1000x225 | 1000 | 225 | 1000 | 0.000 | 0 | 4.710 m2 | IT.02.30160 | A2 | 6774Obj0000051234 | Objekt | 1170.000/650.000/132.500/0.000/-520.000/-132.500/0.000/0.000/0.000/1.000 | 4.71 |  | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.32; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 225
101055604x732xxxxxx0 | Půdorys 1.PP | Kus | 0.451 | 101055604x732xxxxxx0 | UEBERGANG ASYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/1000.0000/225.0000/1/451.1000/120.0192/-0/0/0/0/0/560.0000/400.0000/1/ | 41/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/1000.00/560.00/50.00/50.00/225.00/400.00/0/451.10/-340.02/-99.98/87.50/87.50/44.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 30/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1000x225 | 560 | 400 | 1000 | 0.000 | 0 | 1.380 m2 | IT.02.30161 | A2 | 6774Obj0000051298 | Objekt | 451.100/520.000/220.000/0.000/-520.000/-220.000/0.000/0.000/0.000/1.000 | 1.38 | 451 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.18; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 225
101055604x42xxxxxx0 | Půdorys 1.PP | Kus | 0 | 101055604x42xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/560.0000/560.0000/400.0000/1/430.0000/430.0000/0/90.0/0/0/1.0000/560.0000/400.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/0/50.00/50.00/400.00/100.00/90.00/0/1.00/400.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 2.180 m2 | IT.02.30162 | A2 | 6774Obj0000051870 | Objekt | 730.000/430.000/220.000/0.000/-300.000/-220.000/0.000/0.000/0.000/1.000 | 2.18 |  | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.20; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
2010556056x50504x1x904xxxx0 | Půdorys 1.PP | Kus | 1.019 | 2010556056x50504x1x904xxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/1019.0000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/1019.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 1.960 m2 | IT.02.30163 | A2 | 6774Obj0000051884 | Objekt | 1019.000/300.000/220.000/0.000/-300.000/-220.000/0.000/0.000/0.000/1.000 | 1.96 | 1019 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
4110586056050507604x0492-150-150 | Půdorys 1.PP | Kus | 0.358 | 4110586056050507604x0492-150-150 | UEBERGANG ASYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/860.0000/760.0000/1/357.8000/0/-1.5000/0/0/0/0/560.0000/400.0000/1/ | 41/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/860.00/560.00/50.00/50.00/760.00/400.00/0/357.80/-150.00/-150.00/-181.50/-178.50/35.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 30/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 860x760 | 560 | 400 | 860 | 0.000 | 0 | 1.300 m2 | IT.02.30164 | A2 | 6774Obj0000051928 | Objekt | 357.800/450.000/400.000/0.000/-450.000/-400.000/0.000/0.000/0.000/1.000 | 1.3 | 358 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.6; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 760
4110586056050507604x0358-150-150 | Půdorys 1.PP | Kus | 0.1 | 4110586056050507604x0358-150-150 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/860.0000/760.0000/1/100.0000/0/0/0/0/0/1.0000/860.0000/760.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/860.00/760.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 30/SB 30/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 860x760 | 860 | 760 | 860 | 0.000 | 0 | 1.000 m2 | IT.02.30165 | A2 | 6774Obj0000051942 | Objekt | 100.000/450.000/400.000/0.000/-450.000/-400.000/0.000/0.000/0.000/1.000 | 1 | 100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 760
macro | Půdorys 1.PP | Kus | 1.5 | macro | Schalldämpfer | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/0/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/560.00/400.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 |  | 560x400 | 1 | 1 | 1 | 0.000 | 0 |  | IT.02.30166 | A2 | 6774Obj0000051984 | Objekt | 59301.309/7410.000/-880.000/57801.309/6850.000/-1280.000/0.000/0.000/0.000/1.000 | 0 | 1500 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.31; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1; K_DWGNAME: ${PROD}l\einbauteile\schalldaempfer\; K_DP_EBT: 0.00; K_DATE: 2023/01/13; N_FREI_68: Blech ST37 verzinkt
1x01055604x15xxxxxxx0 | Půdorys 1.PP | Kus | 0.516 | 1x01055604x15xxxxxxx0 | UEBERGANG ASYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/800.0000/800.0000/500.0000/1/515.7000/120.0000/-0/0/0/0/0/560.0000/400.0000/1/ | 41/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/800.00/560.00/50.00/50.00/500.00/400.00/0/515.70/-240.00/0/-50.00/-50.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 800x500 | 560 | 400 | 800 | 0.000 | 0 | 1.480 m2 | IT.02.30167 | A2 | 6774Obj0000052006 | Objekt | 515.700/420.000/270.000/0.000/-420.000/-270.000/0.000/0.000/0.000/1.000 | 1.48 | 516 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.11; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 500
411058x56050505x4x0516-24x-50-50 | Půdorys 1.PP | Kus | 1.5 | 411058x56050505x4x0516-24x-50-50 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/1500.0000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 2.880 m2 | IT.02.30168 | A2 | 6774Obj0000052020 | Objekt | 1500.000/300.000/220.000/0.000/-300.000/-220.000/0.000/0.000/0.000/1.000 | 2.88 | 1500 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.32; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
101055604x15xxxxxxx0 | Půdorys 1.PP | Kus | 0.5 | 101055604x15xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/500.0000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30169 | A2 | 6774Obj0000052034 | Objekt | 500.000/300.000/220.000/0.000/-300.000/-220.000/0.000/0.000/0.000/1.000 | 1 | 500 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.12; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
101055604x5xxxxxxx0 | Půdorys 1.PP | Kus | 0 | 101055604x5xxxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/90.0/560.0000/560.0000/400.0000/1/243.3013/65.1924/0/30.0/0/90.0/1.0000/560.0000/400.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/400.00/0/50.00/50.00/560.00/100.00/30.00/90.00/1.00/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30170 | A2 | 6774Obj0000052084 | Objekt | 353.301/255.718/300.000/0.000/-220.000/-300.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
201054x4x050505601x3056xxxx | Půdorys 1.PP | Kus | 0.399 | 201054x4x050505601x3056xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/399.2304/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/399.23/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30171 | A2 | 6774Obj0000052098 | Objekt | 399.230/300.000/220.000/0.000/-300.000/-220.000/0.000/0.000/0.000/1.000 | 1 | 399 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
101055604x399xxxxxx0 | Půdorys 1.PP | Kus | 0 | 101055604x399xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/90.0/560.0000/560.0000/400.0000/1/243.3013/65.1924/0/30.0/0/90.0/1.0000/560.0000/400.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/400.00/0/50.00/50.00/560.00/100.00/30.00/90.00/1.00/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30172 | A2 | 6774Obj0000052148 | Objekt | 353.301/255.718/300.000/0.000/-220.000/-300.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
201054x4x050505601x3056xxxx | Půdorys 1.PP | Kus | 0.886 | 201054x4x050505601x3056xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/886.3000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/886.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 1.700 m2 | IT.02.30173 | A2 | 6774Obj0000052162 | Objekt | 886.300/300.000/220.000/0.000/-300.000/-220.000/0.000/0.000/0.000/1.000 | 1.7 | 886 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.13; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
101055604x886xxxxxx0 | Půdorys 1.PP | Kus | 0 | 101055604x886xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/400.0000/400.0000/560.0000/1/297.4874/123.2233/0/45.0/0/0/1.0000/400.0000/560.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/400.00/0/50.00/50.00/560.00/100.00/45.00/0/0/560.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x560 | 400 | 560 | 400 | 0.000 | 0 | 1.000 m2 | IT.02.30174 | A2 | 6774Obj0000052212 | Objekt | 453.051/278.787/300.000/0.000/-220.000/-300.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.29; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 560
201054x4x050505601x4556xxxx | Půdorys 1.PP | Kus | 0.377 | 201054x4x050505601x4556xxxx | UEBERGANG ASYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/400.0000/400.0000/560.0000/1/377.1000/80.0000/80.0000/0/0/0/0/560.0000/400.0000/1/ | 41/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/560.00/50.00/50.00/560.00/400.00/0/377.10/0/160.00/0/-160.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x560 | 560 | 400 | 400 | 0.000 | 0 | 1.000 m2 | IT.02.30175 | A2 | 6774Obj0000052234 | Objekt | 377.100/380.000/300.000/0.000/-220.000/-300.000/0.000/0.000/0.000/1.000 | 1 | 377 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.30; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 560
1x01058x5x2xxxxxxx0 | Půdorys 1.PP | Kus | 0.384 | 1x01058x5x2xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/800.0000/500.0000/1/384.3000/0/0/0/0/0/1.0000/800.0000/500.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/800.00/500.00/384.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 800x500 | 800 | 500 | 800 | 0.000 | 0 | 1.000 m2 | IT.02.30176 | A2 | 6774Obj0000052262 | Objekt | 384.300/420.000/270.000/0.000/-420.000/-270.000/0.000/0.000/0.000/1.000 | 1 | 384 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.10; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 500
101058x5x384xxxxxx0 | Půdorys 1.PP | Kus | 0.1 | 101058x5x384xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/800.0000/500.0000/1/100.0000/0/0/0/0/0/1.0000/800.0000/500.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/800.00/500.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 800x500 | 800 | 500 | 800 | 0.000 | 0 | 1.000 m2 | IT.02.30177 | A2 | 6774Obj0000052276 | Objekt | 100.000/420.000/270.000/0.000/-420.000/-270.000/0.000/0.000/0.000/1.000 | 1 | 100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 500
101058x5x1xxxxxxx0 | Půdorys 1.PP | Kus | 0 | 101058x5x1xxxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/400.0000/400.0000/560.0000/1/297.4874/123.2233/0/45.0/0/0/1.0000/400.0000/560.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/400.00/0/50.00/50.00/560.00/100.00/45.00/0/0/560.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x560 | 400 | 560 | 400 | 0.000 | 0 | 1.000 m2 | IT.02.30178 | A2 | 6774Obj0000052326 | Objekt | 453.051/278.787/300.000/0.000/-220.000/-300.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.27; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 560
201054x4x050505601x4556xxxx | Půdorys 1.PP | Kus | 0.732 | 201054x4x050505601x4556xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/400.0000/560.0000/1/732.4000/0/0/0/0/0/1.0000/400.0000/560.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/560.00/732.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x560 | 400 | 560 | 400 | 0.000 | 0 | 1.410 m2 | IT.02.30179 | A2 | 6774Obj0000052340 | Objekt | 732.400/220.000/300.000/0.000/-220.000/-300.000/0.000/0.000/0.000/1.000 | 1.41 | 732 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.9; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 560
101054x560732xxxxxx0 | Půdorys 1.PP | Kus | 0 | 101054x560732xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/180.0/560.0000/560.0000/400.0000/1/430.0000/430.0000/0/90.0/0/180.0/1.0000/560.0000/400.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/0/50.00/50.00/400.00/100.00/90.00/180.00/1.00/400.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 2.180 m2 | IT.02.30180 | A2 | 6774Obj0000052382 | Objekt | 730.000/430.000/220.000/0.000/-300.000/-220.000/0.000/0.000/0.000/1.000 | 2.18 |  | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.23; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
2010556056x50504x1x904xxxx0 | Půdorys 1.PP | Kus | 0.377 | 2010556056x50504x1x904xxxx0 | UEBERGANG ASYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/560.0000/560.0000/400.0000/1/377.1000/0/-80.0000/0/0/0/0/400.0000/560.0000/1/ | 41/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/50.00/50.00/400.00/560.00/0/377.10/-80.00/-80.00/0/160.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 400 | 560 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30181 | A2 | 6774Obj0000052404 | Objekt | 377.100/300.000/220.000/0.000/-300.000/-380.000/0.000/0.000/0.000/1.000 | 1 | 377 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.25; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
411055604x50504x56x377-80-8x1603 | Půdorys 1.PP | Kus | 0.361 | 411055604x50504x56x377-80-8x1603 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/400.0000/560.0000/1/361.0913/0/0/0/0/0/1.0000/400.0000/560.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/560.00/361.09/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x560 | 400 | 560 | 400 | 0.000 | 0 | 1.000 m2 | IT.02.30182 | A2 | 6774Obj0000052418 | Objekt | 361.091/220.000/300.000/0.000/-220.000/-300.000/0.000/0.000/0.000/1.000 | 1 | 361 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.26; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 560
macro | Půdorys 1.PP | Kus | 1.5 | macro | Schalldämpfer | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/0/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/560.00/400.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 1 | 1 | 1 | 0.000 | 0 |  | IT.02.30183 | A2 | 6774Obj0000052432 | Konstrukce v aktuální hladině | 56055.588/9436.813/-880.000/54555.588/8876.813/-1280.000/0.000/0.000/0.000/1.000 | 0 | 1500 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1; K_DWGNAME: ${PROD}l\einbauteile\schalldaempfer\; K_DP_EBT: 0.00; K_DATE: 2023/01/13; N_FREI_68: Blech ST37 verzinkt
1x01055604x15xxxxxxx0 | Půdorys 1.PP | Kus | 0 | 1x01055604x15xxxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/270.0/560.0000/560.0000/400.0000/1/243.3013/65.1924/0/30.0/0/270.0/1.0000/560.0000/400.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/400.00/0/50.00/50.00/560.00/100.00/30.00/270.00/1.00/400.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30184 | A2 | 6774Obj0000052482 | Objekt | 353.301/255.718/300.000/0.000/-220.000/-300.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
201054x4x050505601x3056xxxx | Půdorys 1.PP | Kus | 0.019 | 201054x4x050505601x3056xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/19.2304/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/19.23/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30185 | A2 | 6774Obj0000052496 | Objekt | 20.000/300.000/220.000/-0.770/-300.000/-220.000/0.000/0.000/0.000/1.000 | 1 | 19 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
101055604x19xxxxxx0 | Půdorys 1.PP | Kus | 0 | 101055604x19xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/270.0/560.0000/560.0000/400.0000/1/243.3013/65.1924/0/30.0/0/270.0/1.0000/560.0000/400.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/400.00/0/50.00/50.00/560.00/100.00/30.00/270.00/1.00/400.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30186 | A2 | 6774Obj0000052546 | Objekt | 353.301/255.718/300.000/0.000/-220.000/-300.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
201054x4x050505601x3056xxxx | Půdorys 1.PP | Kus | 0.462 | 201054x4x050505601x3056xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/461.9000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/461.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30187 | A2 | 6774Obj0000052560 | Objekt | 461.900/300.000/220.000/0.000/-300.000/-220.000/0.000/0.000/0.000/1.000 | 1 | 462 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
101055604x462xxxxxx0 | Půdorys 1.PP | Kus | 0.498 | 101055604x462xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/498.4181/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/498.42/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30188 | A2 | 6774Obj0000052574 | Objekt | 498.418/300.000/220.000/0.000/-300.000/-220.000/0.000/0.000/0.000/1.000 | 1 | 498 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
101055604xxxxxxxx | Půdorys 1.PP | Kus | 0.1 | 101055604xxxxxxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/800.0000/500.0000/1/100.0000/0/0/0/0/0/1.0000/800.0000/500.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/800.00/500.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 800x500 | 800 | 500 | 800 | 0.000 | 0 | 1.000 m2 | IT.02.30208 | A2 | 6774Obj0000053492 | Objekt | 100.000/420.000/270.000/0.000/-420.000/-270.000/0.000/0.000/0.000/1.000 | 1 | 100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.12; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 500
101058x5x1xxxxxxx0 | Půdorys 1.PP | Kus | 0.1 | 101058x5x1xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/800.0000/500.0000/1/100.0000/0/0/0/0/0/1.0000/800.0000/500.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/800.00/500.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 800x500 | 800 | 500 | 800 | 0.000 | 0 | 1.000 m2 | IT.02.30209 | A2 | 6774Obj0000053506 | Objekt | 100.000/420.000/270.000/0.000/-420.000/-270.000/0.000/0.000/0.000/1.000 | 1 | 100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 500
1x01058x5x2xxxxxxx0 | Půdorys 1.PP | Kus | 0.384 | 1x01058x5x2xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/800.0000/500.0000/1/384.3000/0/0/0/0/0/1.0000/800.0000/500.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/800.00/500.00/384.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 800x500 | 800 | 500 | 800 | 0.000 | 0 | 1.000 m2 | IT.02.30210 | A2 | 6774Obj0000053534 | Objekt | 384.300/420.000/270.000/0.000/-420.000/-270.000/0.000/0.000/0.000/1.000 | 1 | 384 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.10; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 500
101058x5x384xxxxxx0 | Půdorys 1.PP | Kus | 1.5 | 101058x5x384xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/1500.0000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 2.880 m2 | IT.02.30211 | A2 | 6774Obj0000053548 | Konstrukce v aktuální hladině | 1500.000/300.000/220.000/0.000/-300.000/-220.000/0.000/0.000/0.000/1.000 | 2.88 | 1500 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.25; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
101045604x15xxxxxxx0 | Půdorys 1.PP | Kus | 1.5 | 101045604x15xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/1500.0000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 2.880 m2 | IT.02.30212 | A2 | 6774Obj0000053562 | Objekt | 1500.000/300.000/220.000/0.000/-300.000/-220.000/0.000/0.000/0.000/1.000 | 2.88 | 1500 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.26; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
101045604x15xxxxxxx0 | Půdorys 1.PP | Kus | 0.14 | 101045604x15xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/140.0000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/140.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30213 | A2 | 6774Obj0000053576 | Objekt | 140.000/300.000/220.000/0.000/-300.000/-220.000/0.000/0.000/0.000/1.000 | 1 | 140 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.27; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
101045604x14xxxxxxx | Půdorys 1.PP | Kus | 0.516 | 101045604x14xxxxxxx | UEBERGANG ASYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/515.7000/-120.0000/-72.5000/0/0/0/0/800.0000/500.0000/1/ | 41/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/800.00/50.00/50.00/400.00/500.00/0/515.70/240.00/-0.00/-22.50/122.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 800 | 500 | 560 | 0.000 | 0 | 1.480 m2 | IT.02.30214 | A2 | 6774Obj0000053598 | Objekt | 515.700/300.000/220.000/0.000/-540.000/-342.500/0.000/0.000/0.000/1.000 | 1.48 | 516 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.28; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
macro | Půdorys 1.PP | Kus | 1.05 | macro | Schalldämpfer | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/-1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/560.00/400.00/1050.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 |  | 560x400 | 1 | 1 | 1 | 0.000 | 0 |  | IT.02.30215 | A2 | 6774Obj0000053612 | Objekt | 59879.988/17100.000/-477.500/58829.988/16540.000/-877.500/0.000/0.000/0.000/1.000 | 0 | 1050 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1; K_DWGNAME: ${PROD}l\einbauteile\schalldaempfer\; K_DP_EBT: 0.00; K_DATE: 2023/01/18; N_FREI_68: Blech ST37 verzinkt
1x01045604x105xxxxxxx | Půdorys 1.PP | Kus | 0.45 | 1x01045604x105xxxxxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/450.0000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/450.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30216 | A2 | 6774Obj0000053626 | Objekt | 450.000/300.000/220.000/0.000/-300.000/-220.000/0.000/0.000/0.000/1.000 | 1 | 450 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; K_DWGNAME: ${PROD}l\einbauteile\schalldaempfer\; K_DP_EBT: 0.00; K_DATE: 2023/01/18; N_FREI_68: Blech ST37 verzinkt
101055604x982xxxxxx0 | Půdorys 1.PP | Kus | 0.03 | 101055604x982xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.030 m | IT.02.30001 | A2 | 6774Obj0000017581 | Objekt | 30.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K
101044x56029xxxxxxx | Půdorys 1.PP | Kus | 0 | 101044x56029xxxxxxx | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/400.0000/400.0000/560.0000/1/350.0000/350.0000/0/90.0/0/0/1.0000/400.0000/560.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/400.00/0/50.00/50.00/560.00/100.00/90.00/0/0/560.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x560 | 400 | 560 | 400 | 0.000 | 0 | 1.700 m2 | IT.02.30002 | A2 | 6774Obj0000017677 | Objekt | 570.000/350.000/300.000/0.000/-220.000/-300.000/0.000/0.000/0.000/1.000 | 1.7 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.28; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 560
201044x4x050505601x9056xxxx | Půdorys 1.PP | Kus | 0 | 201044x4x050505601x9056xxxx | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/560.0000/560.0000/400.0000/1/430.0000/430.0000/0/90.0/0/0/1.0000/560.0000/400.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/0/50.00/50.00/400.00/100.00/90.00/0/1.00/400.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 2.180 m2 | IT.02.30003 | A2 | 6774Obj0000017759 | Objekt | 730.000/430.000/220.000/0.000/-300.000/-220.000/0.000/0.000/0.000/1.000 | 2.18 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.43; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
2010456056x50504x1x904xxxx0 | Půdorys 1.PP | Kus | 0.45 | 2010456056x50504x1x904xxxx0 | T-STCK. GERADE | 20 | 1016 | 3/0/0/0/180.0/0/0/560.0000/560.0000/400.0000/1/450.0000/0/0/0/0/0/1.0000/560.0000/400.0000/1/225.0000/380.0000/0/90.0/0/0/250.0000/250.0000/400.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/250.00/250.00/0/0/0/0/400.00/0/0/0/450.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30004 | A2 | 6774Obj0000017807 | Objekt | 450.000/380.000/220.000/0.000/-300.000/-220.000/0.000/0.000/0.000/1.000 | 1 | 450 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.45; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
7010456056025025xx04xx45x1x1x90 | Půdorys 1.PP | Kus | 0.163 | 7010456056025025xx04xx45x1x1x90 | UEBERGANG ASYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/355.0000/1/163.2000/0/-14.0000/0/0/0/0/560.0000/400.0000/1/ | 41/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/50.00/50.00/355.00/400.00/0/163.20/0/0/8.50/36.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x355 | 560 | 400 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30005 | A2 | 6774Obj0000017829 | Objekt | 163.200/300.000/206.000/0.000/-300.000/-234.000/0.000/0.000/0.000/1.000 | 1 | 163 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.53; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355
