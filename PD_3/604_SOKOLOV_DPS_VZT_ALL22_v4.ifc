Properties of the parts of a building model (IFC2X3), part 29 of 51

# IfcFlowFitting (2887)
Name | In | Jednotka | Délka (m) | Označení | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_DIM | L_BES_DIM_A2 | L_BES_DIM_B2 | L_BES_DIM_A | K_VOLSTROM | K_MLH_GOST = K_MLD_GOST | K_LISTVALUE | Kód prvku | Třída reakce na oheň | Allright_Stavebni_dil_ID | Název_objektu | K_EBT_BOX_WC | Plocha | L_BES_LAENGE | K_INTERNAL_ISO | Tloušťka (m) | Součinitel tepelné vodivost
152042x2x117xxxxxx0 | Půdorys 1.NP | Kus | 0.207 | 152042x2x117xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/206.6143/200.0000/200.0000/2/206.6143/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/206.61/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.207 m | IT.03.30334 | B | 6784Obj0000164410 | Objekt | 206.614/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.207 | 207 | __ISO | 0.04 | 0,041 W/m.K
152042x2x76xxxxxx0 | Půdorys 1.NP | Kus | 0.09 | 152042x2x76xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/90.0000/200.0000/200.0000/2/90.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.090 m | IT.03.30336 | B | 6784Obj0000164416 | Objekt | 90.000/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.09 | 90 | __ISO | 0.04 | 0,041 W/m.K
152042x2x9xxxxxxx | Půdorys 1.NP | Kus | 0 | 152042x2x9xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/351.6/200.0000/200.0000/200.0000/2/141.4214/58.5786/0/45.0/0/351.6/200.0000/200.0000/200.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/351.60/0/200.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | IT.03.30337 | B | 6784Obj0000164420 | Objekt | 212.132/129.289/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
3020431525x031525x95-33-33-33-33 | Půdorys 1.NP | Kus | 0.23 | 3020431525x031525x95-33-33-33-33 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/230.0000/315.0000/315.0000/2/230.0000/0/0/0/0/0/315.0000/315.0000/315.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/230.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/70.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN315 | 315 | 315 | 315 | 0.000 | 0 | 0.230 m | IT.03.30339 | B | 6784Obj0000443842 | Objekt | 230.000/157.500/157.500/0.000/-157.500/-157.500/0.000/0.000/0.000/1.000 | 0.23 | 230 | __ISO | 0.07 | 0,041 W/m.K
3020431525x031525x116-33-33-33-3 | Půdorys 1.NP | Kus | 0.23 | 3020431525x031525x116-33-33-33-3 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/230.0000/315.0000/315.0000/2/230.0000/0/0/0/0/0/315.0000/315.0000/315.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/230.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/70.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN315 | 315 | 315 | 315 | 0.000 | 0 | 0.230 m | IT.03.30341 | B | 6784Obj0000443848 | Objekt | 230.000/157.500/157.500/0.000/-157.500/-157.500/0.000/0.000/0.000/1.000 | 0.23 | 230 | __ISO | 0.07 | 0,041 W/m.K
macro | Půdorys 1.NP | Kus | 0.3 | macro | Jalousieklappe JZ | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/-1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/200.00/200.00/300.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 |  | DN200 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30343 | B | 6784Obj0000443871 | Objekt | 28650.000/-7330.000/3200.000/28450.000/-7580.000/2900.000/0.000/0.000/0.000/1.000 | 1 | 300 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_DP_EBT: 0.00; K_DATE: 2023/01/18; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.NP | Kus | 0.085 | macro | Muffe | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/-1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/200.00/200.00/85.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 |  | DN200 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30345 | B | 6784Obj0000443888 | Objekt | 28656.002/-7343.997/2806.005/28443.998/-7556.003/2721.000/0.000/0.000/0.000/1.000 | 1 | 85 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\muffe-nippel\; K_DP_EBT: 0.00; K_DATE: 2023/01/18; N_FREI_68: SPIRO POTRUBÍ
152052502503xxxxxxx0 | Půdorys 1.NP | Kus | 0.102 | 152052502503xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/101.5000/250.0000/250.0000/2/101.5000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/101.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Alu kaschiert/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.102 m | IT.03.30349 | B | 6784Obj0000443930 | Objekt | 101.500/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 0.102 | 102 | __ISO | 0.05 | 0,041 W/m.K
1520416016047xxxxxx0 | Půdorys 1.NP | Kus | 3.61 | 1520416016047xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/3610.0000/160.0000/160.0000/2/3610.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/3610.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 3.610 m | IT.03.30315 | B | 6784Obj0000164338 | Objekt | 3610.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 3.61 | 3610 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 2.722 m2
-1104xxxxxxxx | Půdorys 1.NP | Kus | 0.781 | -1104xxxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/781.2000/250.0000/250.0000/2/781.2000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/781.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.781 m | IT.03.30321 | B | 6784Obj0000164358 | Objekt | 781.200/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 0.781 | 781 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.810 m2
152042x2x117xxxxxx0 | Půdorys 1.NP | Kus | 0.38 | 152042x2x117xxxxxx0 | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/0/250.0000/250.0000/250.0000/2/380.0000/0/0/0/0/0/1.0000/250.0000/250.0000/2/190.0000/190.0000/0/90.0/0/0/250.0000/250.0000/250.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/250.00/0/0/380.00/0/190.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | IT.03.30325 | B | 6784Obj0000164382 | Objekt | 380.000/190.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 1 | 380 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
152042x2x207xxxxxx0 | Půdorys 1.NP | Kus | 0.076 | 152042x2x207xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/75.7514/200.0000/200.0000/2/75.7514/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/75.75/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.076 m | IT.03.30335 | B | 6784Obj0000164413 | Objekt | 75.751/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.076 | 76 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.067 m2
252x25x25019xxxxxx | Půdorys 1.NP | Kus | 0.095 | 252x25x25019xxxxxx | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/315.0000/2/95.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/250.00/0/0/315.00/250.00/0/95.00/-32.50/-32.50/-32.50/-32.50/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/70.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN315 | 250 | 250 | 315 | 0.000 | 0 | 1.0 | IT.03.30338 | B | 6784Obj0000443839 | Objekt | 95.000/157.500/157.500/0.000/-157.500/-157.500/0.000/0.000/0.000/1.000 | 1 | 95 | __ISO | 0.07 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
1520431531523xxxxxxx | Půdorys 1.NP | Kus | 0.116 | 1520431531523xxxxxxx | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/315.0000/2/116.3000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/250.00/0/0/315.00/250.00/0/116.30/-32.50/-32.50/-32.50/-32.50/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/70.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN315 | 250 | 250 | 315 | 0.000 | 0 | 1.0 | IT.03.30340 | B | 6784Obj0000443845 | Objekt | 116.300/157.500/157.500/0.000/-157.500/-157.500/0.000/0.000/0.000/1.000 | 1 | 116 | __ISO | 0.07 | 0,041 W/m.K
15204250250439xxxxxx0 | Půdorys 1.NP | Kus | 0.3 | 15204250250439xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/300.0000/200.0000/200.0000/2/300.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/300.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.300 m | IT.03.30342 | B | 6784Obj0000443857 | Objekt | 300.000/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.3 | 300 | __ISO | 0.05 | 0,041 W/m.K
10152042x2x3xxxxxxx0 | Půdorys 1.NP | Kus | 0.094 | 10152042x2x3xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/94.0000/200.0000/200.0000/2/94.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/94.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.094 m | IT.03.30344 | B | 6784Obj0000443874 | Objekt | 94.000/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.094 | 94 | __ISO | 0.1 | 0,041 W/m.K
10152042x2x85xxxxxx0 | Půdorys 1.NP | Kus | 0.391 | 10152042x2x85xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/391.0000/200.0000/200.0000/2/391.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/391.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.391 m | IT.03.30346 | B | 6784Obj0000443891 | Objekt | 391.000/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.391 | 391 | __ISO | 0.1 | 0,041 W/m.K
1520625025xxxxxxx0 | Půdorys 1.NP | Kus | 0.25 | 1520625025xxxxxxx0 | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/250.0000/250.0000/2/250.0000/0/0/0/0/0/0/500.0000/250.0000/1/ | 50/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/250.00/500.00/70.00/100.00/250.00/250.00/250.00/250.00/125.00/125.00/0/0/57.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN250 | 500 | 250 | 250 | 0.000 | 0 | 1.000 m2 | IT.03.30347 | B | 6784Obj0000443924 | Objekt | 250.000/250.000/125.000/0.000/-250.000/-125.000/0.000/0.000/0.000/1.000 | 1 | 250 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); K_LISTVALUE_ISO: 1.000 m2
502162505x701x250250250250125125 | Půdorys 1.NP | Kus | 0.3 | 502162505x701x250250250250125125 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/300.0000/250.0000/250.0000/2/300.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/300.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Alu kaschiert/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.300 m | IT.03.30348 | B | 6784Obj0000443927 | Objekt | 300.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 0.3 | 300 | __ISO | 0.05 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.424 m2
152042x2x1xxxxxxx0 | Půdorys 1.NP | Kus | 0.21 | 152042x2x1xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/210.0000/250.0000/250.0000/2/210.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/210.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Alu kaschiert/50.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.210 m | IT.03.30350 | B | 6784Obj0000443953 | Objekt | 210.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 0.21 | 210 | __ISO | 0.05 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
1520425025021xxxxxxx | Půdorys 1.NP | Kus | 0.21 | 1520425025021xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/210.0000/200.0000/200.0000/2/210.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/210.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.210 m | IT.03.30351 | B | 6784Obj0000443956 | Objekt | 210.000/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.21 | 210 | __ISO | 0.05 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
152042x2x21xxxxxxx | Půdorys 1.NP | Kus | 0.22 | 152042x2x21xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/220.0000/250.0000/250.0000/2/220.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/220.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Alu kaschiert/50.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.220 m | IT.03.30352 | B | 6784Obj0000443959 | Objekt | 220.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 0.22 | 220 | __ISO | 0.05 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
1520425025022xxxxxxx | Půdorys 1.NP | Kus | 0 | 1520425025022xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/250.0000/250.0000/250.0000/2/250.0000/250.0000/0/90.0/0/90.0/250.0000/250.0000/250.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/90.00/0/250.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Alu kaschiert/50.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | IT.03.30353 | B | 6784Obj0000443962 | Objekt | 375.000/250.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.05 | 0,041 W/m.K
10152042x2x31xxxxxxx | Půdorys 1.NP | Kus | 0.058 | 10152042x2x31xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/58.4000/200.0000/200.0000/2/58.4000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/58.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.058 m | IT.03.30323 | B | 6784Obj0000164375 | Objekt | 58.400/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.058 | 58 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.051 m2
macro | Půdorys 1.NP | Kus | 0.35 | macro | ZG Klappe | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/-1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/315.00/200.00/350.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 |  | 315x200 | 1 | 1 | 1 | 0.000 | 0 |  | IT.03.30354 | A2 | 6784Obj0000148369 | Objekt | 55437.754/9075.718/3080.000/55087.754/8760.718/2880.000/0.000/0.000/0.000/1.000 | 0 | 350 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1; K_LISTVALUE_ISO: 0.470 m2; K_DWGNAME: ${PROD}l\zentralgeräte\zg klappen\; K_DP_EBT: 0.00; K_DATE: 2023/01/11; N_FREI_68: Blech ST37 verzinkt
macro | Půdorys 1.NP | Kus | 0.35 | macro | ZG Klappe | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/-1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/280.00/200.00/350.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 |  | 280x200 | 1 | 1 | 1 | 0.000 | 0 |  | IT.03.30355 | A2 | 6784Obj0000148383 | Objekt | 54970.300/379.592/3360.000/54690.300/29.592/3160.000/0.000/0.000/0.000/1.000 | 0 | 350 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1; K_LISTVALUE_ISO: 0.450 m2; K_DWGNAME: ${PROD}l\zentralgeräte\zg klappen\; K_DP_EBT: 0.00; K_DATE: 2023/01/11; N_FREI_68: Blech ST37 verzinkt
macro | Půdorys 1.NP | Kus | 0.31 | macro | Absperrklappe elektrisch NAK-E | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/100.00/100.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN100 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30356 | A2 | 6784Obj0000148425 | Objekt | 49176.900/23479.881/3160.000/48866.900/23354.881/3060.000/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_DP_EBT: 0.00; K_DATE: 2023/01/09; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.NP | Kus | 0.35 | macro | ZG Klappe | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/200.00/200.00/350.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN200 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30357 | A2 | 6784Obj0000148439 | Objekt | 53647.138/9700.018/3340.000/53447.138/9350.018/3140.000/0.000/0.000/0.000/1.000 | 1 | 350 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_DWGNAME: ${PROD}l\zentralgeräte\zg klappen\; K_DP_EBT: 0.00; K_DATE: 2023/01/12; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.NP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/160.00/160.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN160 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30358 | A2 | 6784Obj0000148453 | Objekt | 53627.138/10660.718/3320.000/53467.138/10350.718/3160.000/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/12; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.NP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/160.00/160.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN160 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30359 | A2 | 6784Obj0000148467 | Objekt | 54007.138/10215.718/3320.000/53697.138/10055.718/3160.000/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/12; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.NP | Kus | 0.35 | macro | ZG Klappe | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/-1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/560.00/355.00/350.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 |  | 560x355 | 1 | 1 | 1 | 0.000 | 0 |  | IT.03.30360 | A2 | 6784Obj0000148481 | Objekt | 55437.800/7300.000/3245.000/55087.800/6740.000/2890.000/0.000/0.000/0.000/1.000 | 0 | 350 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1; K_LISTVALUE_ISO: 0.750 m2; K_DWGNAME: ${PROD}l\zentralgeräte\zg klappen\; K_DP_EBT: 0.00; K_DATE: 2023/01/11; N_FREI_68: Blech ST37 verzinkt
1x010456035535xxxxxxx | Půdorys 1.NP | Kus | 0.75 | 1x010456035535xxxxxxx | T-STCK. GERADE | 20 | 1016 | 3/0/0/0/180.0/0/0/450.0000/450.0000/200.0000/1/750.0000/-162.5000/0/0/0/0/160.0000/125.0000/200.0000/1/375.0000/375.0000/0/90.0/0/0/450.0000/450.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/125.00/450.00/450.00/50.00/50.00/375.00/50.00/200.00/0/0/0/750.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 125 | 200 | 450 | 0.000 | 0 | 1.590 m2 | IT.03.30361 | A2 | 6784Obj0000148537 | Objekt | 750.000/375.000/120.000/0.000/-245.000/-120.000/0.000/0.000/0.000/1.000 | 1.59 | 750 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.120; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.980 m2
701044501254504505050375502xx75x | Půdorys 1.NP | Kus | 0.2 | 701044501254504505050375502xx75x | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/200.0000/1/200.0000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/35.00/100.00/200.00/125.00/125.00/200.00/0/0/-37.50/-37.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 125x200 | 125 | 125 | 125 | 0.000 | 0 | 1.000 m2 | IT.03.30362 | A2 | 6784Obj0000148559 | Objekt | 200.000/62.500/100.000/0.000/-62.500/-100.000/0.000/0.000/0.000/1.000 | 1 | 200 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.121; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
50105125125351x2x1251252xx-38-38 | Půdorys 1.NP | Kus | 0 | 50105125125351x2x1251252xx-38-38 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/270.0/450.0000/450.0000/200.0000/1/226.7767/93.9340/0/45.0/0/270.0/1.0000/450.0000/200.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/0/50.00/50.00/450.00/100.00/45.00/270.00/1.00/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.120 m2 | IT.03.30363 | A2 | 6784Obj0000148641 | Objekt | 311.630/178.787/245.000/0.000/-120.000/-245.000/0.000/0.000/0.000/1.000 | 1.12 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.120 m2
201052x2x050504501x4545xxxx | Půdorys 1.NP | Kus | 0.159 | 201052x2x050504501x4545xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/158.5786/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/158.58/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.000 m2 | IT.03.30364 | A2 | 6784Obj0000148655 | Objekt | 158.579/245.000/120.000/0.000/-245.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 159 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
101054502x159xxxxxx0 | Půdorys 1.NP | Kus | 0 | 101054502x159xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/270.0/450.0000/450.0000/200.0000/1/226.7767/93.9340/0/45.0/0/270.0/1.0000/450.0000/200.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/0/50.00/50.00/450.00/100.00/45.00/270.00/1.00/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.120 m2 | IT.03.30365 | A2 | 6784Obj0000148737 | Objekt | 311.630/178.787/245.000/0.000/-120.000/-245.000/0.000/0.000/0.000/1.000 | 1.12 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.120 m2
201052x2x050504501x4545xxxx | Půdorys 1.NP | Kus | 1.1 | 201052x2x050504501x4545xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/1100.0000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/1100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.430 m2 | IT.03.30366 | A2 | 6784Obj0000148751 | Objekt | 1100.000/245.000/120.000/0.000/-245.000/-120.000/0.000/0.000/0.000/1.000 | 1.43 | 1100 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.130; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.780 m2
101054502x11xxxxxxx0 | Půdorys 1.NP | Kus | 0.381 | 101054502x11xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/380.5000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/380.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.000 m2 | IT.03.30367 | A2 | 6784Obj0000148765 | Objekt | 380.500/245.000/120.000/0.000/-245.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 381 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.131; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
101054502x381xxxxxx0 | Půdorys 1.NP | Kus | 0 | 101054502x381xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/630.0000/630.0000/200.0000/1/465.0000/465.0000/0/90.0/0/0/1.0000/630.0000/200.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/630.00/630.00/0/50.00/50.00/200.00/100.00/90.00/0/1.00/200.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 630x200 | 630 | 200 | 630 | 0.000 | 0 | 2.070 m2 | IT.03.30368 | A2 | 6784Obj0000148847 | Objekt | 800.000/465.000/120.000/0.000/-335.000/-120.000/0.000/0.000/0.000/1.000 | 2.07 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.6; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 2.590 m2
2010463063x50502x1x902xxxx0 | Půdorys 1.NP | Kus | 1.5 | 2010463063x50502x1x902xxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/630.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/630.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/630.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 630x200 | 630 | 200 | 630 | 0.000 | 0 | 2.490 m2 | IT.03.30369 | A2 | 6784Obj0000148861 | Objekt | 1500.000/335.000/120.000/0.000/-335.000/-120.000/0.000/0.000/0.000/1.000 | 2.49 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.8; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 2.970 m2
101046302x15xxxxxxx0 | Půdorys 1.NP | Kus | 1.035 | 101046302x15xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/630.0000/200.0000/1/1034.8000/0/0/0/0/0/1.0000/630.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/630.00/200.00/1034.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 630x200 | 630 | 200 | 630 | 0.000 | 0 | 1.720 m2 | IT.03.30370 | A2 | 6784Obj0000148875 | Objekt | 1034.800/335.000/120.000/0.000/-335.000/-120.000/0.000/0.000/0.000/1.000 | 1.72 | 1035 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.11; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 2.050 m2
101046302x1035xxxxxx0 | Půdorys 1.NP | Kus | 0.555 | 101046302x1035xxxxxx0 | T-STCK. GERADE | 20 | 1016 | 3/0/0/0/180.0/0/0/630.0000/630.0000/200.0000/1/555.0000/-90.0000/0/0/0/0/1.0000/450.0000/200.0000/1/277.5000/415.0000/0/90.0/0/0/355.0000/355.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/630.00/450.00/355.00/355.00/0/0/180.00/0/200.00/0/0/0/555.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 630x200 | 450 | 200 | 630 | 0.000 | 0 | 1.230 m2 | IT.03.30371 | A2 | 6784Obj0000148925 | Objekt | 555.000/415.000/120.000/0.000/-335.000/-120.000/0.000/0.000/0.000/1.000 | 1.23 | 555 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.500 m2
70104630450355355x18x2xx55501x1x | Půdorys 1.NP | Kus | 0.05 | 70104630450355355x18x2xx55501x1x | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/355.0000/200.0000/1/50.0000/0/0/0/0/0/1.0000/355.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/355.00/200.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 355x200 | 355 | 200 | 355 | 0.000 | 0 | 1.000 m2 | IT.03.30372 | A2 | 6784Obj0000148939 | Objekt | 50.000/197.500/120.000/0.000/-197.500/-120.000/0.000/0.000/0.000/1.000 | 1 | 50 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.21; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
101043552x5xxxxxxx | Půdorys 1.NP | Kus | 1.16 | 101043552x5xxxxxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/1159.6000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/1159.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.510 m2 | IT.03.30373 | A2 | 6784Obj0000148953 | Objekt | 1159.600/245.000/120.000/0.000/-245.000/-120.000/0.000/0.000/0.000/1.000 | 1.51 | 1160 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.24; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.880 m2
101044502x116xxxxxxx | Půdorys 1.NP | Kus | 1.5 | 101044502x116xxxxxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/800.0000/1250.0000/1/1500.0000/0/0/0/0/0/1.0000/800.0000/1250.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/800.00/1250.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/1.00 | SB 30/SB 30/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 800x1250 | 800 | 1250 | 800 | 0.000 | 0 | 6.150 m2 | IT.03.30374 | A2 | 6784Obj0000148967 | Objekt | 1500.000/420.000/645.000/0.000/-420.000/-645.000/0.000/0.000/0.000/1.000 | 6.15 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.12; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1250; K_LISTVALUE_ISO: 6.630 m2
101048x125015xxxxxxx0 | Půdorys 1.NP | Kus | 1.5 | 101048x125015xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/800.0000/1250.0000/1/1500.0000/0/0/0/0/0/1.0000/800.0000/1250.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/800.00/1250.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/1.00 | SB 30/SB 30/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 800x1250 | 800 | 1250 | 800 | 0.000 | 0 | 6.150 m2 | IT.03.30375 | A2 | 6784Obj0000148981 | Objekt | 1500.000/420.000/645.000/0.000/-420.000/-645.000/0.000/0.000/0.000/1.000 | 6.15 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.13; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1250; K_LISTVALUE_ISO: 6.630 m2
101048x125015xxxxxxx0 | Půdorys 1.NP | Kus | 0.41 | 101048x125015xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/800.0000/1250.0000/1/410.0000/0/0/0/0/0/1.0000/800.0000/1250.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/800.00/1250.00/410.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/1.00 | SB 30/SB 30/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 800x1250 | 800 | 1250 | 800 | 0.000 | 0 | 1.680 m2 | IT.03.30376 | A2 | 6784Obj0000148995 | Objekt | 410.000/420.000/645.000/0.000/-420.000/-645.000/0.000/0.000/0.000/1.000 | 1.68 | 410 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.16; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1250; K_LISTVALUE_ISO: 1.810 m2
101048x125041xxxxxxx | Půdorys 1.NP | Kus | 0.85 | 101048x125041xxxxxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/800.0000/1250.0000/1/850.0000/0/0/0/0/0/1.0000/800.0000/1250.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/800.00/1250.00/850.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/1.00 | SB 30/SB 30/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 800x1250 | 800 | 1250 | 800 | 0.000 | 0 | 3.480 m2 | IT.03.30377 | A2 | 6784Obj0000149009 | Objekt | 850.000/420.000/645.000/0.000/-420.000/-645.000/0.000/0.000/0.000/1.000 | 3.48 | 850 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1250; K_LISTVALUE_ISO: 3.760 m2
101048x125085xxxxxxx | Půdorys 1.NP | Kus | 1.5 | 101048x125085xxxxxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/280.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/280.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 280x200 | 280 | 200 | 280 | 0.000 | 0 | 1.440 m2 | IT.03.30378 | A2 | 6784Obj0000149023 | Objekt | 1500.000/160.000/120.000/0.000/-160.000/-120.000/0.000/0.000/0.000/1.000 | 1.44 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.920 m2
101042802x15xxxxxxx0 | Půdorys 1.NP | Kus | 0 | 101042802x15xxxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/90.0/315.0000/315.0000/200.0000/1/193.3013/51.7949/0/30.0/0/90.0/1.0000/315.0000/200.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/0/50.00/50.00/315.00/100.00/30.00/90.00/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x200 | 315 | 200 | 315 | 0.000 | 0 | 1.000 m2 | IT.03.30379 | A2 | 6784Obj0000149105 | Objekt | 253.301/155.718/177.500/0.000/-120.000/-177.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
201052x2x050503151x30315xxx0 | Půdorys 1.NP | Kus | 0.353 | 201052x2x050503151x30315xxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/200.0000/1/352.8204/0/0/0/0/0/1.0000/315.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/200.00/352.82/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x200 | 315 | 200 | 315 | 0.000 | 0 | 1.000 m2 | IT.03.30380 | A2 | 6784Obj0000149119 | Objekt | 352.820/177.500/120.000/0.000/-177.500/-120.000/0.000/0.000/0.000/1.000 | 1 | 353 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
101053152x353xxxxxx0 | Půdorys 1.NP | Kus | 0 | 101053152x353xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/90.0/315.0000/315.0000/200.0000/1/193.3013/51.7949/0/30.0/0/90.0/1.0000/315.0000/200.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/0/50.00/50.00/315.00/100.00/30.00/90.00/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x200 | 315 | 200 | 315 | 0.000 | 0 | 1.000 m2 | IT.03.30381 | A2 | 6784Obj0000149201 | Objekt | 253.301/155.718/177.500/0.000/-120.000/-177.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
201052x2x050503151x30315xxx0 | Půdorys 1.NP | Kus | 0.112 | 201052x2x050503151x30315xxx0 | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/112.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 30/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/100.00/0/0/160.00/100.00/0/112.00/-30.00/-30.00/-30.00/-30.00/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 100 | 100 | 160 | 0.000 | 0 | 1.0 | IT.03.30382 | A2 | 6784Obj0000149204 | Objekt | 112.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 112 | __ISO | 0.04 | 0,041 W/m.K
302051601xx1601x0112-30-30-30-30 | Půdorys 1.NP | Kus | 0 | 302051601xx1601x0112-30-30-30-30 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/100.0000/100.0000/100.0000/2/70.7107/29.2893/0/45.0/0/90.0/100.0000/100.0000/100.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/90.00/0/100.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | IT.03.30383 | A2 | 6784Obj0000149207 | Objekt | 106.066/64.645/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1x01x145xxxxx0 | Půdorys 1.NP | Kus | 0.426 | 252x1x01x145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/426.2742/100.0000/100.0000/2/426.2742/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/426.27/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 0.426 m | IT.03.30384 | A2 | 6784Obj0000149210 | Objekt | 426.274/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.426 | 426 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.241 m2
152051x1x426xxxxxx0 | Půdorys 1.NP | Kus | 0 | 152051x1x426xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/100.0000/100.0000/100.0000/2/70.7107/29.2893/0/45.0/0/270.0/100.0000/100.0000/100.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/270.00/0/100.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | IT.03.30385 | A2 | 6784Obj0000149213 | Objekt | 106.066/64.645/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1x01x145xxxxx0 | Půdorys 1.NP | Kus | 1.5 | 252x1x01x145xxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/315.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x200 | 315 | 200 | 315 | 0.000 | 0 | 1.550 m2 | IT.03.30386 | A2 | 6784Obj0000149227 | Objekt | 1500.000/177.500/120.000/0.000/-177.500/-120.000/0.000/0.000/0.000/1.000 | 1.55 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.13; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 2.030 m2
101043152x15xxxxxxx0 | Půdorys 1.NP | Kus | 0.916 | 101043152x15xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/280.0000/200.0000/1/915.5680/0/0/0/0/0/1.0000/280.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/200.00/915.57/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 280x200 | 280 | 200 | 280 | 0.000 | 0 | 0.880 m2 | IT.03.30387 | A2 | 6784Obj0000149241 | Objekt | 915.568/160.000/120.000/0.000/-160.000/-120.000/0.000/0.000/0.000/1.000 | 0.88 | 916 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.170 m2
101042802x916xxxxxx0 | Půdorys 1.NP | Kus | 0.03 | 101042802x916xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.030 m | IT.03.30388 | A2 | 6784Obj0000149244 | Objekt | 30.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.019 m2
152041251253xxxxxxx | Půdorys 1.NP | Kus | 0.03 | 152041251253xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.030 m | IT.03.30389 | A2 | 6784Obj0000149247 | Objekt | 30.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.019 m2
152041251253xxxxxxx | Půdorys 1.NP | Kus | 0 | 152041251253xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/315.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/315.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/315.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.03.30390 | A2 | 6784Obj0000149250 | Objekt | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012519xxxxxx | Půdorys 1.NP | Kus | 0.293 | 252x125012519xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/293.4493/125.0000/125.0000/2/293.4493/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/293.45/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.293 m | IT.03.30391 | A2 | 6784Obj0000149253 | Objekt | 293.449/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.293 | 293 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.189 m2
15204125125293xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15204125125293xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.03.30392 | A2 | 6784Obj0000149256 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125145xxxxx0 | Půdorys 1.NP | Kus | 0.03 | 252x1250125145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.030 m | IT.03.30393 | A2 | 6784Obj0000149259 | Objekt | 30.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.019 m2
152041251253xxxxxxx | Půdorys 1.NP | Kus | 0 | 152041251253xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/315.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/315.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/315.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.03.30394 | A2 | 6784Obj0000149262 | Objekt | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012519xxxxxx | Půdorys 1.NP | Kus | 0.293 | 252x125012519xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/293.4493/125.0000/125.0000/2/293.4493/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/293.45/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.293 m | IT.03.30395 | A2 | 6784Obj0000149265 | Objekt | 293.449/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.293 | 293 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.189 m2
15204125125293xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15204125125293xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.03.30396 | A2 | 6784Obj0000149268 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125145xxxxx0 | Půdorys 1.NP | Kus | 0.03 | 252x1250125145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.030 m | IT.03.30397 | A2 | 6784Obj0000149271 | Objekt | 30.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.019 m2
152041251253xxxxxxx | Půdorys 1.NP | Kus | 0 | 152041251253xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/315.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/315.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/315.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.03.30398 | A2 | 6784Obj0000149274 | Objekt | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012519xxxxxx | Půdorys 1.NP | Kus | 0.293 | 252x125012519xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/293.4493/125.0000/125.0000/2/293.4493/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/293.45/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.293 m | IT.03.30399 | A2 | 6784Obj0000149277 | Objekt | 293.449/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.293 | 293 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.189 m2
15204125125293xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15204125125293xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.03.30400 | A2 | 6784Obj0000149280 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125145xxxxx0 | Půdorys 1.NP | Kus | 0.03 | 252x1250125145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.030 m | IT.03.30401 | A2 | 6784Obj0000149283 | Objekt | 30.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.019 m2
152041251253xxxxxxx | Půdorys 1.NP | Kus | 0 | 152041251253xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/315.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/315.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/315.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.03.30402 | A2 | 6784Obj0000149286 | Objekt | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012519xxxxxx | Půdorys 1.NP | Kus | 0.293 | 252x125012519xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/293.4493/125.0000/125.0000/2/293.4493/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/293.45/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.293 m | IT.03.30403 | A2 | 6784Obj0000149289 | Objekt | 293.449/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.293 | 293 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.189 m2
15204125125293xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15204125125293xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.03.30404 | A2 | 6784Obj0000149292 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125145xxxxx0 | Půdorys 1.NP | Kus | 0.03 | 252x1250125145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.030 m | IT.03.30405 | A2 | 6784Obj0000149295 | Objekt | 30.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.019 m2
152041251253xxxxxxx | Půdorys 1.NP | Kus | 0 | 152041251253xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/315.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/315.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/315.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.03.30406 | A2 | 6784Obj0000149298 | Objekt | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012519xxxxxx | Půdorys 1.NP | Kus | 0.293 | 252x125012519xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/293.4493/125.0000/125.0000/2/293.4493/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/293.45/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.293 m | IT.03.30407 | A2 | 6784Obj0000149301 | Objekt | 293.449/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.293 | 293 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.189 m2
15204125125293xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15204125125293xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.03.30408 | A2 | 6784Obj0000149304 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125145xxxxx0 | Půdorys 1.NP | Kus | 0.03 | 252x1250125145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/160.0000/160.0000/2/30.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.030 m | IT.03.30409 | A2 | 6784Obj0000149307 | Objekt | 30.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.023 m2
152041601603xxxxxxx | Půdorys 1.NP | Kus | 0.515 | 152041601603xxxxxxx | T-STCK. GERADE | 20 | 1016 | 3/0/0/0/180.0/0/180.0/280.0000/280.0000/200.0000/1/515.0000/-60.0000/0/0/0/180.0/1.0000/160.0000/200.0000/1/257.5000/240.0000/0/90.0/0/180.0/315.0000/315.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/160.00/315.00/315.00/0/0/120.00/0/200.00/0/0/180.00/515.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 280x200 | 160 | 200 | 280 | 0.000 | 0 | 1.000 m2 | IT.03.30410 | A2 | 6784Obj0000149357 | Objekt | 515.000/240.000/120.000/0.000/-160.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 515 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.11; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
70104280160315315x12x2xx51501x1x | Půdorys 1.NP | Kus | 0.17 | 70104280160315315x12x2xx51501x1x | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/200.0000/1/169.6000/0/0/0/0/0/0/160.0000/160.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/35.00/100.00/200.00/160.00/160.00/169.60/0/0/-20.00/-20.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x200 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.03.30411 | A2 | 6784Obj0000149379 | Objekt | 169.600/80.000/100.000/0.000/-80.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 170 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.12; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
