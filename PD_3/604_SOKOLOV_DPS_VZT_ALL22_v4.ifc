Properties of the parts of a building model (IFC2X3), part 51 of 51

# IfcFlowTerminal (86)
Name | In | Délka (m) | Název_objektu | Označení = K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_POSITION | K_DWGNAME | K_MATERIAL | K_ISOLATION | L_BES_DIM_A = L_BES_DIM_B | K_DP_EBT | K_VOLSTROM | K_DATE | N_FREI_68 | Kód prvku | Podlaží | Číslo místnosti | Šířka (m) | Výška (m) | Průměr | Jmenovitá velikost vstupu | Třída reakce na oheň | Průtok | Rychlost | Allright_Stavebni_dil_ID | Jednotka | K_NORM | K_PROFIL | L_BES_LAENGE | L_BES_DIM | L_BES_DIM_A2 = L_BES_DIM_B2 | K_MLH_GOST = K_MLD_GOST
Ablufttellerventil LVS | Půdorys 1.NP | 0 | Bodový prvek | Ablufttellerventil LVS | 120 | 1001 | 1/0/0/0/180.0/0/0/125.0000/0/125.0000/-1/ | 1001/30/-1/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/28.00/125.00/125.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/ | - | \\machn\allplan\v2018\std\prod\ess\l\auslaesse\lüftungsventile\ | Mat_12 |  | 125 | 0.000 | 120.00 | ? | Mat_12 | VV.03.3064 | Nadzemní podlaží 1.NP | K1.04 | 0.164 | 0.05 | 164 mm | 125 mm | A1 | 30 m3/hod | 0,9 m/s | 6782BP_0798478972 | Kus | NEMSOK - Index kóty: 0; K_LVZNR: K_LVZNR; K_Z_KOORD: M.2; A_ZETA_EBT: 0.00; L_LP_AIR_TYPE: 1; L_FREI_24: 0|0|0|0|0||; K_SYSTEMTYPE: 1; K_VD_TYPE: LP; K_MAXDELTAP: 0.000; K_DELTAP: 0.000; K_ZETA: 0.000; K_RWERT: 0.000; K_VD_DG: 0.000; K_VD_DN: 0.000; K_VD_DI: 0.000; K_VD_DA: 0.000; K_VD_A: 0.000; K_VD_B: 0.000; K_VD_QFORM: -1|0|2||0|; K_VD_ADN: 125.000; K_VD_BDN: 0.000; K_VD_V: 0.000; K_VD_R: 0.000; E_FREI_39: 1|30.00|20.00|0.000000|0.000000|-1; K_LISTVALUE: 1.0; N_FREI_62: 0; N_FREI_75: """""""""""""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;"""""""""""""""; N_FREI_76: """""""""""""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""""""""""; N_FREI_77: """""""""""""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""""""""""
ABL Regler konst. EN mit Antrieb | Půdorys 1.NP | 0.26 | Objekt | ABL Regler konst. EN mit Antrieb | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/0/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/320.00/160.00/260.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.2 | ${PROD}l\einbauteile\volumenstromregler konstant\ | Blech ST37 verzinkt/0.60 | Blech ummantelt/40.00 | 1 | 0.00 | 0.000 | 2023/01/04 | Blech ST37 verzinkt | KA.03.30110 | Nadzení podlaží 1.NP | K1.08 |  |  |  | 320x160 mm | B | 1,002 m3/s |  | 6782Obj0798481654 | Stk | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa) | SB 20/SB 20/// | 260 | 320x160 | 1 | 0 | NEMSOK - Dolní_hrana: 0 m; Horní_hrana: 0 m; K_LISTVALUE_ISO: 0.330 m2; Jmenovitá velikost výstupu: 320x160 mm; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
Ablufttellerventil LVS | Půdorys 1.NP | 0.028 | Konstrukce v aktuální hladině | Ablufttellerventil LVS | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/30/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/100.00/100.00/28.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.1 | ${PROD}l\auslässe\lüftungsventile\ | Plech ST37 pozink/0.70 | Mineralwolle/40.00 | 1 | 0.00 | 120.000 | 2022/09/29 | Plech ST37 pozink | VV.03.30033 | Nadzemní podlaží 1.NP | 1.33 |  |  | 100 mm | 100 mm | A1 | 50 m3/h | 1,7 | 6782Obj0798479283 | Stk | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa) | SB 20/SB 20/// | 28 | 100x100 | 1 | 0 | NEMSOK - A_ZETA_EBT: 0.00; L_LP_AIR_TYPE: 0; L_FREI_24: 0|0|0|0|0||; K_SYSTEMTYPE: 0; K_VD_TYPE: LP; K_MAXDELTAP: 0.000; K_DELTAP: 0.000; K_ZETA: 0.000; K_RWERT: 0.000; K_VD_DG: 0.000; K_VD_DN: 0.000; K_VD_DI: 0.000; K_VD_DA: 0.000; K_VD_A: 0.000; K_VD_B: 0.000; K_VD_QFORM: -1|0|2||0|; K_VD_ADN: 100.000; K_VD_BDN: 0.000; K_VD_V: 0.000; K_VD_R: 0.000; E_FREI_39: 1|30.00|20.00|0.000000|0.000000|-1; N_FREI_62: 0; N_FREI_75: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;"""""""; N_FREI_76: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""; N_FREI_77: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""; K_LISTVALUE_ISO: 0.020 m2; K_EBT_BOX_WC: 57499.892|31473.481|-50.730|57045.334|31018.923|-187.639|0.000|0.000|0.000|1.000
Ablufttellerventil LVS | Půdorys 1.NP | 0.028 | Konstrukce v aktuální hladině | Ablufttellerventil LVS | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/30/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/100.00/100.00/28.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.1 | ${PROD}l\auslässe\lüftungsventile\ | Plech ST37 pozink/0.70 | Mineralwolle/40.00 | 1 | 0.00 | 120.000 | 2022/09/29 | Plech ST37 pozink | VV.03.30039 | Nadzemní podlaží 1.NP | 1.07 |  |  | 100 mm | 100 mm | A1 | 50 m3/h | 1,7 | 6782Obj0798478870 | Stk | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa) | SB 20/SB 20/// | 28 | 100x100 | 1 | 0 | NEMSOK - A_ZETA_EBT: 0.00; L_LP_AIR_TYPE: 0; L_FREI_24: 0|0|0|0|0||; K_SYSTEMTYPE: 0; K_VD_TYPE: LP; K_MAXDELTAP: 0.000; K_DELTAP: 0.000; K_ZETA: 0.000; K_RWERT: 0.000; K_VD_DG: 0.000; K_VD_DN: 0.000; K_VD_DI: 0.000; K_VD_DA: 0.000; K_VD_A: 0.000; K_VD_B: 0.000; K_VD_QFORM: -1|0|2||0|; K_VD_ADN: 100.000; K_VD_BDN: 0.000; K_VD_V: 0.000; K_VD_R: 0.000; E_FREI_39: 1|30.00|20.00|0.000000|0.000000|-1; N_FREI_62: 0; N_FREI_75: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;"""""""; N_FREI_76: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""; N_FREI_77: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""; K_LISTVALUE_ISO: 0.020 m2; K_EBT_BOX_WC: 57499.892|31473.481|-50.730|57045.334|31018.923|-187.639|0.000|0.000|0.000|1.000
Ablufttellerventil LVS | Půdorys 1.NP | 0.028 | Konstrukce v aktuální hladině | Ablufttellerventil LVS | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/30/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/100.00/100.00/28.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.1 | ${PROD}l\auslässe\lüftungsventile\ | Plech ST37 pozink/0.70 | Mineralwolle/40.00 | 1 | 0.00 | 120.000 | 2022/09/29 | Plech ST37 pozink | VV.03.30040 | Nadzemní podlaží 1.NP | 1.32 |  |  | 100 mm | 100 mm | A1 | 25 m3/h | 0,9 | 6782Obj0798487082 | Stk | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa) | SB 20/SB 20/// | 28 | 100x100 | 1 | 0 | NEMSOK - A_ZETA_EBT: 0.00; L_LP_AIR_TYPE: 0; L_FREI_24: 0|0|0|0|0||; K_SYSTEMTYPE: 0; K_VD_TYPE: LP; K_MAXDELTAP: 0.000; K_DELTAP: 0.000; K_ZETA: 0.000; K_RWERT: 0.000; K_VD_DG: 0.000; K_VD_DN: 0.000; K_VD_DI: 0.000; K_VD_DA: 0.000; K_VD_A: 0.000; K_VD_B: 0.000; K_VD_QFORM: -1|0|2||0|; K_VD_ADN: 100.000; K_VD_BDN: 0.000; K_VD_V: 0.000; K_VD_R: 0.000; E_FREI_39: 1|30.00|20.00|0.000000|0.000000|-1; N_FREI_62: 0; N_FREI_75: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;"""""""; N_FREI_76: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""; N_FREI_77: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""; K_LISTVALUE_ISO: 0.020 m2; K_EBT_BOX_WC: 57499.892|31473.481|-50.730|57045.334|31018.923|-187.639|0.000|0.000|0.000|1.000
Ablufttellerventil LVS | Půdorys 1.NP | 0.028 | Konstrukce v aktuální hladině | Ablufttellerventil LVS | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/30/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/100.00/100.00/28.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.1 | ${PROD}l\auslässe\lüftungsventile\ | Plech ST37 pozink/0.70 | Mineralwolle/40.00 | 1 | 0.00 | 120.000 | 2022/09/29 | Plech ST37 pozink | VV.03.30041 | Nadzemní podlaží 1.NP | 1.31 |  |  | 100 mm | 100 mm | A1 | 25 m3/h | 0,9 | 6782Obj0798479643 | Stk | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa) | SB 20/SB 20/// | 28 | 100x100 | 1 | 0 | NEMSOK - A_ZETA_EBT: 0.00; L_LP_AIR_TYPE: 0; L_FREI_24: 0|0|0|0|0||; K_SYSTEMTYPE: 0; K_VD_TYPE: LP; K_MAXDELTAP: 0.000; K_DELTAP: 0.000; K_ZETA: 0.000; K_RWERT: 0.000; K_VD_DG: 0.000; K_VD_DN: 0.000; K_VD_DI: 0.000; K_VD_DA: 0.000; K_VD_A: 0.000; K_VD_B: 0.000; K_VD_QFORM: -1|0|2||0|; K_VD_ADN: 100.000; K_VD_BDN: 0.000; K_VD_V: 0.000; K_VD_R: 0.000; E_FREI_39: 1|30.00|20.00|0.000000|0.000000|-1; N_FREI_62: 0; N_FREI_75: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;"""""""; N_FREI_76: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""; N_FREI_77: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""; K_LISTVALUE_ISO: 0.020 m2; K_EBT_BOX_WC: 57499.892|31473.481|-50.730|57045.334|31018.923|-187.639|0.000|0.000|0.000|1.000
Ablufttellerventil LVS | Půdorys 1.NP | 0.028 | Konstrukce v aktuální hladině | Ablufttellerventil LVS | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/30/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/100.00/100.00/28.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.1 | ${PROD}l\auslässe\lüftungsventile\ | Plech ST37 pozink/0.70 | Mineralwolle/40.00 | 1 | 0.00 | 120.000 | 2022/09/29 | Plech ST37 pozink | VV.03.30047 | Nadzemní podlaží 1.NP | 1.28 |  |  | 100 mm | 100 mm | A1 | 30 m3/h | 1,1 | 6782Obj0798479498 | Stk | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa) | SB 20/SB 20/// | 28 | 100x100 | 1 | 0 | NEMSOK - A_ZETA_EBT: 0.00; L_LP_AIR_TYPE: 0; L_FREI_24: 0|0|0|0|0||; K_SYSTEMTYPE: 0; K_VD_TYPE: LP; K_MAXDELTAP: 0.000; K_DELTAP: 0.000; K_ZETA: 0.000; K_RWERT: 0.000; K_VD_DG: 0.000; K_VD_DN: 0.000; K_VD_DI: 0.000; K_VD_DA: 0.000; K_VD_A: 0.000; K_VD_B: 0.000; K_VD_QFORM: -1|0|2||0|; K_VD_ADN: 100.000; K_VD_BDN: 0.000; K_VD_V: 0.000; K_VD_R: 0.000; E_FREI_39: 1|30.00|20.00|0.000000|0.000000|-1; N_FREI_62: 0; N_FREI_75: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;"""""""; N_FREI_76: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""; N_FREI_77: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""; K_LISTVALUE_ISO: 0.020 m2; K_EBT_BOX_WC: 57499.892|31473.481|-50.730|57045.334|31018.923|-187.639|0.000|0.000|0.000|1.000
Ablufttellerventil LVS | Půdorys 1.NP | 0.028 | Konstrukce v aktuální hladině | Ablufttellerventil LVS | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/30/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/100.00/100.00/28.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.1 | ${PROD}l\auslässe\lüftungsventile\ | Plech ST37 pozink/0.70 | Mineralwolle/40.00 | 1 | 0.00 | 120.000 | 2022/09/29 | Plech ST37 pozink | VV.03.30048 | Nadzemní podlaží 1.NP | 1.28a |  |  | 100 mm | 100 mm | A1 | 50 m3/h | 1,8 | 6782Obj0798478863 | Stk | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa) | SB 20/SB 20/// | 28 | 100x100 | 1 | 0 | NEMSOK - A_ZETA_EBT: 0.00; L_LP_AIR_TYPE: 0; L_FREI_24: 0|0|0|0|0||; K_SYSTEMTYPE: 0; K_VD_TYPE: LP; K_MAXDELTAP: 0.000; K_DELTAP: 0.000; K_ZETA: 0.000; K_RWERT: 0.000; K_VD_DG: 0.000; K_VD_DN: 0.000; K_VD_DI: 0.000; K_VD_DA: 0.000; K_VD_A: 0.000; K_VD_B: 0.000; K_VD_QFORM: -1|0|2||0|; K_VD_ADN: 100.000; K_VD_BDN: 0.000; K_VD_V: 0.000; K_VD_R: 0.000; E_FREI_39: 1|30.00|20.00|0.000000|0.000000|-1; N_FREI_62: 0; N_FREI_75: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;"""""""; N_FREI_76: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""; N_FREI_77: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""; K_LISTVALUE_ISO: 0.020 m2; K_EBT_BOX_WC: 57499.892|31473.481|-50.730|57045.334|31018.923|-187.639|0.000|0.000|0.000|1.000
Ablufttellerventil LVS | Půdorys 1.NP | 0 | Bodový prvek | Ablufttellerventil LVS | 120 | 1001 | 1/0/0/0/180.0/0/0/160.0000/0/160.0000/-1/ | 1001/30/-1/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/28.00/160.00/160.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/ | - | \\machn\allplan\v2018\std\prod\ess\l\auslaesse\lüftungsventile\ | Mat_12 | Mineralwolle/40.00 | 160 | 0.000 | 120.00 | ? | Mat_12 | VV.03.30049 | Nadzemní podlaží 1.NP | 1.28b |  |  | 160 mm | 160 mm | A1 | 150 m3/h | 2,1 | 6782BP_0798478865 | Kus | NEMSOK - Index kóty: 0; K_LVZNR: K_LVZNR; K_Z_KOORD: M.2; A_ZETA_EBT: 0.00; L_LP_AIR_TYPE: 1; L_FREI_24: 0|0|0|0|0||; K_SYSTEMTYPE: 1; K_VD_TYPE: LP; K_MAXDELTAP: 0.000; K_DELTAP: 0.000; K_ZETA: 0.000; K_RWERT: 0.000; K_VD_DG: 0.000; K_VD_DN: 0.000; K_VD_DI: 0.000; K_VD_DA: 0.000; K_VD_A: 0.000; K_VD_B: 0.000; K_VD_QFORM: -1|0|2||0|; K_VD_ADN: 160.000; K_VD_BDN: 0.000; K_VD_V: 0.000; K_VD_R: 0.000; E_FREI_39: 1|30.00|20.00|0.000000|0.000000|-1; K_LISTVALUE: 1.0; N_FREI_62: 0; N_FREI_75: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;"""""""; N_FREI_76: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""; N_FREI_77: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""
Ablufttellerventil LVS | Půdorys 1.NP | 0.028 | Konstrukce v aktuální hladině | Ablufttellerventil LVS | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/30/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/100.00/100.00/28.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.1 | ${PROD}l\auslässe\lüftungsventile\ | Plech ST37 pozink/0.70 | Mineralwolle/40.00 | 1 | 0.00 | 120.000 | 2022/09/29 | Plech ST37 pozink | VV.03.30052 | Nadzemní podlaží 1.NP | 1.21 |  |  | 100 mm | 100 mm | A1 | 80 m3/h | 2,8 | 6782Obj0798479795 | Stk | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa) | SB 20/SB 20/// | 28 | 100x100 | 1 | 0 | NEMSOK - A_ZETA_EBT: 0.00; L_LP_AIR_TYPE: 0; L_FREI_24: 0|0|0|0|0||; K_SYSTEMTYPE: 0; K_VD_TYPE: LP; K_MAXDELTAP: 0.000; K_DELTAP: 0.000; K_ZETA: 0.000; K_RWERT: 0.000; K_VD_DG: 0.000; K_VD_DN: 0.000; K_VD_DI: 0.000; K_VD_DA: 0.000; K_VD_A: 0.000; K_VD_B: 0.000; K_VD_QFORM: -1|0|2||0|; K_VD_ADN: 100.000; K_VD_BDN: 0.000; K_VD_V: 0.000; K_VD_R: 0.000; E_FREI_39: 1|30.00|20.00|0.000000|0.000000|-1; N_FREI_62: 0; N_FREI_75: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;"""""""; N_FREI_76: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""; N_FREI_77: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""; K_LISTVALUE_ISO: 0.020 m2; K_EBT_BOX_WC: 57499.892|31473.481|-50.730|57045.334|31018.923|-187.639|0.000|0.000|0.000|1.000
Ablufttellerventil LVS | Půdorys 1.NP | 0.028 | Konstrukce v aktuální hladině | Ablufttellerventil LVS | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/30/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/100.00/100.00/28.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.1 | ${PROD}l\auslässe\lüftungsventile\ | Plech ST37 pozink/0.70 | Mineralwolle/40.00 | 1 | 0.00 | 120.000 | 2022/09/29 | Plech ST37 pozink | VV.03.30053 | Nadzemní podlaží 1.NP | 1.22 |  |  | 100 mm | 100 mm | A1 | 80 m3/h | 2,8 | 6782Obj0798479799 | Stk | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa) | SB 20/SB 20/// | 28 | 100x100 | 1 | 0 | NEMSOK - A_ZETA_EBT: 0.00; L_LP_AIR_TYPE: 0; L_FREI_24: 0|0|0|0|0||; K_SYSTEMTYPE: 0; K_VD_TYPE: LP; K_MAXDELTAP: 0.000; K_DELTAP: 0.000; K_ZETA: 0.000; K_RWERT: 0.000; K_VD_DG: 0.000; K_VD_DN: 0.000; K_VD_DI: 0.000; K_VD_DA: 0.000; K_VD_A: 0.000; K_VD_B: 0.000; K_VD_QFORM: -1|0|2||0|; K_VD_ADN: 100.000; K_VD_BDN: 0.000; K_VD_V: 0.000; K_VD_R: 0.000; E_FREI_39: 1|30.00|20.00|0.000000|0.000000|-1; N_FREI_62: 0; N_FREI_75: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;"""""""; N_FREI_76: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""; N_FREI_77: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""; K_LISTVALUE_ISO: 0.020 m2; K_EBT_BOX_WC: 57499.892|31473.481|-50.730|57045.334|31018.923|-187.639|0.000|0.000|0.000|1.000
Ablufttellerventil LVS | Půdorys 1.NP | 0.028 | Konstrukce v aktuální hladině | Ablufttellerventil LVS | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/30/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/100.00/100.00/28.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.1 | ${PROD}l\auslässe\lüftungsventile\ | Plech ST37 pozink/0.70 | Mineralwolle/40.00 | 1 | 0.00 | 120.000 | 2022/09/29 | Plech ST37 pozink | VV.03.30055 | Nadzemní podlaží 1.NP | 1.25 | 0.595 | 0.261 | - | 160 mm | A1 | 240 m3/h | 3,7 | 6782Obj0798479787 | Stk | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa) | SB 20/SB 20/// | 28 | 100x100 | 1 | 0 | NEMSOK - A_ZETA_EBT: 0.00; L_LP_AIR_TYPE: 0; L_FREI_24: 0|0|0|0|0||; K_SYSTEMTYPE: 0; K_VD_TYPE: LP; K_MAXDELTAP: 0.000; K_DELTAP: 0.000; K_ZETA: 0.000; K_RWERT: 0.000; K_VD_DG: 0.000; K_VD_DN: 0.000; K_VD_DI: 0.000; K_VD_DA: 0.000; K_VD_A: 0.000; K_VD_B: 0.000; K_VD_QFORM: -1|0|2||0|; K_VD_ADN: 100.000; K_VD_BDN: 0.000; K_VD_V: 0.000; K_VD_R: 0.000; E_FREI_39: 1|30.00|20.00|0.000000|0.000000|-1; N_FREI_62: 0; N_FREI_75: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;"""""""; N_FREI_76: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""; N_FREI_77: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""; K_LISTVALUE_ISO: 0.020 m2; K_EBT_BOX_WC: 57499.892|31473.481|-50.730|57045.334|31018.923|-187.639|0.000|0.000|0.000|1.000
Ablufttellerventil LVS | Půdorys 1.NP | 0 | Bodový prvek | Ablufttellerventil LVS | 120 | 1001 | 1/0/0/0/180.0/0/0/160.0000/0/160.0000/-1/ | 1001/30/-1/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/28.00/160.00/160.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/ | - | \\machn\allplan\v2018\std\prod\ess\l\auslaesse\lüftungsventile\ | Mat_12 | Mineralwolle/40.00 | 160 | 0.000 | 120.00 | ? | Mat_12 | VV.03.30056 | Nadzemní podlaží 1.NP | 1.26b |  |  | 160 mm | 160 mm | A1 | 150 m3/h | 2,1 | 6782BP_0798479543 | Kus | NEMSOK - Index kóty: 0; K_LVZNR: K_LVZNR; K_Z_KOORD: M.2; A_ZETA_EBT: 0.00; L_LP_AIR_TYPE: 1; L_FREI_24: 0|0|0|0|0||; K_SYSTEMTYPE: 1; K_VD_TYPE: LP; K_MAXDELTAP: 0.000; K_DELTAP: 0.000; K_ZETA: 0.000; K_RWERT: 0.000; K_VD_DG: 0.000; K_VD_DN: 0.000; K_VD_DI: 0.000; K_VD_DA: 0.000; K_VD_A: 0.000; K_VD_B: 0.000; K_VD_QFORM: -1|0|2||0|; K_VD_ADN: 160.000; K_VD_BDN: 0.000; K_VD_V: 0.000; K_VD_R: 0.000; E_FREI_39: 1|30.00|20.00|0.000000|0.000000|-1; K_LISTVALUE: 1.0; N_FREI_62: 0; N_FREI_75: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;"""""""; N_FREI_76: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""; N_FREI_77: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""
Ablufttellerventil LVS | Půdorys 1.NP | 0.028 | Konstrukce v aktuální hladině | Ablufttellerventil LVS | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/30/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/100.00/100.00/28.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.1 | ${PROD}l\auslässe\lüftungsventile\ | Plech ST37 pozink/0.70 | Mineralwolle/40.00 | 1 | 0.00 | 120.000 | 2022/09/29 | Plech ST37 pozink | VV.03.30057 | Nadzemní podlaží 1.NP | 1.26 |  |  | 100 mm | 100 mm | A1 | 40 m3/h | 1,6 | 6782Obj0798487258 | Stk | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa) | SB 20/SB 20/// | 28 | 100x100 | 1 | 0 | NEMSOK - A_ZETA_EBT: 0.00; L_LP_AIR_TYPE: 0; L_FREI_24: 0|0|0|0|0||; K_SYSTEMTYPE: 0; K_VD_TYPE: LP; K_MAXDELTAP: 0.000; K_DELTAP: 0.000; K_ZETA: 0.000; K_RWERT: 0.000; K_VD_DG: 0.000; K_VD_DN: 0.000; K_VD_DI: 0.000; K_VD_DA: 0.000; K_VD_A: 0.000; K_VD_B: 0.000; K_VD_QFORM: -1|0|2||0|; K_VD_ADN: 100.000; K_VD_BDN: 0.000; K_VD_V: 0.000; K_VD_R: 0.000; E_FREI_39: 1|30.00|20.00|0.000000|0.000000|-1; N_FREI_62: 0; N_FREI_75: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;"""""""; N_FREI_76: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""; N_FREI_77: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""; K_LISTVALUE_ISO: 0.020 m2; K_EBT_BOX_WC: 57499.892|31473.481|-50.730|57045.334|31018.923|-187.639|0.000|0.000|0.000|1.000
Ablufttellerventil LVS | Půdorys 1.NP | 0.028 | Konstrukce v aktuální hladině | Ablufttellerventil LVS | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/30/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/100.00/100.00/28.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.1 | ${PROD}l\auslässe\lüftungsventile\ | Plech ST37 pozink/0.70 | Mineralwolle/40.00 | 1 | 0.00 | 120.000 | 2022/09/29 | Plech ST37 pozink | VV.03.30058 | Nadzemní podlaží 1.NP | 1.26a |  |  | 100 mm | 100 mm | A1 | 50 m3/h | 1,8 | 6782Obj0798478882 | Stk | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa) | SB 20/SB 20/// | 28 | 100x100 | 1 | 0 | NEMSOK - A_ZETA_EBT: 0.00; L_LP_AIR_TYPE: 0; L_FREI_24: 0|0|0|0|0||; K_SYSTEMTYPE: 0; K_VD_TYPE: LP; K_MAXDELTAP: 0.000; K_DELTAP: 0.000; K_ZETA: 0.000; K_RWERT: 0.000; K_VD_DG: 0.000; K_VD_DN: 0.000; K_VD_DI: 0.000; K_VD_DA: 0.000; K_VD_A: 0.000; K_VD_B: 0.000; K_VD_QFORM: -1|0|2||0|; K_VD_ADN: 100.000; K_VD_BDN: 0.000; K_VD_V: 0.000; K_VD_R: 0.000; E_FREI_39: 1|30.00|20.00|0.000000|0.000000|-1; N_FREI_62: 0; N_FREI_75: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;"""""""; N_FREI_76: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""; N_FREI_77: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""; K_LISTVALUE_ISO: 0.020 m2; K_EBT_BOX_WC: 57499.892|31473.481|-50.730|57045.334|31018.923|-187.639|0.000|0.000|0.000|1.000
Ablufttellerventil LVS | Půdorys 1.NP | 0.028 | Konstrukce v aktuální hladině | Ablufttellerventil LVS | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/30/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/100.00/100.00/28.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.1 | ${PROD}l\auslässe\lüftungsventile\ | Plech ST37 pozink/0.70 | Mineralwolle/40.00 | 1 | 0.00 | 120.000 | 2022/09/29 | Plech ST37 pozink | VV.03.30059 | Nadzemní podlaží 1.NP | 1.17 |  |  | 100 mm | 100 mm | A1 | 50 m3/h | 1,8 | 6782Obj0798479839 | Stk | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa) | SB 20/SB 20/// | 28 | 100x100 | 1 | 0 | NEMSOK - A_ZETA_EBT: 0.00; L_LP_AIR_TYPE: 0; L_FREI_24: 0|0|0|0|0||; K_SYSTEMTYPE: 0; K_VD_TYPE: LP; K_MAXDELTAP: 0.000; K_DELTAP: 0.000; K_ZETA: 0.000; K_RWERT: 0.000; K_VD_DG: 0.000; K_VD_DN: 0.000; K_VD_DI: 0.000; K_VD_DA: 0.000; K_VD_A: 0.000; K_VD_B: 0.000; K_VD_QFORM: -1|0|2||0|; K_VD_ADN: 100.000; K_VD_BDN: 0.000; K_VD_V: 0.000; K_VD_R: 0.000; E_FREI_39: 1|30.00|20.00|0.000000|0.000000|-1; N_FREI_62: 0; N_FREI_75: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;"""""""; N_FREI_76: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""; N_FREI_77: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""; K_LISTVALUE_ISO: 0.020 m2; K_EBT_BOX_WC: 57499.892|31473.481|-50.730|57045.334|31018.923|-187.639|0.000|0.000|0.000|1.000
Zuluftgitter horizontal | Půdorys 1.NP | 0.06 | Konstrukce v aktuální hladině | Zuluftgitter horizontal | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/30/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/200.00/100.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.1 | ${PROD}l\auslässe\gitter zuluft\ | Plech ST37 pozink/0.70 |  | 1 | 0.00 | 120.000 | 2023/01/20 | Plech ST37 pozink | VV.03.30081 | Nadzemní podlaží 1.NP | 1.07 | 0.1 | 0.03 | - | - | A1 | 50 m3/h | 2,3 | 6782Obj0798492501 | Stk | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa) | SB 20/SB 20/// | 60 | 200x100 | 1 | 0 | NEMSOK - K_EBT_BOX_WC: 48697.000|13550.000|-49.375|48455.000|13367.500|-170.375|0.000|0.000|0.000|1.000
Abluftgitter horizontal | Půdorys 1.NP | 0.06 | Konstrukce v aktuální hladině | Abluftgitter horizontal | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/30/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/200.00/100.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.1 | ${PROD}l\auslässe\gitter abluft\ | Plech ST37 pozink/0.70 |  | 1 | 0.00 | 120.000 | 2023/01/20 | Plech ST37 pozink | VV.03.30082 | Nadzemní podlaží 1.NP | 1.30 | 0.1 | 0.03 | - | - | A1 | 50 m3/h | 2,3 | 6782Obj0798492490 | Stk | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa) | SB 20/SB 20/// | 60 | 200x100 | 1 | 0 | NEMSOK - K_EBT_BOX_WC: 48697.000|13755.468|-49.375|48455.000|13572.968|-170.375|0.000|0.000|0.000|1.000
Zuluftgitter horizontal | Půdorys 1.NP | 0.06 | Konstrukce v aktuální hladině | Zuluftgitter horizontal | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/30/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/200.00/100.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.1 | ${PROD}l\auslässe\gitter zuluft\ | Plech ST37 pozink/0.70 |  | 1 | 0.00 | 120.000 | 2023/01/20 | Plech ST37 pozink | VV.03.30083 | Nadzemní podlaží 1.NP | 1.31 | 0.1 | 0.03 | - | - | A1 | 50 m3/h | 2,3 | 6782Obj0798492503 | Stk | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa) | SB 20/SB 20/// | 60 | 200x100 | 1 | 0 | NEMSOK - K_EBT_BOX_WC: 48697.000|13550.000|-49.375|48455.000|13367.500|-170.375|0.000|0.000|0.000|1.000
Abluftgitter horizontal | Půdorys 1.NP | 0.06 | Konstrukce v aktuální hladině | Abluftgitter horizontal | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/30/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/200.00/100.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.1 | ${PROD}l\auslässe\gitter abluft\ | Plech ST37 pozink/0.70 |  | 1 | 0.00 | 120.000 | 2023/01/20 | Plech ST37 pozink | VV.03.30084 | Nadzemní podlaží 1.NP | 1.30 | 0.1 | 0.03 | - | - | A1 | 50 m3/h | 2,3 | 6782Obj0798492504 | Stk | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa) | SB 20/SB 20/// | 60 | 200x100 | 1 | 0 | NEMSOK - K_EBT_BOX_WC: 48697.000|13755.468|-49.375|48455.000|13572.968|-170.375|0.000|0.000|0.000|1.000
Abluftgitter horizontal | Půdorys 1.NP | 0.06 | Konstrukce v aktuální hladině | Abluftgitter horizontal | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/30/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/200.00/100.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.1 | ${PROD}l\auslässe\gitter abluft\ | Plech ST37 pozink/0.70 | Mineralwolle/40.00 | 1 | 0.00 | 120.000 | 2023/01/20 | Plech ST37 pozink | VV.03.30085 | Nadzemní podlaží 1.NP | 1.31 | 0.1 | 0.03 | - | - | A1 | 50 m3/h | 2,3 | 6782Obj0798492506 | Stk | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa) | SB 20/SB 20/// | 60 | 200x100 | 1 | 0 | NEMSOK - K_EBT_BOX_WC: 48697.000|13755.468|-49.375|48455.000|13572.968|-170.375|0.000|0.000|0.000|1.000
Zuluftgitter horizontal | Půdorys 1.NP | 0.06 | Konstrukce v aktuální hladině | Zuluftgitter horizontal | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/30/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/200.00/100.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.1 | ${PROD}l\auslässe\gitter zuluft\ | Plech ST37 pozink/0.70 | Mineralwolle/40.00 | 1 | 0.00 | 120.000 | 2023/01/20 | Plech ST37 pozink | VV.03.30086 | Nadzemní podlaží 1.NP | 1.32 | 0.1 | 0.03 | - | - | A1 | 50 m3/h | 2,3 | 6782Obj0798492505 | Stk | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa) | SB 20/SB 20/// | 60 | 200x100 | 1 | 0 | NEMSOK - K_EBT_BOX_WC: 48697.000|13550.000|-49.375|48455.000|13367.500|-170.375|0.000|0.000|0.000|1.000
ZG Klappe | Půdorys 1.NP | 0.35 | Konstrukce v aktuální hladině | ZG Klappe | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/-1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/315.00/200.00/350.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.2 | ${PROD}l\zentralgeräte\zg klappen\ | Blech ST37 verzinkt/0.60 | Mineralwolle/40.00 | 1 | 0.00 | 0.000 | 2023/01/11 | Blech ST37 verzinkt | KA.03.30023 | Nadzení podlaží 1.NP | 1.03 |  |  |  | 315x200 | - | 980 m3/h |  | 6782Obj0798485666 | Stk | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa) | SB 20/SB 20/// | 350 | 315x200 | 1 | 0 | NEMSOK - K_LISTVALUE_ISO: 0.470 m2; Jmenovitá velikost výstupu: 315x200; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
ZG Klappe | Půdorys 1.NP | 0.35 | Konstrukce v aktuální hladině | ZG Klappe | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/-1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/630.00/200.00/350.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.2 | ${PROD}l\zentralgeräte\zg klappen\ | Blech ST37 verzinkt/0.80 | Mineralwolle/40.00 | 1 | 0.00 | 0.000 | 2023/01/11 | Blech ST37 verzinkt | KA.03.30024 | Nadzení podlaží 1.NP | 1.03 |  |  |  | 630x200 | - | 2650 m3/h |  | 6782Obj0798485671 | Stk | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa) | SB 20/SB 20/// | 350 | 630x200 | 1 | 0 | NEMSOK - K_LISTVALUE_ISO: 0.690 m2; Jmenovitá velikost výstupu: 630x200; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
ZG Klappe | Půdorys 1.NP | 0.35 | Konstrukce v aktuální hladině | ZG Klappe | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/-1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/560.00/355.00/350.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.2 | ${PROD}l\zentralgeräte\zg klappen\ | Blech ST37 verzinkt/0.80 | Mineralwolle/40.00 | 1 | 0.00 | 0.000 | 2023/01/11 | Blech ST37 verzinkt | KA.03.30025 | Nadzení podlaží 1.NP | 1.03 |  |  |  | 560x355 | - | 4030 m3/h |  | 6782Obj0798485672 | Stk | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa) | SB 20/SB 20/// | 350 | 560x355 | 1 | 0 | NEMSOK - K_LISTVALUE_ISO: 0.750 m2; Jmenovitá velikost výstupu: 560x355; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
ZG Klappe | Půdorys 1.NP | 0.35 | Konstrukce v aktuální hladině | ZG Klappe | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/-1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/280.00/200.00/350.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.2 | ${PROD}l\zentralgeräte\zg klappen\ | Blech ST37 verzinkt/0.60 | Mineralwolle/40.00 | 1 | 0.00 | 0.000 | 2023/01/11 | Blech ST37 verzinkt | KA.03.30027 | Nadzení podlaží 1.NP | 1.03 |  |  |  | 280x200 | - | 850 m3/h |  | 6782Obj0798485916 | Stk | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa) | SB 20/SB 20/// | 350 | 280x200 | 1 | 0 | NEMSOK - K_LISTVALUE_ISO: 0.450 m2; Jmenovitá velikost výstupu: 280x200; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
ZG Klappe | Půdorys 1.NP | 0.35 | Konstrukce v aktuální hladině | ZG Klappe | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/-1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/280.00/200.00/350.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.2 | ${PROD}l\zentralgeräte\zg klappen\ | Blech ST37 verzinkt/0.60 | Mineralwolle/40.00 | 1 | 0.00 | 0.000 | 2023/01/11 | Blech ST37 verzinkt | KA.03.30028 | Nadzení podlaží 1.NP | 1.03 |  |  |  | 280x200 | - | 850 m3/h |  | 6782Obj0798485890 | Stk | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa) | SB 20/SB 20/// | 350 | 280x200 | 1 | 0 | NEMSOK - K_LISTVALUE_ISO: 0.450 m2; Jmenovitá velikost výstupu: 280x200; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
ABL Regler konst. EN mit Antrieb | Půdorys 1.NP | 0.35 | Konstrukce v aktuální hladině | ABL Regler konst. EN mit Antrieb | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/0/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/250.00/200.00/350.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.2 | ${PROD}l\einbauteile\volumenstromregler konstant\ | Blech ST37 verzinkt/0.60 | Mineralwolle/40.00 | 1 | 0.00 | 0.000 | 2023/01/17 | Blech ST37 verzinkt | KA.03.30031 | Nadzení podlaží 1.NP | 1.01b |  |  |  | 250x200 | - | 750 m3/h |  | 6782Obj0798490919 | Stk | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa) | SB 20/SB 20/// | 350 | 250x200 | 1 | 0 | NEMSOK - K_LISTVALUE_ISO: 0.320 m2; Jmenovitá velikost výstupu: 250x200; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
ABL Regler konst. EN mit Antrieb | Půdorys 1.NP | 0.35 | Konstrukce v aktuální hladině | ABL Regler konst. EN mit Antrieb | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/0/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/250.00/200.00/350.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.2 | ${PROD}l\einbauteile\volumenstromregler konstant\ | Blech ST37 verzinkt/0.60 | Mineralwolle/40.00 | 1 | 0.00 | 0.000 | 2023/01/17 | Blech ST37 verzinkt | KA.03.30032 | Nadzení podlaží 1.NP | 1.01b |  |  |  | 250x200 | - | 550 m3/h |  | 6782Obj0798490972 | Stk | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa) | SB 20/SB 20/// | 350 | 250x200 | 1 | 0 | NEMSOK - K_LISTVALUE_ISO: 0.320 m2; Jmenovitá velikost výstupu: 250x200; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
ZG Klappe | Půdorys 1.NP | 0.35 | Konstrukce v aktuální hladině | ZG Klappe | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/-1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/500.00/200.00/350.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.2 | ${PROD}l\zentralgeräte\zg klappen\ | Blech ST37 verzinkt/0.60 | Mineralwolle/40.00 | 1 | 0.00 | 0.000 | 2023/01/11 | Blech ST37 verzinkt | KA.03.30042 | Nadzení podlaží 1.NP | 1.05 |  |  |  | 500x200 | - | 1750 m3/h |  | 6782Obj0798485697 | Stk | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa) | SB 20/SB 20/// | 350 | 500x200 | 1 | 0 | NEMSOK - K_LISTVALUE_ISO: 0.600 m2; Jmenovitá velikost výstupu: 500x200; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
ZG Klappe | Půdorys 1.NP | 0.35 | Konstrukce v aktuální hladině | ZG Klappe | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/-1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/450.00/200.00/350.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.15 | ${PROD}l\zentralgeräte\zg klappen\ | Blech ST37 verzinkt/0.60 | Mineralwolle/40.00 | 1 | 0.00 | 0.000 | 2023/01/11 | Blech ST37 verzinkt | KA.03.30045 | Nadzení podlaží 1.NP | 1.06 |  |  |  | 450x200 | - | 1750 m3/h |  | 6782Obj0798486125 | Stk | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa) | SB 20/SB 20/// | 350 | 450x200 | 1 | 0 | NEMSOK - K_LISTVALUE_ISO: 0.570 m2; Jmenovitá velikost výstupu: 450x200; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
ZG Klappe | Půdorys 1.NP | 0.35 | Objekt | ZG Klappe | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/-1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/450.00/200.00/350.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.2 | ${PROD}l\zentralgeräte\zg klappen\ | Blech ST37 verzinkt/0.60 | Mineralwolle/0.00 | 1 | 0.00 | 0.000 | 2023/01/18 | Blech ST37 verzinkt | KA.03.30067 | Nadzení podlaží 1.NP | 1.10 |  |  |  | 450x200 | - | 1330 m3/h |  | 6782Obj0798492422 | Stk | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa) | SB 20/SB 20/// | 350 | 450x200 | 1 | 0 | NEMSOK - Dolní_hrana: 0 m; Horní_hrana: 0 m; K_LISTVALUE_ISO: 0.460 m2; Jmenovitá velikost výstupu: 450x200; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
Maschendraht-Gitter | Půdorys 2.NP | 0.05 | Konstrukce v aktuální hladině | Maschendraht-Gitter | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/-1/1/0/0/0/0/1000/0/-1/-1/-1/0/0/0/0/0/0/0/0/1250.00/1400.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.18 | ${PROD}l\einbauteile\ausblas\ | Blech ST37 verzinkt/1.00 | Alu kaschiert/100.00 | 1 | 0.00 | 0.000 | 2022/09/30 | Blech ST37 verzinkt | VV.04.30001 | Nadzemní podlaží 1.NP | - | 1.25 | 1.4 | - | 1250x1400 | A1 | 10000 m3/h | 2,2 m/s | 6792Obj0000000003 | Stk | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa) | SB 30/SB 30/// | 50 | 1250x1400 | 1 | 0
Maschendraht-Gitter | Půdorys střechy | 0.05 | Objekt | Maschendraht-Gitter | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/30/1/0/0/0/0/1000/0/-1/-1/-1/0/0/0/0/0/0/0/0/950.00/800.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.1 | ${PROD}l\einbauteile\ausblas\ | Plech ST37 pozink/0.70 | Alu kaschiert/100.00 | 1 | 0.00 | 1320.000 | 2022/10/04 | Plech ST37 pozink | VV.07.300001 | Nadzemní podlaží 5.NP | - | 1 | 0.8 | - | 1000x800 | A1 | 6000 m3/h | 3,0 m/s | 6882Obj0000000073 | Stk | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa) | SB 20/SB 20/// | 50 | 950x800 | 1 | 0 | NEMSOK - Dolní_hrana: 0 m; Horní_hrana: 0 m; K_LISTVALUE_ISO: 0.220 m2; K_EBT_BOX_WC: 29137.500|7108.000|71.500|29075.000|6745.000|-291.500|0.000|0.000|0.000|1.000
Maschendraht-Gitter | Půdorys střechy | 0.05 | Objekt | Maschendraht-Gitter | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/30/1/0/0/0/0/1000/0/-1/-1/-1/0/0/0/0/0/0/0/0/950.00/800.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.1 | ${PROD}l\einbauteile\ausblas\ | Plech ST37 pozink/0.70 | Alu kaschiert/100.00 | 1 | 0.00 | 1320.000 | 2022/10/04 | Plech ST37 pozink | VV.07.300002 | Nadzemní podlaží 5.NP | - | 1 | 0.8 | - | 1000x800 | A1 | 6000 m3/h | 3,0 m/s | 6882Obj0000000074 | Stk | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa) | SB 20/SB 20/// | 50 | 950x800 | 1 | 0 | NEMSOK - Dolní_hrana: 0 m; Horní_hrana: 0 m; K_LISTVALUE_ISO: 0.220 m2; K_EBT_BOX_WC: 29137.500|7108.000|71.500|29075.000|6745.000|-291.500|0.000|0.000|0.000|1.000
