Properties of the parts of a building model (IFC2X3), part 49 of 51

# IfcFlowSegment (1090)
Name | In | Jednotka | Délka (m) | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_LAENGE | L_BES_DIM | L_BES_DIM_A2 = L_BES_DIM_A | L_BES_DIM_B2 | K_VOLSTROM | K_LISTVALUE | Kód prvku | Podlaží | Průměr | Teplonosná látka | Allright_Stavebni_dil_ID | Název_objektu | Označení | K_LISTVALUE_ISO
101044502x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 450x200 | 450 | 200 | 0.000 | 1.950 m2 | PO.03.30314 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798489766 | Objekt | 101044502x15xxxxxxx0 | NEMSOK - K_POSITION: L.19; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.45 m; Výška: 0.2 m
101044502x557xxxxxx0 | Půdorys 1.NP | m2 | 0.557 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/557.3000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/557.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 557 | 450x200 | 450 | 200 | 0.000 | 1.000 m2 | PO.03.30315 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798489781 | Objekt | 101044502x557xxxxxx0 | NEMSOK - K_POSITION: L.20; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.45 m; Výška: 0.2 m
15204125125206xxxxxx0 | Půdorys 1.NP | m | 0.206 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/205.5962/125.0000/125.0000/2/205.5962/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/205.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 206 | DN125 | 125 | 125 | 0.000 | 0.206 m | PO.03.30316 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798489816 | Objekt | 15204125125206xxxxxx0
15204125125585xxxxxx0 | Půdorys 1.NP | m | 0.585 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/275.0000/125.0000/125.0000/2/275.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/275.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 275 | DN125 | 125 | 125 | 0.000 | 0.275 m | PO.03.30317 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798489828 | Objekt | 15204125125585xxxxxx0 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 585.000|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
101045x2x6xxxxxxx0 | Půdorys 1.NP | m2 | 0.6 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/500.0000/200.0000/1/600.0000/0/0/0/0/0/1.0000/500.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/200.00/600.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 600 | 500x200 | 500 | 200 | 0.000 | 1.000 m2 | PO.03.30318 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798489846 | Objekt | 101045x2x6xxxxxxx0 | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.5 m; Výška: 0.2 m
101045x2x837xxxxxx0 | Půdorys 1.NP | m2 | 0.837 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/500.0000/200.0000/1/836.5000/0/0/0/0/0/1.0000/500.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/200.00/836.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 837 | 500x200 | 500 | 200 | 0.000 | 1.170 m2 | PO.03.30319 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798489861 | Objekt | 101045x2x837xxxxxx0 | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.5 m; Výška: 0.2 m
 | Půdorys 1.NP | m | 1.757 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1757.0000/125.0000/125.0000/2/1757.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/1757.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | 1757 | DN125 | 125 | 125 | 0.000 | 1.757 m | PO.03.30320 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798489866 | Objekt
15204160160143xxxxxx0 | Půdorys 1.NP | m | 0.143 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/142.8613/160.0000/160.0000/2/142.8613/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/142.86/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 143 | DN160 | 160 | 160 | 0.000 | 0.143 m | PO.03.30321 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798489871 | Objekt | 15204160160143xxxxxx0
1520416016067xxxxxx0 | Půdorys 1.NP | m | 0.067 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/66.5485/160.0000/160.0000/2/66.5485/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/66.55/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 67 | DN160 | 160 | 160 | 0.000 | 0.067 m | PO.03.30322 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798489891 | Objekt | 1520416016067xxxxxx0
152042x2x1405xxxxxx0 | Půdorys 1.NP | m | 1.405 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1405.0000/200.0000/200.0000/2/1405.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/1405.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1405 | DN200 | 200 | 200 | 0.000 | 1.405 m | PO.03.30323 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798489896 | Objekt | 152042x2x1405xxxxxx0
 | Půdorys 1.NP | m | 2.912 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/2911.5000/125.0000/125.0000/2/2911.5000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/2911.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 2912 | DN125 | 125 | 125 | 0.000 | 2.912 m | PO.03.30324 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798489901 | Objekt
152042x2x4368xxxxxx0 | Půdorys 1.NP | m | 4.368 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/4367.7000/200.0000/200.0000/2/4367.7000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/4367.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 4368 | DN200 | 200 | 200 | 0.000 | 4.368 m | PO.03.30325 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798489906 | Objekt | 152042x2x4368xxxxxx0
 | Půdorys 1.NP | m | 2.482 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/2481.6000/125.0000/125.0000/2/2481.6000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/2481.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 2482 | DN125 | 125 | 125 | 0.000 | 2.482 m | PO.03.30326 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798489911 | Objekt
152041x1x881xxxxxx0 | Půdorys 1.NP | m | 0.881 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/880.6000/100.0000/100.0000/2/880.6000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/880.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 881 | DN100 | 100 | 100 | 0.000 | 0.881 m | PO.03.30327 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798489916 | Objekt | 152041x1x881xxxxxx0
101044502x18xxxxxxx | Půdorys 1.NP | m2 | 0.18 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/180.4000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/180.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 180 | 450x200 | 450 | 200 | 0.000 | 1.000 m2 | PO.03.30328 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798489931 | Objekt | 101044502x18xxxxxxx | NEMSOK - K_POSITION: L.11; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.45 m; Výška: 0.2 m
 | Půdorys 1.NP | m | 5.342 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/5342.3000/125.0000/125.0000/2/5342.3000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/5342.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 5342 | DN125 | 125 | 125 | 0.000 | 5.342 m | PO.03.30329 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798490197 | Objekt
101042x2x787xxxxxx0 | Půdorys 1.NP | m2 | 0.787 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/1/786.5000/0/0/0/0/0/1.0000/200.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/786.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 787 | 200x200 | 200 | 200 | 0.000 | 1.000 m2 | PO.03.30330 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798490212 | Objekt | 101042x2x787xxxxxx0 | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.2 m; Výška: 0.2 m
152042x2x64xxxxxx0 | Půdorys 1.NP | m | 0.064 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/64.1000/200.0000/200.0000/2/64.1000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/64.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 64 | DN200 | 200 | 200 | 0.000 | 0.064 m | PO.03.30331 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798490237 | Objekt | 152042x2x64xxxxxx0
152042x2x136xxxxxx0 | Půdorys 1.NP | m | 0.136 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/135.9000/200.0000/200.0000/2/135.9000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/135.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 136 | DN200 | 200 | 200 | 0.000 | 0.136 m | PO.03.30332 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798490247 | Objekt | 152042x2x136xxxxxx0
15204160160371xxxxxx0 | Půdorys 1.NP | m | 0.371 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/61.4000/160.0000/160.0000/2/61.4000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/61.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 61 | DN160 | 160 | 160 | 0.000 | 0.061 m | PO.03.30333 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798490347 | Objekt | 15204160160371xxxxxx0 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 371.380|80.000|80.000|0.000|-80.000|-80.000|0.000|0.000|0.000|1.000
101044x2x842xxxxxx0 | Půdorys 1.NP | m2 | 0.842 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/400.0000/200.0000/1/842.0000/0/0/0/0/0/1.0000/400.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/200.00/842.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 842 | 400x200 | 400 | 200 | 0.000 | 1.010 m2 | PO.03.30335 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798490559 | Objekt | 101044x2x842xxxxxx0 | NEMSOK - K_POSITION: L.15; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.4 m; Výška: 0.2 m
101043152x1xxxxxxx0 | Půdorys 1.NP | m2 | 0.1 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/200.0000/1/100.0000/0/0/0/0/0/1.0000/315.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/200.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 100 | 315x200 | 315 | 200 | 0.000 | 1.000 m2 | PO.03.30336 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798490574 | Objekt | 101043152x1xxxxxxx0 | NEMSOK - K_POSITION: L.16; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.315 m; Výška: 0.2 m
15204160160432xxxxxx0 | Půdorys 1.NP | m | 0.432 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/431.9000/160.0000/160.0000/2/431.9000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/431.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 432 | DN160 | 160 | 160 | 0.000 | 0.432 m | PO.03.30337 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798490579 | Objekt | 15204160160432xxxxxx0
152041x1x809xxxxxx0 | Půdorys 1.NP | m | 0.809 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/808.6000/100.0000/100.0000/2/808.6000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/808.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 809 | DN100 | 100 | 100 | 0.000 | 0.809 m | PO.03.30338 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798490584 | Objekt | 152041x1x809xxxxxx0
101043152x1355xxxxxx0 | Půdorys 1.NP | m2 | 1.355 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/200.0000/1/1354.8000/0/0/0/0/0/1.0000/315.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/200.00/1354.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1355 | 315x200 | 315 | 200 | 0.000 | 1.400 m2 | PO.03.30342 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798490654 | Objekt | 101043152x1355xxxxxx0 | NEMSOK - K_POSITION: L.22; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.315 m; Výška: 0.2 m
101042502x924xxxxxx0 | Půdorys 1.NP | m2 | 0.924 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/250.0000/200.0000/1/924.1000/0/0/0/0/0/1.0000/250.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/200.00/924.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 924 | 250x200 | 250 | 200 | 0.000 | 0.830 m2 | PO.03.30344 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798490674 | Objekt | 101042502x924xxxxxx0 | NEMSOK - K_POSITION: L.24; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.25 m; Výška: 0.2 m
152042x2x16xxxxxxx | Půdorys 1.NP | m | 0.16 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/159.6000/200.0000/200.0000/2/159.6000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/159.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160 | DN200 | 200 | 200 | 0.000 | 0.160 m | PO.03.30345 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798490679 | Objekt | 152042x2x16xxxxxxx
152062x2x464xxxxxx0 | Půdorys 1.NP | m | 0.464 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/463.6541/200.0000/200.0000/2/463.6541/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/463.65/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 464 | DN200 | 200 | 200 | 0.000 | 0.464 m | PO.03.30346 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798490684 | Objekt | 152062x2x464xxxxxx0
152062x2x309xxxxxx0 | Půdorys 1.NP | m | 0.309 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/309.4904/200.0000/200.0000/2/309.4904/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/309.49/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 309 | DN200 | 200 | 200 | 0.000 | 0.309 m | PO.03.30347 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798490694 | Objekt | 152062x2x309xxxxxx0
152062x2x464xxxxxx0 | Půdorys 1.NP | m | 0.464 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/463.7323/200.0000/200.0000/2/463.7323/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/463.73/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 464 | DN200 | 200 | 200 | 0.000 | 0.464 m | PO.03.30348 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798490704 | Objekt | 152062x2x464xxxxxx0
152061x1x22xxxxxxx | Půdorys 1.NP | m | 0.22 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/220.0000/100.0000/100.0000/2/220.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/220.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 220 | DN100 | 100 | 100 | 0.000 | 0.220 m | PO.03.30349 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798490709 | Objekt | 152061x1x22xxxxxxx
152061x1x1013xxxxxx0 | Půdorys 1.NP | m | 1.013 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1013.3000/100.0000/100.0000/2/1013.3000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/1013.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | 1013 | DN100 | 100 | 100 | 0.000 | 1.013 m | PO.03.30350 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798490714 | Objekt | 152061x1x1013xxxxxx0
1520512512531xxxxxxx | Půdorys 1.NP | m | 0.31 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/310.0000/125.0000/125.0000/2/310.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 310 | DN125 | 125 | 125 | 0.000 | 0.310 m | PO.03.30351 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798490729 | Objekt | 1520512512531xxxxxxx
15205125125146xxxxxx0 | Půdorys 1.NP | m | 0.146 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/146.0000/125.0000/125.0000/2/146.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/146.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | 146 | DN125 | 125 | 125 | 0.000 | 0.146 m | PO.03.30352 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798490734 | Objekt | 15205125125146xxxxxx0
152051251258xxxxxx0 | Půdorys 1.NP | m | 0.008 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/7.9160/125.0000/125.0000/2/7.9160/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/7.92/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 8 | DN125 | 125 | 125 | 0.000 | 0.008 m | PO.03.30353 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798490739 | Objekt | 152051251258xxxxxx0
1520512512575xxxxxxx | Půdorys 1.NP | m | 0.75 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/750.2148/125.0000/125.0000/2/750.2148/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/750.21/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 750 | DN125 | 125 | 125 | 0.000 | 0.750 m | PO.03.30354 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798490749 | Objekt | 1520512512575xxxxxxx
101052x28015xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/200.0000/280.0000/1/1500.0000/0/0/0/0/0/1.0000/200.0000/280.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/280.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 200x280 | 200 | 280 | 0.000 | 1.440 m2 | PO.03.30355 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798490774 | Objekt | 101052x28015xxxxxxx0 | NEMSOK - K_POSITION: L.5; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 280; Šířka: 0.2 m; Výška: 0.28 m
101052x280269xxxxxx0 | Půdorys 1.NP | m2 | 0.269 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/200.0000/280.0000/1/268.9000/0/0/0/0/0/1.0000/200.0000/280.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/280.00/268.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 269 | 200x280 | 200 | 280 | 0.000 | 1.000 m2 | PO.03.30356 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798490789 | Objekt | 101052x280269xxxxxx0 | NEMSOK - K_POSITION: L.6; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 280; Šířka: 0.2 m; Výška: 0.28 m
101052x280103xxxxxxx | Půdorys 1.NP | m2 | 1.03 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/200.0000/280.0000/1/1030.3000/0/0/0/0/0/1.0000/200.0000/280.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/280.00/1030.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1030 | 200x280 | 200 | 280 | 0.000 | 0.990 m2 | PO.03.30357 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798490804 | Objekt | 101052x280103xxxxxxx | NEMSOK - K_POSITION: L.7; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 280; Šířka: 0.2 m; Výška: 0.28 m
152052x2x429xxxxxx0 | Půdorys 1.NP | m | 0.429 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/429.2000/200.0000/200.0000/2/429.2000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/429.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 429 | DN200 | 200 | 200 | 0.000 | 0.429 m | PO.03.30358 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798490809 | Objekt | 152052x2x429xxxxxx0
152052x2x752xxxxxx0 | Půdorys 1.NP | m | 0.752 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/752.0000/200.0000/200.0000/2/752.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/752.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 752 | DN200 | 200 | 200 | 0.000 | 0.752 m | PO.03.30359 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798490814 | Objekt | 152052x2x752xxxxxx0
15204160160123xxxxxx0 | Půdorys 1.NP | m | 0.123 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/123.2031/160.0000/160.0000/2/123.2031/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/123.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 123 | DN160 | 160 | 160 | 0.000 | 0.123 m | PO.03.30360 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798490840 | Objekt | 15204160160123xxxxxx0
152042x2x67xxxxxxx | Půdorys 1.NP | m | 0.67 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/669.5000/200.0000/200.0000/2/669.5000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/669.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 670 | DN200 | 200 | 200 | 0.000 | 0.669 m | PO.03.30361 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798490865 | Objekt | 152042x2x67xxxxxxx
152042x2x2125xxxxxx0 | Půdorys 1.NP | m | 2.125 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/2125.2000/200.0000/200.0000/2/2125.2000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/2125.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 2125 | DN200 | 200 | 200 | 0.000 | 2.125 m | PO.03.30362 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798490870 | Objekt | 152042x2x2125xxxxxx0
 | Půdorys 1.NP | m | 1.089 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/778.6000/160.0000/160.0000/2/778.6000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/778.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 779 | DN160 | 160 | 160 | 0.000 | 0.779 m | PO.03.30363 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798490880 | Objekt | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 1088.620|80.000|80.000|0.000|-80.000|-80.000|0.000|0.000|0.000|1.000
101052502x115xxxxxxx | Půdorys 1.NP | m2 | 1.15 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/250.0000/200.0000/1/1150.0000/0/0/0/0/0/1.0000/250.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/200.00/1150.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1150 | 250x200 | 250 | 200 | 0.000 | 1.040 m2 | PO.03.30364 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798490917 | Objekt | 101052502x115xxxxxxx | 1.040 m2 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.25 m; Výška: 0.2 m; K_EBT_BOX_WC: 1500.000|145.000|120.000|0.000|-145.000|-120.000|0.000|0.000|0.000|1.000
101052502x115xxxxxxx | Půdorys 1.NP | m2 | 1.15 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/250.0000/200.0000/1/1150.0000/0/0/0/0/0/1.0000/250.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/200.00/1150.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1150 | 250x200 | 250 | 200 | 0.000 | 1.040 m2 | PO.03.30365 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798490970 | Objekt | 101052502x115xxxxxxx | 1.040 m2 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.25 m; Výška: 0.2 m; K_EBT_BOX_WC: 1500.000|145.000|120.000|0.000|-145.000|-120.000|0.000|0.000|0.000|1.000
152051251254xxxxxx0 | Půdorys 1.NP | m | 0.004 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/4.0000/125.0000/125.0000/2/4.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/4.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 4 | DN125 | 125 | 125 | 0.000 | 0.004 m | PO.03.30366 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798491007 | Konstrukce v aktuální hladině | 152051251254xxxxxx0
15204160160834xxxxxx0 | Půdorys 1.NP | m | 0.834 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/523.9000/160.0000/160.0000/2/523.9000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/523.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 524 | DN160 | 160 | 160 | 0.000 | 0.524 m | PO.03.30367 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798491027 | Objekt | 15204160160834xxxxxx0 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 833.900|80.000|80.000|0.000|-80.000|-80.000|0.000|0.000|0.000|1.000
152042x2x7xxxxxxx | Půdorys 1.NP | m | 0.07 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/69.5272/200.0000/200.0000/2/69.5272/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/69.53/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 70 | DN200 | 200 | 200 | 0.000 | 0.070 m | PO.03.30368 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798491540 | Objekt | 152042x2x7xxxxxxx
152042x2x7xxxxxxx | Půdorys 1.NP | m | 0.07 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/69.5271/200.0000/200.0000/2/69.5271/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/69.53/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 70 | DN200 | 200 | 200 | 0.000 | 0.070 m | PO.03.30369 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798491565 | Objekt | 152042x2x7xxxxxxx
152042x2x592xxxxxx0 | Půdorys 1.NP | m | 0.592 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/292.2000/200.0000/200.0000/2/292.2000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/292.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 292 | DN200 | 200 | 200 | 0.000 | 0.292 m | PO.03.30370 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798491578 | Objekt | 152042x2x592xxxxxx0 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 592.193|100.000|100.000|0.000|-100.000|-100.000|0.000|0.000|0.000|1.000
15204160160487xxxxxx0 | Půdorys 1.NP | m | 0.487 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/487.0000/160.0000/160.0000/2/487.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/487.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 487 | DN160 | 160 | 160 | 0.000 | 0.487 m | PO.03.30371 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798491586 | Konstrukce v aktuální hladině | 15204160160487xxxxxx0
101044502x652xxxxxx0 | Půdorys 1.NP | m2 | 0.652 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/651.5000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/651.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/0.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 652 | 450x200 | 450 | 200 | 0.000 | 1.000 m2 | PO.03.30372 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798492421 | Objekt | 101044502x652xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.45 m; Výška: 0.2 m; K_EBT_BOX_WC: 1001.500|245.000|120.000|0.000|-245.000|-120.000|0.000|0.000|0.000|1.000
101054x2x104xxxxxxx | Půdorys 1.NP | m2 | 1.04 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/400.0000/200.0000/1/1040.1000/0/0/0/0/0/1.0000/400.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/200.00/1040.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1040 | 400x200 | 400 | 200 | 0.000 | 1.250 m2 | PO.03.30373 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798492924 | Objekt | 101054x2x104xxxxxxx | NEMSOK - K_POSITION: L.11; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.4 m; Výška: 0.2 m; Plocha: 1.25
101053152x86xxxxxxx | Půdorys 1.NP | m2 | 0.86 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/200.0000/1/859.9000/0/0/0/0/0/1.0000/315.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/200.00/859.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 860 | 315x200 | 315 | 200 | 0.000 | 1.000 m2 | PO.03.30374 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798492939 | Objekt | 101053152x86xxxxxxx | NEMSOK - K_POSITION: L.12; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.315 m; Výška: 0.2 m; Plocha: 1
152042x2x323xxxxxx0 | Půdorys 1.NP | m | 0.323 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/322.6208/200.0000/200.0000/2/322.6208/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/322.62/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 323 | DN200 | 200 | 200 | 0.000 | 0.323 m | PO.03.30375 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798493044 | Objekt | 152042x2x323xxxxxx0
152042x2x1344xxxxxx0 | Půdorys 1.NP | m | 1.344 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1343.8000/200.0000/200.0000/2/1343.8000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/1343.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | 1344 | DN200 | 200 | 200 | 0.000 | 1.344 m | PO.03.30376 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798493059 | Objekt | 152042x2x1344xxxxxx0
101048x125054xxxxxxx | Půdorys 2.NP | m2 | 0.54 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/800.0000/1250.0000/1/540.0000/0/0/0/0/0/1.0000/800.0000/1250.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/800.00/1250.00/540.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/1.00 | SB 30/SB 30/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 540 | 800x1250 | 800 | 1250 | 0.000 | 2.210 m2 | PO.04.30001 | Nadzemní podlaží 2.NP | - | - | 6792Obj0000000007 | Konstrukce v aktuální hladině | 101048x125054xxxxxxx | NEMSOK - K_POSITION: L.15; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1250; Šířka: 0.8 m; Výška: 1.25 m
10104125014x5xxxxxxx0 | Půdorys 2.NP | m2 | 0.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/1250.0000/1400.0000/1/500.0000/0/0/0/0/0/1.0000/1250.0000/1400.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/1250.00/1400.00/500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/1.00 | SB 30/SB 30/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 500 | 1250x1400 | 1250 | 1400 | 0.000 | 2.650 m2 | PO.04.30002 | Nadzemní podlaží 2.NP | - | - | 6792Obj0000000009 | Konstrukce v aktuální hladině | 10104125014x5xxxxxxx0 | NEMSOK - K_POSITION: L.17; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1400; Šířka: 1.25 m; Výška: 1.4 m
15205250250725xxxxxx0 | Půdorys 2.NP | m | 0.725 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/725.0000/250.0000/250.0000/2/725.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/725.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Mineralwolle/100.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | 725 | DN250 | 250 | 250 | 0.000 | 0.725 m | PO.04.30003 | Nadzemní podlaží 2.NP | DN250 | vzduch | 6792Obj0000000012 | Objekt | 15205250250725xxxxxx0
152042x2x333xxxxxx0 | Půdorys 2.NP | m | 0.333 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/333.0000/200.0000/200.0000/2/333.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/333.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 333 | DN200 | 200 | 200 | 0.000 | 0.333 m | PO.04.30004 | Nadzemní podlaží 2.NP | DN200 | vzduch | 6792Obj0000000020 | Objekt | 152042x2x333xxxxxx0
152042x2x517xxxxxx0 | Půdorys 2.NP | m | 0.517 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/517.0000/200.0000/200.0000/2/517.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/517.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 517 | DN200 | 200 | 200 | 0.000 | 0.517 m | PO.04.30005 | Nadzemní podlaží 2.NP | DN200 | vzduch | 6792Obj0000000024 | Objekt | 152042x2x517xxxxxx0
152042502501xxxxxxx0 | Půdorys střechy | m | 0.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 100 | DN250 | 250 | 250 | 0.000 | 0.100 m | PO.05.30001 | Nadzemní podlaží 3.NP | 250 mm | - | 6882Obj0000000027 | Objekt | 152042502501xxxxxxx0 | 0.141 m2
152042502501xxxxxxx0 | Půdorys střechy | m | 0.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 100 | DN250 | 250 | 250 | 0.000 | 0.100 m | PO.05.30002 | Nadzemní podlaží 3.NP | 250 mm | - | 6882Obj0000000028 | Objekt | 152042502501xxxxxxx0 | 0.141 m2
152042502501xxxxxxx0 | Půdorys střechy | m | 0.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 100 | DN250 | 250 | 250 | 0.000 | 0.100 m | PO.05.30003 | Nadzemní podlaží 3.NP | 250 mm | - | 6882Obj0000000029 | Objekt | 152042502501xxxxxxx0 | 0.141 m2
152042502501xxxxxxx0 | Půdorys střechy | m | 0.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 100 | DN250 | 250 | 250 | 0.000 | 0.100 m | PO.05.30004 | Nadzemní podlaží 3.NP | 250 mm | - | 6882Obj0000000030 | Objekt | 152042502501xxxxxxx0 | 0.141 m2
152042502501xxxxxxx0 | Půdorys střechy | m | 0.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 100 | DN250 | 250 | 250 | 0.000 | 0.100 m | PO.05.30005 | Nadzemní podlaží 3.NP | 250 mm | - | 6882Obj0000000031 | Objekt | 152042502501xxxxxxx0 | 0.141 m2
152042502501xxxxxxx0 | Půdorys střechy | m | 0.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 100 | DN250 | 250 | 250 | 0.000 | 0.100 m | PO.05.30006 | Nadzemní podlaží 3.NP | 250 mm | - | 6882Obj0000000032 | Objekt | 152042502501xxxxxxx0 | 0.141 m2
1520425025011xxxxxxx0 | Půdorys střechy | m | 1.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1100.0000/250.0000/250.0000/2/1100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/1100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | 1100 | DN250 | 250 | 250 | 0.000 | 1.100 m | PO.05.30007 | Nadzemní podlaží 3.NP | 250 mm | - | 6882Obj0000000034 | Objekt | 1520425025011xxxxxxx0 | 1.555 m2
1520425025011xxxxxxx0 | Půdorys střechy | m | 1.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1100.0000/250.0000/250.0000/2/1100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/1100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | 1100 | DN250 | 250 | 250 | 0.000 | 1.100 m | PO.05.30008 | Nadzemní podlaží 3.NP | 250 mm | - | 6882Obj0000000035 | Objekt | 1520425025011xxxxxxx0 | 1.555 m2
1520425025011xxxxxxx0 | Půdorys střechy | m | 1.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1100.0000/250.0000/250.0000/2/1100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/1100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | 1100 | DN250 | 250 | 250 | 0.000 | 1.100 m | PO.05.30009 | Nadzemní podlaží 3.NP | 250 mm | - | 6882Obj0000000036 | Objekt | 1520425025011xxxxxxx0 | 1.555 m2
1520425025011xxxxxxx0 | Půdorys střechy | m | 1.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1100.0000/250.0000/250.0000/2/1100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/1100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | 1100 | DN250 | 250 | 250 | 0.000 | 1.100 m | PO.05.30010 | Nadzemní podlaží 3.NP | 250 mm | - | 6882Obj0000000037 | Objekt | 1520425025011xxxxxxx0 | 1.555 m2
1520425025011xxxxxxx0 | Půdorys střechy | m | 1.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1100.0000/250.0000/250.0000/2/1100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/1100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | 1100 | DN250 | 250 | 250 | 0.000 | 1.100 m | PO.05.30011 | Nadzemní podlaží 3.NP | 250 mm | - | 6882Obj0000000038 | Objekt | 1520425025011xxxxxxx0 | 1.555 m2
1520425025011xxxxxxx0 | Půdorys střechy | m | 1.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1100.0000/250.0000/250.0000/2/1100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/1100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | 1100 | DN250 | 250 | 250 | 0.000 | 1.100 m | PO.05.30012 | Nadzemní podlaží 3.NP | 250 mm | - | 6882Obj0000000039 | Objekt | 1520425025011xxxxxxx0 | 1.555 m2
152042502501xxxxxxx0 | Půdorys střechy | m | 0.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 100 | DN250 | 250 | 250 | 0.000 | 0.100 m | PO.07.30001 | Nadzemní podlaží 5.NP | 250 mm | - | 6882Obj0000000040 | Objekt | 152042502501xxxxxxx0 | 0.141 m2
152042502501xxxxxxx0 | Půdorys střechy | m | 0.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 100 | DN250 | 250 | 250 | 0.000 | 0.100 m | PO.07.30002 | Nadzemní podlaží 5.NP | 250 mm | - | 6882Obj0000000041 | Objekt | 152042502501xxxxxxx0 | 0.141 m2
152042502501xxxxxxx0 | Půdorys střechy | m | 0.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 100 | DN250 | 250 | 250 | 0.000 | 0.100 m | PO.07.30003 | Nadzemní podlaží 5.NP | 250 mm | - | 6882Obj0000000042 | Objekt | 152042502501xxxxxxx0 | 0.141 m2
152042502501xxxxxxx0 | Půdorys střechy | m | 0.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 100 | DN250 | 250 | 250 | 0.000 | 0.100 m | PO.07.30004 | Nadzemní podlaží 5.NP | 250 mm | - | 6882Obj0000000043 | Objekt | 152042502501xxxxxxx0 | 0.141 m2
152042502501xxxxxxx0 | Půdorys střechy | m | 0.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 100 | DN250 | 250 | 250 | 0.000 | 0.100 m | PO.07.30005 | Nadzemní podlaží 5.NP | 250 mm | - | 6882Obj0000000044 | Objekt | 152042502501xxxxxxx0 | 0.141 m2
152042502501xxxxxxx0 | Půdorys střechy | m | 0.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 100 | DN250 | 250 | 250 | 0.000 | 0.100 m | PO.07.30006 | Nadzemní podlaží 5.NP | 250 mm | - | 6882Obj0000000045 | Objekt | 152042502501xxxxxxx0 | 0.141 m2
152042502501xxxxxxx0 | Půdorys střechy | m | 0.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 100 | DN250 | 250 | 250 | 0.000 | 0.100 m | PO.07.30007 | Nadzemní podlaží 5.NP | 250 mm | - | 6882Obj0000000046 | Objekt | 152042502501xxxxxxx0 | 0.141 m2
152042502501xxxxxxx0 | Půdorys střechy | m | 0.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 100 | DN250 | 250 | 250 | 0.000 | 0.100 m | PO.07.30008 | Nadzemní podlaží 5.NP | 250 mm | - | 6882Obj0000000047 | Objekt | 152042502501xxxxxxx0 | 0.141 m2
152042502501xxxxxxx0 | Půdorys střechy | m | 0.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 100 | DN250 | 250 | 250 | 0.000 | 0.100 m | PO.07.30009 | Nadzemní podlaží 5.NP | 250 mm | - | 6882Obj0000000048 | Objekt | 152042502501xxxxxxx0 | 0.141 m2
152042502501xxxxxxx0 | Půdorys střechy | m | 0.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 100 | DN250 | 250 | 250 | 0.000 | 0.100 m | PO.07.30010 | Nadzemní podlaží 5.NP | 250 mm | - | 6882Obj0000000049 | Objekt | 152042502501xxxxxxx0 | 0.141 m2
152042502501xxxxxxx0 | Půdorys střechy | m | 0.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 100 | DN250 | 250 | 250 | 0.000 | 0.100 m | PO.07.30011 | Nadzemní podlaží 5.NP | 250 mm | - | 6882Obj0000000050 | Objekt | 152042502501xxxxxxx0 | 0.141 m2
152042502501xxxxxxx0 | Půdorys střechy | m | 0.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 100 | DN250 | 250 | 250 | 0.000 | 0.100 m | PO.07.30012 | Nadzemní podlaží 5.NP | 250 mm | - | 6882Obj0000000051 | Objekt | 152042502501xxxxxxx0 | 0.141 m2
1520425025011xxxxxxx0 | Půdorys střechy | m | 1.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1100.0000/250.0000/250.0000/2/1100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/1100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1100 | DN250 | 250 | 250 | 0.000 | 1.100 m | PO.07.30013 | Nadzemní podlaží 5.NP | 250 mm | - | 6882Obj0000000053 | Objekt | 1520425025011xxxxxxx0 | 1.555 m2
1520425025011xxxxxxx0 | Půdorys střechy | m | 1.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1100.0000/250.0000/250.0000/2/1100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/1100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1100 | DN250 | 250 | 250 | 0.000 | 1.100 m | PO.07.30014 | Nadzemní podlaží 5.NP | 250 mm | - | 6882Obj0000000054 | Objekt | 1520425025011xxxxxxx0 | 1.555 m2
1520425025011xxxxxxx0 | Půdorys střechy | m | 1.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1100.0000/250.0000/250.0000/2/1100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/1100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1100 | DN250 | 250 | 250 | 0.000 | 1.100 m | PO.07.30015 | Nadzemní podlaží 5.NP | 250 mm | - | 6882Obj0000000055 | Objekt | 1520425025011xxxxxxx0 | 1.555 m2
1520425025011xxxxxxx0 | Půdorys střechy | m | 1.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1100.0000/250.0000/250.0000/2/1100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/1100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1100 | DN250 | 250 | 250 | 0.000 | 1.100 m | PO.07.30016 | Nadzemní podlaží 5.NP | 250 mm | - | 6882Obj0000000056 | Objekt | 1520425025011xxxxxxx0 | 1.555 m2
1520425025011xxxxxxx0 | Půdorys střechy | m | 1.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1100.0000/250.0000/250.0000/2/1100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/1100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1100 | DN250 | 250 | 250 | 0.000 | 1.100 m | PO.07.30017 | Nadzemní podlaží 5.NP | 250 mm | - | 6882Obj0000000057 | Objekt | 1520425025011xxxxxxx0 | 1.555 m2
1520425025011xxxxxxx0 | Půdorys střechy | m | 1.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1100.0000/250.0000/250.0000/2/1100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/1100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1100 | DN250 | 250 | 250 | 0.000 | 1.100 m | PO.07.30018 | Nadzemní podlaží 5.NP | 250 mm | - | 6882Obj0000000058 | Objekt | 1520425025011xxxxxxx0 | 1.555 m2
1520425025011xxxxxxx0 | Půdorys střechy | m | 1.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1100.0000/250.0000/250.0000/2/1100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/1100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1100 | DN250 | 250 | 250 | 0.000 | 1.100 m | PO.07.30019 | Nadzemní podlaží 5.NP | 250 mm | - | 6882Obj0000000059 | Objekt | 1520425025011xxxxxxx0 | 1.555 m2
1520425025011xxxxxxx0 | Půdorys střechy | m | 1.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1100.0000/250.0000/250.0000/2/1100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/1100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1100 | DN250 | 250 | 250 | 0.000 | 1.100 m | PO.07.30020 | Nadzemní podlaží 5.NP | 250 mm | - | 6882Obj0000000060 | Objekt | 1520425025011xxxxxxx0 | 1.555 m2
1520425025011xxxxxxx0 | Půdorys střechy | m | 1.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1100.0000/250.0000/250.0000/2/1100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/1100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1100 | DN250 | 250 | 250 | 0.000 | 1.100 m | PO.07.30021 | Nadzemní podlaží 5.NP | 250 mm | - | 6882Obj0000000061 | Objekt | 1520425025011xxxxxxx0 | 1.555 m2
1520425025011xxxxxxx0 | Půdorys střechy | m | 1.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1100.0000/250.0000/250.0000/2/1100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/1100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1100 | DN250 | 250 | 250 | 0.000 | 1.100 m | PO.07.30022 | Nadzemní podlaží 5.NP | 250 mm | - | 6882Obj0000000062 | Objekt | 1520425025011xxxxxxx0 | 1.555 m2
1520425025011xxxxxxx0 | Půdorys střechy | m | 1.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1100.0000/250.0000/250.0000/2/1100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/1100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1100 | DN250 | 250 | 250 | 0.000 | 1.100 m | PO.07.30023 | Nadzemní podlaží 5.NP | 250 mm | - | 6882Obj0000000063 | Objekt | 1520425025011xxxxxxx0 | 1.555 m2
1520425025011xxxxxxx0 | Půdorys střechy | m | 1.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1100.0000/250.0000/250.0000/2/1100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/1100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1100 | DN250 | 250 | 250 | 0.000 | 1.100 m | PO.07.30024 | Nadzemní podlaží 5.NP | 250 mm | - | 6882Obj0000000064 | Objekt | 1520425025011xxxxxxx0 | 1.555 m2
