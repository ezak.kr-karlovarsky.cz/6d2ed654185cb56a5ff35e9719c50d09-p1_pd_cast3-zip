Properties of the parts of a building model (IFC2X3), part 13 of 51

# IfcFlowFitting (2887)
Name | In | Jednotka | Délka (m) | Označení | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_DIM | L_BES_DIM_A2 | L_BES_DIM_B2 | L_BES_DIM_A | K_VOLSTROM | K_MLH_GOST = K_MLD_GOST | K_LISTVALUE | Kód prvku | Třída reakce na oheň | Allright_Stavebni_dil_ID | Název_objektu | K_EBT_BOX_WC | Plocha | L_BES_LAENGE | K_INTERNAL_ISO | Tloušťka (m) | Součinitel tepelné vodivost
30204125125x125125092-x0-03xx | Půdorys 1.PP | Kus | 0 | 30204125125x125125092-x0-03xx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/219.8/125.0000/125.0000/125.0000/2/59.4530/15.0439/0/28.4/0/219.8/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/219.80/0/125.00/1.00/28.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | IT.02.30333 | A1 | 6774Obj0000045585 | Objekt | 89.180/70.022/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125128xxxxx0 | Půdorys 1.PP | Kus | 0.164 | 252x1250125128xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/164.4372/125.0000/125.0000/2/164.4372/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/164.44/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 0.164 m | IT.02.30334 | A1 | 6774Obj0000045588 | Objekt | 164.437/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.164 | 164 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.106 m2
15204125125164xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15204125125164xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | IT.02.30335 | A1 | 6774Obj0000045591 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
252x1250125145xxxxx0 | Půdorys 1.PP | Kus | 0.348 | 252x1250125145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/347.9569/125.0000/125.0000/2/347.9569/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/347.96/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 0.348 m | IT.02.30336 | A1 | 6774Obj0000045594 | Objekt | 347.957/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.348 | 348 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.224 m2
15204125125348xxxxxx0 | Půdorys 1.PP | Kus | 0.1 | 15204125125348xxxxxx0 | UE RUND AS | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/125.0000/125.0000/2/100.0000/-0.0143/0/0/0/0/125.0000/125.0000/125.0000/2/ | 31/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/0/0/125.00/125.00/0/100.00/0.01/-0.01/0/0/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | IT.02.30337 | A1 | 6774Obj0000045597 | Objekt | 100.000/62.500/62.500/0.000/-62.514/-62.500/0.000/0.000/0.000/1.000 | 1 | 100 | __ISO | 0.04 | 0,041 W/m.K
31205125125x12512501x0-x03xx | Půdorys 1.PP | Kus | 0 | 31205125125x12512501x0-x03xx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | IT.02.30338 | A1 | 6774Obj0000045600 | Objekt | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012519xxxxxx | Půdorys 1.PP | Kus | 0.75 | 252x125012519xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/750.0000/125.0000/125.0000/2/750.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/750.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 0.750 m | IT.02.30339 | A1 | 6774Obj0000045603 | Objekt | 750.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.75 | 750 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
1520412512575xxxxxxx | Půdorys 1.PP | Kus | 0.139 | 1520412512575xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/139.2797/125.0000/125.0000/2/139.2797/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/139.28/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 0.139 m | IT.02.30340 | A1 | 6774Obj0000045606 | Objekt | 139.280/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.139 | 139 | __ISO | 0.04 | 0,041 W/m.K
15204125125139xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15204125125139xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/90.0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/0/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 |  | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 100 | 100 | 100 | 120.000 |  | 1.0 | IT.02.30341 | A1 | 6774Obj0000045609 | Objekt | 150.000/100.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; L_BES_DIM_B: 100
252x1x01x19xxxxxx | Půdorys 1.PP | Kus | 0 | 252x1x01x19xxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/90.0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/0/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 |  | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 100 | 100 | 100 | 120.000 |  | 1.0 | IT.02.30342 | A1 | 6774Obj0000045612 | Objekt | 150.000/100.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; L_BES_DIM_B: 100
252x1x01x19xxxxxx | Půdorys 1.PP | Kus | 0.09 | 252x1x01x19xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/89.5000/125.0000/125.0000/2/89.5000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/89.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 0.089 m | IT.02.30343 | A1 | 6774Obj0000045615 | Objekt | 89.500/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.089 | 90 | __ISO | 0.04 | 0,041 W/m.K
152061251259xxxxxxx | Půdorys 1.PP | Kus | 0.215 | 152061251259xxxxxxx | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/110.0000/-107.5000/0/270.0/0/0/125.0000/125.0000/125.0000/2/110.0000/107.5000/0/90.0/0/0/125.0000/125.0000/125.0000/2/ | 75/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/125.00/0/0/215.00/0/110.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | IT.02.30344 | A1 | 6774Obj0000045619 | Objekt | 172.500/107.500/62.500/0.000/-107.500/-62.500/0.000/0.000/0.000/1.000 | 1 | 215 | __ISO | 0.04 | 0,041 W/m.K
752061251251250215011x9xxxx | Půdorys 1.PP | Kus | 0.064 | 752061251251250215011x9xxxx | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/64.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/100.00/0/0/125.00/100.00/0/64.00/-12.50/-12.50/-12.50/-12.50/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 100 | 100 | 125 | 120.000 | 0 | 1.0 | IT.02.30345 | A1 | 6774Obj0000045622 | Objekt | 64.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 | 64 | __ISO | 0.04 | 0,041 W/m.K
302041251xx1251x064-13-13-13-133 | Půdorys 1.PP | Kus | 0.064 | 302041251xx1251x064-13-13-13-133 | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/0/125.0000/125.0000/2/64.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/100.00/0/0/125.00/100.00/0/64.00/-12.50/-12.50/-12.50/-12.50/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 100 | 100 | 125 | 120.000 | 0 | 1.0 | IT.02.30346 | A1 | 6774Obj0000045625 | Objekt | 64.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 | 64 | __ISO | 0.04 | 0,041 W/m.K
302041251xx1251x064-13-13-13-133 | Půdorys 1.PP | Kus | 0.104 | 302041251xx1251x064-13-13-13-133 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/103.5000/100.0000/100.0000/2/103.5000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/103.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 0.104 m | IT.02.30347 | A1 | 6774Obj0000045628 | Objekt | 103.500/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.104 | 104 | __ISO | 0.04 | 0,041 W/m.K
152041x1x104xxxxxx0 | Půdorys 1.PP | Kus | 0.104 | 152041x1x104xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/103.5000/100.0000/100.0000/2/103.5000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/103.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 0.104 m | IT.02.30348 | A1 | 6774Obj0000045631 | Objekt | 103.500/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.104 | 104 | __ISO | 0.04 | 0,041 W/m.K
152041x1x104xxxxxx0 | Půdorys 1.PP | Kus | 0.05 | 152041x1x104xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/50.0000/100.0000/100.0000/2/50.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/94.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | CENTRÁLNÍ VYSAVAČ/3.00 | //// | Blech ummantelt/30.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/CENTRÁLNÍ VYSAVAČ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 0.050 m | IT.02.30349 | A1 | 6774Obj0000045634 | Objekt | 50.000/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.05 | 50 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
152041x1x5xxxxxxx | Půdorys 1.PP | Kus | 0.05 | 152041x1x5xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/50.0000/100.0000/100.0000/2/50.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 0.050 m | IT.02.30350 | A1 | 6774Obj0000045637 | Objekt | 50.000/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.05 | 50 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
152041x1x5xxxxxxx | Půdorys 1.PP | Kus | 0.078 | 152041x1x5xxxxxxx | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/78.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/160.00/0/0/125.00/160.00/0/78.00/17.50/17.50/17.50/17.50/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 160 | 160 | 125 | 120.000 | 0 | 1.0 | IT.02.30351 | A1 | 6774Obj0000045640 | Objekt | 78.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 78 | __ISO | 0.04 | 0,041 W/m.K
3020412516x012516x78181818183xx | Půdorys 1.PP | Kus | 0.074 | 3020412516x012516x78181818183xx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/74.1000/160.0000/160.0000/2/74.1000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/74.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 0.074 m | IT.02.30352 | A1 | 6774Obj0000045643 | Objekt | 74.100/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.074 | 74 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.056 m2
1520416016074xxxxxx0 | Půdorys 1.PP | Kus | 0.215 | 1520416016074xxxxxx0 | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/215.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/107.5000/125.0000/0/90.0/0/0/125.0000/125.0000/125.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/125.00/0/0/215.00/0/125.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | IT.02.30353 | A1 | 6774Obj0000045647 | Objekt | 215.000/125.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 215 | __ISO | 0.04 | 0,041 W/m.K
752041601601250215012509xxxx | Půdorys 1.PP | Kus | 0.19 | 752041601601250215012509xxxx | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/190.0000/0/0/0/0/180.0/160.0000/160.0000/160.0000/2/95.0000/125.0000/0/90.0/0/180.0/100.0000/100.0000/100.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/100.00/0/180.00/190.00/0/125.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | IT.02.30354 | A1 | 6774Obj0000045651 | Objekt | 190.000/125.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 190 | __ISO | 0.04 | 0,041 W/m.K
752041601601x019x12509xxxx | Půdorys 1.PP | Kus | 0.162 | 752041601601x019x12509xxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/162.0000/160.0000/160.0000/2/162.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/162.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 0.162 m | IT.02.30355 | A1 | 6774Obj0000045654 | Objekt | 162.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.162 | 162 | __ISO | 0.04 | 0,041 W/m.K
15204160160162xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15204160160162xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/180.0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/180.00/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 1.0 | IT.02.30356 | A1 | 6774Obj0000045657 | Objekt | 150.000/100.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1x01x19xxxxxx | Půdorys 1.PP | Kus | 0.314 | 252x1x01x19xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/314.1452/100.0000/100.0000/2/314.1452/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/314.15/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 0.314 m | IT.02.30357 | A1 | 6774Obj0000045660 | Objekt | 314.145/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.314 | 314 | __ISO | 0.04 | 0,041 W/m.K
152041x1x314xxxxxx0 | Půdorys 1.PP | Kus | 0 | 152041x1x314xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | IT.02.30358 | A1 | 6774Obj0000045663 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
252x1250125145xxxxx0 | Půdorys 1.PP | Kus | 0.267 | 252x1250125145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/267.4175/125.0000/125.0000/2/267.4175/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/267.42/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 0.267 m | IT.02.30359 | A1 | 6774Obj0000045666 | Objekt | 267.417/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.267 | 267 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.172 m2
15204125125267xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15204125125267xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | IT.02.30360 | A1 | 6774Obj0000045669 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125145xxxxx0 | Půdorys 1.PP | Kus | 1.195 | 252x1250125145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1195.0000/125.0000/125.0000/2/1195.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/1195.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.195 m | IT.02.30361 | A1 | 6774Obj0000045672 | Objekt | 1195.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1.195 | 1195 | __ISO | 0.04 | 0,041 W/m.K
 | Půdorys 1.PP | Kus | 0 |  | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/90.0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/0/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 |  | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 100 | 100 | 100 | 120.000 |  | 1.0 | IT.02.30362 | A1 | 6774Obj0000045675 | Objekt | 150.000/100.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; L_BES_DIM_B: 100
252x1x01x19xxxxxx | Půdorys 1.PP | Kus | 0.072 | 252x1x01x19xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/72.2927/100.0000/100.0000/2/72.2927/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/72.29/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 0.072 m | IT.02.30363 | A1 | 6774Obj0000045678 | Objekt | 72.293/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.072 | 72 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.041 m2
152041x1x72xxxxxx0 | Půdorys 1.PP | Kus | 0.072 | 152041x1x72xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/72.3000/100.0000/100.0000/2/72.3000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/72.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 0.072 m | IT.02.30364 | A1 | 6774Obj0000045681 | Objekt | 72.300/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.072 | 72 | __ISO | 0.04 | 0,041 W/m.K
152041x1x72xxxxxx0 | Půdorys 1.PP | Kus | 0 | 152041x1x72xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/180.0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/180.00/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 1.0 | IT.02.30365 | A1 | 6774Obj0000045684 | Objekt | 150.000/100.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1x01x19xxxxxx | Půdorys 1.PP | Kus | 0.314 | 252x1x01x19xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/313.9934/100.0000/100.0000/2/313.9934/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/313.99/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 0.314 m | IT.02.30366 | A1 | 6774Obj0000045687 | Objekt | 313.993/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.314 | 314 | __ISO | 0.04 | 0,041 W/m.K
152041x1x314xxxxxx0 | Půdorys 1.PP | Kus | 0.004 | 152041x1x314xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/3.6838/160.0000/160.0000/2/3.6838/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/3.68/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 0.004 m | IT.02.30367 | A1 | 6774Obj0000045690 | Objekt | 3.684/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.004 | 4 | __ISO | 0.04 | 0,041 W/m.K
152041601604xxxxxx0 | Půdorys 1.PP | Kus | 0 | 152041601604xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/0/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | IT.02.30368 | A1 | 6774Obj0000045693 | Objekt | 169.706/103.431/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x160145xxxxx0 | Půdorys 1.PP | Kus | 0.054 | 252x16x160145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/54.1453/160.0000/160.0000/2/54.1453/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/54.15/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 0.054 m | IT.02.30369 | A1 | 6774Obj0000045696 | Objekt | 54.145/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.054 | 54 | __ISO | 0.04 | 0,041 W/m.K
1520416016054xxxxxx0 | Půdorys 1.PP | Kus | 0 | 1520416016054xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/180.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/180.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | IT.02.30370 | A1 | 6774Obj0000045699 | Objekt | 169.706/103.431/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x160145xxxxx0 | Půdorys 1.PP | Kus | 0.004 | 252x16x160145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/3.6306/160.0000/160.0000/2/3.6306/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/3.63/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 0.004 m | IT.02.30371 | A1 | 6774Obj0000045702 | Objekt | 3.631/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.004 | 4 | __ISO | 0.04 | 0,041 W/m.K
152041601604xxxxxx0 | Půdorys 1.PP | Kus | 0.082 | 152041601604xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/81.7000/125.0000/125.0000/2/81.7000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/81.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 0.082 m | IT.02.30372 | A1 | 6774Obj0000045705 | Objekt | 81.700/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.082 | 82 | __ISO | 0.04 | 0,041 W/m.K
1520412512582xxxxxx0 | Půdorys 1.PP | Kus | 0 | 1520412512582xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/195.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/195.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/195.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | IT.02.30373 | A1 | 6774Obj0000045708 | Objekt | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012519xxxxxx | Půdorys 1.PP | Kus | 0.055 | 252x125012519xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/55.3155/125.0000/125.0000/2/55.3155/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/55.32/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 0.055 m | IT.02.30374 | A1 | 6774Obj0000045711 | Objekt | 55.316/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.055 | 55 | __ISO | 0.04 | 0,041 W/m.K
1520412512555xxxxxx0 | Půdorys 1.PP | Kus | 0 | 1520412512555xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/88.7/125.0000/125.0000/125.0000/2/7.4133/0.2200/0/3.4/0/88.7/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/88.70/0/125.00/1.00/3.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | IT.02.30375 | A1 | 6774Obj0000045714 | Objekt | 11.120/62.610/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012513xxxxx0 | Půdorys 1.PP | Kus | 0.01 | 252x125012513xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/9.7800/125.0000/125.0000/2/9.7800/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/9.78/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 0.010 m | IT.02.30376 | A1 | 6774Obj0000045717 | Objekt | 9.780/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.01 | 10 | __ISO | 0.04 | 0,041 W/m.K
152041251251xxxxxxx | Půdorys 1.PP | Kus | 0 | 152041251251xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.4/125.0000/125.0000/125.0000/2/25.1347/2.5531/0/11.6/0/90.4/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.40/0/125.00/1.00/11.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | IT.02.30377 | A1 | 6774Obj0000045720 | Objekt | 37.702/63.777/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125112xxxxx0 | Půdorys 1.PP | Kus | 0.046 | 252x1250125112xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/46.3303/125.0000/125.0000/2/46.3303/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/46.33/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 0.046 m | IT.02.30378 | A1 | 6774Obj0000045723 | Objekt | 46.330/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.046 | 46 | __ISO | 0.04 | 0,041 W/m.K
1520412512546xxxxxx0 | Půdorys 1.PP | Kus | 0.097 | 1520412512546xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/96.7000/100.0000/100.0000/2/96.7000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/96.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 0.097 m | IT.02.30379 | A1 | 6774Obj0000045726 | Objekt | 96.700/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.097 | 97 | __ISO | 0.04 | 0,041 W/m.K
152041x1x97xxxxxx0 | Půdorys 1.PP | Kus | 0.05 | 152041x1x97xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/49.9000/125.0000/125.0000/2/49.9000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/49.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 0.050 m | IT.02.30380 | A1 | 6774Obj0000045729 | Objekt | 49.900/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.05 | 50 | __ISO | 0.04 | 0,041 W/m.K
152041251255xxxxxxx | Půdorys 1.PP | Kus | 0 | 152041251255xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/225.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/225.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/225.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | IT.02.30381 | A1 | 6774Obj0000045732 | Objekt | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012519xxxxxx | Půdorys 1.PP | Kus | 0.284 | 252x125012519xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/283.8000/125.0000/125.0000/2/283.8000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/283.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 0.284 m | IT.02.30382 | A1 | 6774Obj0000045735 | Objekt | 283.800/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.284 | 284 | __ISO | 0.04 | 0,041 W/m.K
252x1x01x19xxxxxx | Půdorys 1.PP | Kus | 1.06 | 252x1x01x19xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1059.7113/125.0000/125.0000/2/1059.7113/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/1059.71/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.060 m | IT.02.30383 | A1 | 6774Obj0000045741 | Objekt | 1059.711/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1.06 | 1060 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.682 m2
15205125125106xxxxxxx | Půdorys 1.PP | Kus | 1.098 | 15205125125106xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1097.6000/125.0000/125.0000/2/1097.6000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/1097.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.098 m | IT.02.30384 | A1 | 6774Obj0000045744 | Objekt | 1097.600/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1.098 | 1098 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.707 m2
 | Půdorys 1.PP | Kus | 0.165 |  | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/165.3000/0/0/0/0/0/0/160.0000/160.0000/1/ | 50/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/125.00/160.00/35.00/100.00/125.00/160.00/125.00/165.30/17.50/17.50/17.50/17.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 160 | 160 | 125 | 120.000 | 0 | 1.000 m2 | IT.02.30385 | A1 | 6774Obj0000045766 | Objekt | 165.300/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 165 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.12; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); K_LISTVALUE_ISO: 1.000 m2
50216125160351x12516012516518181 | Půdorys 1.PP | Kus | 0.46 | 50216125160351x12516012516518181 | T-STCK. GERADE | 20 | 1016 | 3/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/1/460.0000/0/0/0/0/180.0/1.0000/160.0000/160.0000/1/230.0000/230.0000/0/90.0/0/180.0/160.0000/160.0000/160.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/160.00/160.00/50.00/50.00/50.00/50.00/160.00/0/0/0/460.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 120.000 | 0 | 1.000 m2 | IT.02.30386 | A1 | 6774Obj0000045822 | Objekt | 460.000/230.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 460 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
701041601601601605050505016x046x | Půdorys 1.PP | Kus | 1.492 | 701041601601601605050505016x046x | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/1492.1000/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/1492.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 0.950 m2 | IT.02.30387 | A1 | 6774Obj0000045836 | Objekt | 1492.100/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.95 | 1492 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.430 m2
 | Půdorys 1.PP | Kus | 0.46 |  | T-STCK. SCHRÄG | 20 | 1016 | 3/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/1/460.0000/-20.0000/0/0/0/0/1.0000/200.0000/160.0000/1/230.0000/230.0000/0/90.0/0/0/160.0000/160.0000/160.0000/1/ | 71/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/200.00/160.00/160.00/50.00/50.00/50.00/50.00/160.00/0/0/0/460.00/-40.00/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 200 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30388 | A1 | 6774Obj0000045892 | Objekt | 460.000/230.000/100.000/0.000/-140.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 460 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
711041602x1601605050505016x0460- | Půdorys 1.PP | Kus | 1.5 | 711041602x1601605050505016x0460- | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/250.0000/160.0000/1/1500.0000/0/0/0/0/0/1.0000/250.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/160.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x160 | 250 | 160 | 250 | 0.000 | 0 | 1.230 m2 | IT.02.30389 | A1 | 6774Obj0000045906 | Objekt | 1500.000/145.000/100.000/0.000/-145.000/-100.000/0.000/0.000/0.000/1.000 | 1.23 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.6; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.710 m2
1010425016015xxxxxxx0 | Půdorys 1.PP | Kus | 0.056 | 1010425016015xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/250.0000/160.0000/1/55.5000/0/0/0/0/0/1.0000/250.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/160.00/55.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x160 | 250 | 160 | 250 | 0.000 | 0 | 1.000 m2 | IT.02.30390 | A1 | 6774Obj0000045920 | Objekt | 55.500/145.000/100.000/0.000/-145.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 56 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.7; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
1010425016056xxxxxx0 | Půdorys 1.PP | Kus | 0.46 | 1010425016056xxxxxx0 | T-STCK. SCHRÄG | 20 | 1016 | 3/0/0/0/180.0/0/180.0/250.0000/250.0000/160.0000/1/460.0000/-32.5000/0/0/0/180.0/1.0000/315.0000/160.0000/1/230.0000/275.0000/0/90.0/0/180.0/160.0000/160.0000/160.0000/1/ | 71/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/315.00/160.00/160.00/50.00/50.00/50.00/50.00/160.00/0/0/180.00/460.00/-65.00/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x160 | 315 | 160 | 250 | 0.000 | 0 | 1.000 m2 | IT.02.30391 | A1 | 6774Obj0000045976 | Objekt | 460.000/275.000/100.000/0.000/-210.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 460 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.8; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
711042503151601605050505016x0460 | Půdorys 1.PP | Kus | 1.146 | 711042503151601605050505016x0460 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/1145.9000/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/1145.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.090 m2 | IT.02.30392 | A1 | 6774Obj0000045990 | Objekt | 1145.900/177.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1.09 | 1146 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.9; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.450 m2
 | Půdorys 1.PP | Kus | 0.46 |  | T-STCK. GERADE | 20 | 1016 | 3/0/0/0/180.0/0/0/315.0000/315.0000/160.0000/1/460.0000/0/0/0/0/0/1.0000/315.0000/160.0000/1/230.0000/307.5000/0/90.0/0/0/160.0000/160.0000/160.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/160.00/160.00/50.00/50.00/50.00/50.00/160.00/0/0/0/460.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.02.30393 | A1 | 6774Obj0000046046 | Objekt | 460.000/307.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1 | 460 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.10; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
701043153151601605050505016x046x | Půdorys 1.PP | Kus | 1.5 | 701043153151601605050505016x046x | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/1500.0000/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.420 m2 | IT.02.30394 | A1 | 6774Obj0000046060 | Objekt | 1500.000/177.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1.42 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.11; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.910 m2
1010431516015xxxxxxx0 | Půdorys 1.PP | Kus | 1.346 | 1010431516015xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/1346.1000/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/1346.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.280 m2 | IT.02.30395 | A1 | 6774Obj0000046074 | Objekt | 1346.100/177.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1.28 | 1346 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.16; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.710 m2
 | Půdorys 1.PP | Kus | 1.5 |  | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/355.0000/160.0000/1/1500.0000/0/0/0/0/0/1.0000/355.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/355.00/160.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 355x160 | 355 | 160 | 355 | 0.000 | 0 | 1.550 m2 | IT.02.30396 | A1 | 6774Obj0000046088 | Objekt | 1500.000/197.500/100.000/0.000/-197.500/-100.000/0.000/0.000/0.000/1.000 | 1.55 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.21; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 2.030 m2
1010435516015xxxxxxx0 | Půdorys 1.PP | Kus | 0.916 | 1010435516015xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/355.0000/160.0000/1/916.1000/0/0/0/0/0/1.0000/355.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/355.00/160.00/916.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 355x160 | 355 | 160 | 355 | 0.000 | 0 | 0.940 m2 | IT.02.30397 | A1 | 6774Obj0000046102 | Objekt | 916.100/197.500/100.000/0.000/-197.500/-100.000/0.000/0.000/0.000/1.000 | 0.94 | 916 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.22; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.240 m2
10104355160916xxxxxx0 | Půdorys 1.PP | Kus | 0.46 | 10104355160916xxxxxx0 | T-STCK. SCHRÄG | 20 | 1016 | 3/0/0/0/180.0/0/180.0/355.0000/355.0000/160.0000/1/460.0000/-22.5000/0/0/0/180.0/1.0000/400.0000/160.0000/1/230.0000/327.5000/0/90.0/0/180.0/160.0000/160.0000/160.0000/1/ | 71/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/355.00/400.00/160.00/160.00/50.00/50.00/50.00/50.00/160.00/0/0/180.00/460.00/-45.00/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 355x160 | 400 | 160 | 355 | 0.000 | 0 | 1.000 m2 | IT.02.30398 | A1 | 6774Obj0000046158 | Objekt | 460.000/327.500/100.000/0.000/-242.500/-100.000/0.000/0.000/0.000/1.000 | 1 | 460 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.23; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
711043554x1601605050505016x0460- | Půdorys 1.PP | Kus | 0.002 | 711043554x1601605050505016x0460- | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/400.0000/160.0000/1/2.3000/0/0/0/0/0/1.0000/400.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/160.00/2.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x160 | 400 | 160 | 400 | 0.000 | 0 | 1.000 m2 | IT.02.30399 | A1 | 6774Obj0000046172 | Objekt | 20.000/220.000/100.000/-17.700/-220.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 2 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.24; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
101044x1602xxxxxx0 | Půdorys 1.PP | Kus | 0.46 | 101044x1602xxxxxx0 | T-STCK. SCHRÄG | 20 | 1016 | 3/0/0/0/180.0/0/0/400.0000/400.0000/160.0000/1/460.0000/-25.0000/0/0/0/0/1.0000/450.0000/160.0000/1/230.0000/350.0000/0/90.0/0/0/160.0000/160.0000/160.0000/1/ | 71/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/450.00/160.00/160.00/50.00/50.00/50.00/50.00/160.00/0/0/0/460.00/-50.00/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x160 | 450 | 160 | 400 | 0.000 | 0 | 1.000 m2 | IT.02.30400 | A1 | 6774Obj0000046228 | Objekt | 460.000/350.000/100.000/0.000/-270.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 460 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.25; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
711044x4501601605050505016x0460- | Půdorys 1.PP | Kus | 0.135 | 711044x4501601605050505016x0460- | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/135.0000/0/0/0/0/0/0/160.0000/120.0000/1/ | 50/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/160.00/160.00/35.00/100.00/160.00/120.00/160.00/135.00/0/0/-20.00/-20.00/53.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 120 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30401 | A1 | 6774Obj0000046250 | Objekt | 135.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 135 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.23; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); K_LISTVALUE_ISO: 1.000 m2
50216160160351x160120160135x-20- | Půdorys 1.PP | Kus | 0.165 | 50216160160351x160120160135x-20- | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/1/165.3000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/35.00/100.00/160.00/125.00/125.00/165.30/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 125 | 125 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30402 | A1 | 6774Obj0000046272 | Objekt | 165.300/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 165 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.40; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
50105160125351x160125125165-18-1 | Půdorys 1.PP | Kus | 0.014 | 50105160125351x160125125165-18-1 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/14.4874/125.0000/125.0000/2/14.4874/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/14.49/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.015 m | IT.02.30403 | A1 | 6774Obj0000046275 | Objekt | 14.487/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.015 | 14 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.009 m2
1520512512514xxxxxx0 | Půdorys 1.PP | Kus | 0 | 1520512512514xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30404 | A1 | 6774Obj0000046278 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125145xxxxx0 | Půdorys 1.PP | Kus | 0.222 | 252x1250125145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/221.7157/125.0000/125.0000/2/221.7157/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/221.72/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.222 m | IT.02.30405 | A1 | 6774Obj0000046281 | Objekt | 221.716/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.222 | 222 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.143 m2
15205125125222xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15205125125222xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30406 | A1 | 6774Obj0000046284 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125145xxxxx0 | Půdorys 1.PP | Kus | 0.014 | 252x1250125145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/14.1593/125.0000/125.0000/2/14.1593/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/14.16/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.014 m | IT.02.30407 | A1 | 6774Obj0000046287 | Objekt | 14.159/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.014 | 14 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.009 m2
1520512512514xxxxxx0 | Půdorys 1.PP | Kus | 0.165 | 1520512512514xxxxxx0 | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/1/165.3000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/35.00/100.00/160.00/125.00/125.00/165.30/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 125 | 125 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30408 | A1 | 6774Obj0000046309 | Objekt | 165.300/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 165 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.43; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
50105160125351x160125125165-18-1 | Půdorys 1.PP | Kus | 1.463 | 50105160125351x160125125165-18-1 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1463.0342/125.0000/125.0000/2/1463.0342/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/1463.03/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.463 m | IT.02.30409 | A1 | 6774Obj0000046312 | Objekt | 1463.034/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1.463 | 1463 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.942 m2
 | Půdorys 1.PP | Kus | 0.165 |  | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/1/165.3000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/35.00/100.00/160.00/125.00/125.00/165.30/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 125 | 125 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30410 | A1 | 6774Obj0000046334 | Objekt | 165.300/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 165 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.50; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
50105160125351x160125125165-18-1 | Půdorys 1.PP | Kus | 0.165 | 50105160125351x160125125165-18-1 | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/1000.0000/160.0000/160.0000/1/165.3000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/35.00/100.00/160.00/125.00/125.00/165.30/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 125 | 125 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30411 | A1 | 6774Obj0000046356 | Objekt | 165.300/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 165 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.8; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
macro | Půdorys 1.PP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.02.30412 | A1 | 6774Obj0000046370 | Objekt | 1162.500/8498.128/-410.500/1037.500/8188.128/-535.500/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2022/11/04; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.PP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.02.30413 | A1 | 6774Obj0000046384 | Objekt | 4962.500/9130.628/-410.500/4837.500/8820.628/-535.500/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2022/11/04; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.PP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/-1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.02.30414 | A1 | 6774Obj0000046398 | Objekt | 10062.500/8883.428/-410.500/9937.500/8573.428/-535.500/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2022/11/04; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.PP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/-1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.02.30415 | A1 | 6774Obj0000046412 | Objekt | 8456.600/6164.761/-410.500/8331.592/5854.758/-535.500/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2022/11/04; N_FREI_68: SPIRO POTRUBÍ
