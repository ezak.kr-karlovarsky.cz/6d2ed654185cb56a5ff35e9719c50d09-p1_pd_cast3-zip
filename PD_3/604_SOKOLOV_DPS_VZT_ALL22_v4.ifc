Properties of the parts of a building model (IFC2X3), part 28 of 51

# IfcFlowFitting (2887)
Name | In | Jednotka | Délka (m) | Označení | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_DIM | L_BES_DIM_A2 | L_BES_DIM_B2 | L_BES_DIM_A | K_VOLSTROM | K_MLH_GOST = K_MLD_GOST | K_LISTVALUE | Kód prvku | Třída reakce na oheň | Allright_Stavebni_dil_ID | Název_objektu | K_EBT_BOX_WC | Plocha | L_BES_LAENGE | K_INTERNAL_ISO | Tloušťka (m) | Součinitel tepelné vodivost
152042x2x209xxxxxx0 | Půdorys 1.NP | Kus | 0.216 | 152042x2x209xxxxxx0 | UEBERGANG ECK/RU AS | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/215.9000/0/-45.0000/0/0/0/0/250.0000/250.0000/2/ | 51/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/250.00/50.00/50.00/160.00/250.00/0/215.90/-32.50/-32.50/0/90.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 315x160 | 250 | 250 | 315 | 0.000 | 0 | 1.000 m2 | IT.03.30242 | B | 6784Obj0000160932 | Objekt | 215.900/157.500/80.000/0.000/-157.500/-170.000/0.000/0.000/0.000/1.000 | 1 | 216 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
51105315250505016025x216-33-3309 | Půdorys 1.NP | Kus | 0.38 | 51105315250505016025x216-33-3309 | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/0/250.0000/250.0000/250.0000/2/190.0000/-190.0000/0/270.0/0/0/1.0000/250.0000/250.0000/2/190.0000/190.0000/0/90.0/0/0/250.0000/250.0000/250.0000/2/ | 75/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/250.00/0/0/380.00/0/190.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | IT.03.30243 | B | 6784Obj0000160936 | Objekt | 315.000/190.000/125.000/0.000/-190.000/-125.000/0.000/0.000/0.000/1.000 | 1 | 380 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
7520625025025x38x19x9xxxx | Půdorys 1.NP | Kus | 0.06 | 7520625025025x38x19x9xxxx | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/250.0000/250.0000/2/60.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/0/0/250.00/250.00/0/60.00/0/0/0/0/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | IT.03.30244 | B | 6784Obj0000160939 | Objekt | 60.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 1 | 60 | __ISO | 0.04 | 0,041 W/m.K
3020425025x025025x6xx03xx | Půdorys 1.NP | Kus | 0.154 | 3020425025x025025x6xx03xx | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/250.0000/250.0000/250.0000/2/154.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/160.00/0/0/250.00/160.00/0/154.00/-45.00/-45.00/-45.00/-45.00/30.00/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 160 | 160 | 250 | 0.000 | 0 | 1.0 | IT.03.30245 | B | 6784Obj0000160942 | Objekt | 154.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 1 | 154 | __ISO | 0.04 | 0,041 W/m.K
3020425016x025016x154-45-45-45-4 | Půdorys 1.NP | Kus | 0.206 | 3020425016x025016x154-45-45-45-4 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/206.3049/160.0000/160.0000/2/206.3049/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/206.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.206 m | IT.03.30246 | B | 6784Obj0000160945 | Objekt | 206.305/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.206 | 206 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.156 m2
15204160160206xxxxxx0 | Půdorys 1.NP | Kus | 0.405 | 15204160160206xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/405.0000/250.0000/250.0000/2/405.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/405.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.405 m | IT.03.30247 | B | 6784Obj0000160948 | Objekt | 405.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 0.405 | 405 | __ISO | 0.04 | 0,041 W/m.K
15204250250405xxxxxx0 | Půdorys 1.NP | Kus | 0.228 | 15204250250405xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/227.9000/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/227.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.03.30248 | B | 6784Obj0000160962 | Objekt | 227.900/177.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1 | 228 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160
10104315160228xxxxxx0 | Půdorys 1.NP | Kus | 0.021 | 10104315160228xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/20.9788/160.0000/160.0000/2/20.9788/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/20.98/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.021 m | IT.03.30249 | B | 6784Obj0000160965 | Objekt | 20.979/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.021 | 21 | __ISO | 0.04 | 0,041 W/m.K
1520416016021xxxxxx0 | Půdorys 1.NP | Kus | 0 | 1520416016021xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/345.7/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/345.7/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/345.70/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30250 | B | 6784Obj0000160968 | Objekt | 120.000/90.718/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16013xxxxxx | Půdorys 1.NP | Kus | 0.279 | 252x16x16013xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/279.1075/160.0000/160.0000/2/279.1075/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/279.11/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.279 m | IT.03.30251 | B | 6784Obj0000160971 | Objekt | 279.108/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.279 | 279 | __ISO | 0.04 | 0,041 W/m.K
15204160160279xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15204160160279xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/167.6/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/167.6/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/167.60/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30252 | B | 6784Obj0000160974 | Objekt | 120.000/90.718/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16013xxxxxx | Půdorys 1.NP | Kus | 0.021 | 252x16x16013xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/21.0021/160.0000/160.0000/2/21.0021/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/21.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.021 m | IT.03.30253 | B | 6784Obj0000160977 | Objekt | 21.002/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.021 | 21 | __ISO | 0.04 | 0,041 W/m.K
1520416016021xxxxxx0 | Půdorys 1.NP | Kus | 0.06 | 1520416016021xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/60.0000/160.0000/160.0000/2/60.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.060 m | IT.03.30254 | B | 6784Obj0000160980 | Objekt | 60.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.06 | 60 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.045 m2
152041601606xxxxxxx | Půdorys 1.NP | Kus | 0.2 | 152041601606xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/200.0000/160.0000/160.0000/2/200.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/200.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.200 m | IT.03.30255 | B | 6784Obj0000160983 | Objekt | 200.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.2 | 200 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
152052502504xxxxxxx0 | Půdorys 1.NP | Kus | 0.105 | 152052502504xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/105.0382/160.0000/160.0000/2/105.0382/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/105.04/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.105 m | IT.03.30256 | B | 6784Obj0000161003 | Objekt | 105.038/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.105 | 105 | __ISO | 0.04 | 0,041 W/m.K
15204160160105xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15204160160105xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.2/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/90.2/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.20/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30257 | B | 6784Obj0000161006 | Objekt | 120.000/90.718/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16013xxxxxx | Půdorys 1.NP | Kus | 0.18 | 252x16x16013xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/180.2967/160.0000/160.0000/2/180.2967/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/180.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.180 m | IT.03.30258 | B | 6784Obj0000161009 | Objekt | 180.297/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.18 | 180 | __ISO | 0.04 | 0,041 W/m.K
1520416016018xxxxxxx | Půdorys 1.NP | Kus | 0 | 1520416016018xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.2/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/270.2/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.20/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30259 | B | 6784Obj0000161012 | Objekt | 120.000/90.718/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16013xxxxxx | Půdorys 1.NP | Kus | 0.105 | 252x16x16013xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/105.0204/160.0000/160.0000/2/105.0204/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/105.02/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.105 m | IT.03.30260 | B | 6784Obj0000161015 | Objekt | 105.020/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.105 | 105 | __ISO | 0.04 | 0,041 W/m.K
15204160160105xxxxxx0 | Půdorys 1.NP | Kus | 0.129 | 15204160160105xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/129.2837/250.0000/250.0000/2/129.2837/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/129.28/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.129 m | IT.03.30261 | B | 6784Obj0000161018 | Objekt | 129.284/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 0.129 | 129 | __ISO | 0.04 | 0,041 W/m.K
15205250250129xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15205250250129xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/250.0000/250.0000/250.0000/2/64.7048/8.5185/0/15.0/0/90.0/250.0000/250.0000/250.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/90.00/0/250.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | IT.03.30262 | B | 6784Obj0000161021 | Objekt | 97.057/129.259/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x25x250115xxxxx0 | Půdorys 1.NP | Kus | 0.108 | 252x25x250115xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/108.0406/250.0000/250.0000/2/108.0406/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/108.04/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.108 m | IT.03.30263 | B | 6784Obj0000161024 | Objekt | 108.041/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 0.108 | 108 | __ISO | 0.04 | 0,041 W/m.K
15205250250108xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15205250250108xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/250.0000/250.0000/250.0000/2/64.7048/8.5185/0/15.0/0/270.0/250.0000/250.0000/250.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/270.00/0/250.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | IT.03.30264 | B | 6784Obj0000161027 | Objekt | 97.057/129.259/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x25x250115xxxxx0 | Půdorys 1.NP | Kus | 0.129 | 252x25x250115xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/128.7888/250.0000/250.0000/2/128.7888/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/128.79/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.129 m | IT.03.30265 | B | 6784Obj0000161030 | Objekt | 128.789/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 0.129 | 129 | __ISO | 0.04 | 0,041 W/m.K
15205250250129xxxxxx0 | Půdorys 1.NP | Kus | 0.06 | 15205250250129xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/60.0000/100.0000/100.0000/2/60.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 0.060 m | IT.03.30266 | B | 6784Obj0000161033 | Objekt | 60.000/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.06 | 60 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.034 m2
macro | Půdorys 1.NP | Kus | 0.2 | macro | Absperrklappe elektrisch NAK-E | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/-1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/100.00/100.00/200.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30267 | B | 6784Obj0000161047 | Objekt | 32664.998/-9104.727/3115.000/32464.998/-9229.727/3015.000/0.000/0.000/0.000/1.000 | 1 | 200 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_DP_EBT: 0.00; K_DATE: 2023/01/04; N_FREI_68: SPIRO POTRUBÍ
10152041x1x2xxxxxxx0 | Půdorys 1.NP | Kus | 0.425 | 10152041x1x2xxxxxxx0 | T-STCK. GERADE | 20 | 1016 | 3/0/0/0/180.0/0/180.0/315.0000/315.0000/160.0000/1/425.0000/0/0/0/0/180.0/160.0000/315.0000/160.0000/1/212.5000/307.5000/0/90.0/0/180.0/125.0000/125.0000/160.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/125.00/125.00/50.00/50.00/50.00/50.00/160.00/0/0/180.00/425.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.03.30268 | B | 6784Obj0000161103 | Objekt | 425.000/307.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1 | 425 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
701043153151251255050505016x0425 | Půdorys 1.NP | Kus | 0.187 | 701043153151251255050505016x0425 | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/125.0000/160.0000/1/187.0000/0/0/0/0/0/0/100.0000/100.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/100.00/35.00/100.00/160.00/100.00/100.00/187.00/-12.50/-12.50/-30.00/-30.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 125x160 | 100 | 100 | 125 | 0.000 | 0 | 1.000 m2 | IT.03.30269 | B | 6784Obj0000161125 | Objekt | 187.000/62.500/80.000/0.000/-62.500/-80.000/0.000/0.000/0.000/1.000 | 1 | 187 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
501051251x351x1601x1x187-13-13-3 | Půdorys 1.NP | Kus | 0.14 | 501051251x351x1601x1x187-13-13-3 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/320.0000/160.0000/1/140.0000/0/0/0/0/0/1.0000/320.0000/160.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/320.00/160.00/140.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 320x160 | 320 | 160 | 320 | 0.000 | 0 | 1.000 m2 | IT.03.30270 | B | 6784Obj0000161139 | Objekt | 140.000/180.000/100.000/0.000/-180.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 140 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
macro | Půdorys 1.NP | Kus | 0.26 | macro | ABL Regler konst. EN mit Antrieb | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/0/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/320.00/160.00/260.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 |  | 320x160 | 1 | 1 | 1 | 0.000 | 0 |  | IT.03.30271 | B | 6784Obj0000161153 | Objekt | 33910.429/-9074.684/3200.000/33590.429/-9334.684/3040.000/0.000/0.000/0.000/1.000 | 0 | 260 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1; K_LISTVALUE_ISO: 0.330 m2; K_DWGNAME: ${PROD}l\einbauteile\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/04; N_FREI_68: Blech ST37 verzinkt
1x010532016026xxxxxxx | Půdorys 1.NP | Kus | 0.1 | 1x010532016026xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/100.0000/100.0000/2/100.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 0.100 m | IT.03.30272 | B | 6784Obj0000161156 | Objekt | 100.000/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.1 | 100 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.057 m2
152041x1x1xxxxxxx0 | Půdorys 1.NP | Kus | 0.035 | 152041x1x1xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/34.7776/100.0000/100.0000/2/34.7776/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/34.78/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 0.035 m | IT.03.30273 | B | 6784Obj0000161159 | Objekt | 34.778/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.035 | 35 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.020 m2
152041x1x35xxxxxx0 | Půdorys 1.NP | Kus | 0 | 152041x1x35xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/174.0/100.0000/100.0000/100.0000/2/86.6025/50.0000/0/60.0/0/174.0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/174.00/0/100.00/1.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | IT.03.30274 | B | 6784Obj0000161162 | Objekt | 129.904/75.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1x01x16xxxxxx | Půdorys 1.NP | Kus | 0.491 | 252x1x01x16xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/491.1937/100.0000/100.0000/2/491.1937/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/491.19/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 0.491 m | IT.03.30275 | B | 6784Obj0000161165 | Objekt | 491.194/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.491 | 491 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.278 m2
152041x1x491xxxxxx0 | Půdorys 1.NP | Kus | 0 | 152041x1x491xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/357.0/100.0000/100.0000/100.0000/2/86.6025/50.0000/0/60.0/0/357.0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/357.00/0/100.00/1.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | IT.03.30276 | B | 6784Obj0000161168 | Objekt | 129.904/75.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1x01x16xxxxxx | Půdorys 1.NP | Kus | 0.035 | 252x1x01x16xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/34.8514/100.0000/100.0000/2/34.8514/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/34.85/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 0.035 m | IT.03.30277 | B | 6784Obj0000161171 | Objekt | 34.851/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.035 | 35 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.020 m2
152041x1x35xxxxxx0 | Půdorys 1.NP | Kus | 1.197 | 152041x1x35xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/1196.8431/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/1196.84/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.140 m2 | IT.03.30278 | B | 6784Obj0000161185 | Objekt | 1196.843/177.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1.14 | 1197 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160
 | Půdorys 1.NP | Kus | 0.921 |  | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/920.9000/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/920.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 0.870 m2 | IT.03.30279 | B | 6784Obj0000161199 | Objekt | 920.900/177.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 0.87 | 921 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.6; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160
macro | Půdorys 1.NP | Kus | 1.25 | macro | Schalldämpfer | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/250.00/250.00/1250.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Alu kaschiert/100.00 |  | DN250 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30280 | B | 6784Obj0000161215 | Objekt | 27323.826/-4776.500/3155.000/26073.826/-5026.500/2905.000/0.000/0.000/0.000/1.000 |  | 1250 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_DWGNAME: ${PROD}l\einbauteile\schalldaempfer\; K_DP_EBT: 0.00; K_DATE: 2022/05/10; N_FREI_68: POZINK
1015205250250125xxxxxxx | Půdorys 1.NP | Kus | 0.15 | 1015205250250125xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/150.0000/250.0000/250.0000/2/150.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/150.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.150 m | IT.03.30281 | B | 6784Obj0000161217 | Objekt | 150.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 150 | __ISO | 0.04 | 0,041 W/m.K
macro | Půdorys 1.NP | Kus | 1.25 | macro | Schalldämpfer | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/250.00/250.00/1250.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 |  | DN250 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30282 | B | 6784Obj0000161219 | Objekt | 32828.474/-6550.000/3155.000/31578.474/-6800.000/2905.000/0.000/0.000/0.000/1.000 |  | 1250 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_DWGNAME: ${PROD}l\einbauteile\schalldaempfer\; K_DP_EBT: 0.00; K_DATE: 2023/01/19; N_FREI_68: POZINK
152041601601xxxxxx0 | Půdorys 1.NP | Kus | 0 | 152041601601xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/250.0000/250.0000/250.0000/2/176.7767/73.2233/0/45.0/0/0/250.0000/250.0000/250.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/0/0/250.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | IT.03.30283 | B | 6784Obj0000161260 | Objekt | 265.165/161.612/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x25x250145xxxxx0 | Půdorys 1.NP | Kus | 0.413 | 252x25x250145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/413.2233/250.0000/250.0000/2/413.2233/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/413.22/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.413 m | IT.03.30284 | B | 6784Obj0000161263 | Objekt | 413.223/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 0.413 | 413 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.428 m2
15204250250413xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15204250250413xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/250.0000/250.0000/250.0000/2/176.7767/73.2233/0/45.0/0/180.0/250.0000/250.0000/250.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/180.00/0/250.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | IT.03.30285 | B | 6784Obj0000161266 | Objekt | 265.165/161.612/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x25x250145xxxxx0 | Půdorys 1.NP | Kus | 0.205 | 252x25x250145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/205.0000/250.0000/250.0000/2/205.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/205.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.205 m | IT.03.30286 | B | 6784Obj0000161269 | Objekt | 205.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 0.205 | 205 | __ISO | 0.04 | 0,041 W/m.K
15204250250205xxxxxx0 | Půdorys 1.NP | Kus | 0.053 | 15204250250205xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/53.3673/100.0000/100.0000/2/53.3673/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/53.37/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 0.053 m | IT.03.30287 | B | 6784Obj0000161272 | Objekt | 53.367/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.053 | 53 | __ISO | 0.04 | 0,041 W/m.K
152041x1x53xxxxxx0 | Půdorys 1.NP | Kus | 0 | 152041x1x53xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/147.9/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/147.9/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/147.90/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | IT.03.30288 | B | 6784Obj0000161275 | Objekt | 150.000/100.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1x01x19xxxxxx | Půdorys 1.NP | Kus | 0 | 252x1x01x19xxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/100.0000/100.0000/2/97.4761/77.6750/0/77.1/0/0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/0/0/100.00/1.00/77.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | IT.03.30289 | B | 6784Obj0000161278 | Objekt | 146.214/88.837/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1x01x177xxxxx0 | Půdorys 1.NP | Kus | 0.02 | 252x1x01x177xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/19.8386/100.0000/100.0000/2/19.8386/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/19.84/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 0.020 m | IT.03.30290 | B | 6784Obj0000161281 | Objekt | 19.839/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.02 | 20 | __ISO | 0.04 | 0,041 W/m.K
macro | Půdorys 1.NP | Kus | 0.24 | macro | Absperrklappe elektrisch NAK-E | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/-1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/100.00/100.00/240.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 |  | DN100 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30291 | B | 6784Obj0000161295 | Objekt | 34045.940/-5116.023/3080.029/33812.514/-5385.758/2980.029/0.000/0.000/0.000/1.000 | 1 | 240 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_DP_EBT: 0.00; K_DATE: 2023/01/19; N_FREI_68: POZINK
10152041x1x24xxxxxxx | Půdorys 1.NP | Kus | 0.049 | 10152041x1x24xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/49.3000/100.0000/100.0000/2/49.3000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/49.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 0.049 m | IT.03.30292 | B | 6784Obj0000161298 | Objekt | 49.300/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.049 | 49 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
152041x1x49xxxxxx0 | Půdorys 1.NP | Kus | 0.19 | 152041x1x49xxxxxx0 | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/0/250.0000/250.0000/250.0000/2/190.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/95.0000/170.0000/0/90.0/0/0/100.0000/100.0000/100.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/190.00/0/170.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | IT.03.30293 | B | 6784Obj0000161302 | Objekt | 190.000/170.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 1 | 190 | __ISO | 0.04 | 0,041 W/m.K
752042502501x019x17x9xxxx | Půdorys 1.NP | Kus | 0.1 | 752042502501x019x17x9xxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/100.0000/100.0000/2/100.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 0.100 m | IT.03.30294 | B | 6784Obj0000161305 | Objekt | 100.000/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.1 | 100 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
152041x1x1xxxxxxx0 | Půdorys 1.NP | Kus | 0.186 | 152041x1x1xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/185.9000/100.0000/100.0000/2/185.9000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/185.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 0.186 m | IT.03.30295 | B | 6784Obj0000161308 | Objekt | 185.900/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.186 | 186 | __ISO | 0.04 | 0,041 W/m.K
15204160160204xxxxxx0 | Půdorys 1.NP | Kus | 0.54 | 15204160160204xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/540.0000/160.0000/160.0000/2/540.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/540.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.540 m | IT.03.30296 | B | 6784Obj0000161311 | Objekt | 540.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.54 | 540 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.407 m2
1520416016054xxxxxxx | Půdorys 1.NP | Kus | 0.23 | 1520416016054xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/230.0000/160.0000/160.0000/2/230.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/230.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 0.230 m | IT.03.30297 | B | 6784Obj0000161314 | Objekt | 230.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.23 | 230 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
1520516016023xxxxxxx | Půdorys 1.NP | Kus | 0 | 1520516016023xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/270.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.00/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30298 | B | 6784Obj0000161317 | Objekt | 240.000/160.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16019xxxxxx | Půdorys 1.NP | Kus | 0.246 | 252x16x16019xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/245.7071/160.0000/160.0000/2/245.7071/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/245.71/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.246 m | IT.03.30299 | B | 6784Obj0000161320 | Objekt | 245.707/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.246 | 246 | __ISO | 0.04 | 0,041 W/m.K
15204160160246xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15204160160246xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/0/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30300 | B | 6784Obj0000161323 | Objekt | 240.000/160.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16019xxxxxx | Půdorys 1.NP | Kus | 0.204 | 252x16x16019xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/203.8038/160.0000/160.0000/2/203.8038/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/203.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.204 m | IT.03.30301 | B | 6784Obj0000161326 | Objekt | 203.804/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.204 | 204 | __ISO | 0.04 | 0,041 W/m.K
1520416016081xxxxxx0 | Půdorys 1.NP | Kus | 0.081 | 1520416016081xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/80.6122/160.0000/160.0000/2/80.6122/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/80.61/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.081 m | IT.03.30302 | B | 6784Obj0000164154 | Objekt | 80.612/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.081 | 81 | __ISO | 0.04 | 0,041 W/m.K
1520416016081xxxxxx0 | Půdorys 1.NP | Kus | 0.06 | 1520416016081xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/60.0000/250.0000/250.0000/2/60.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.060 m | IT.03.30303 | B | 6784Obj0000164157 | Objekt | 60.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 0.06 | 60 | __ISO | 0.04 | 0,041 W/m.K
152042502506xxxxxxx | Půdorys 1.NP | Kus | 0.26 | 152042502506xxxxxxx | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/0/250.0000/250.0000/250.0000/2/260.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/130.0000/175.0000/0/90.0/0/0/160.0000/160.0000/160.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/160.00/0/0/260.00/0/175.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | IT.03.30304 | B | 6784Obj0000164161 | Objekt | 260.000/175.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 1 | 260 | __ISO | 0.04 | 0,041 W/m.K
7520425025016x26x17509xxxx | Půdorys 1.NP | Kus | 0 | 7520425025016x26x17509xxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/270.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.00/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30305 | B | 6784Obj0000164165 | Objekt | 120.000/90.718/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16013xxxxxx | Půdorys 1.NP | Kus | 0.004 | 252x16x16013xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/4.2563/160.0000/160.0000/2/4.2563/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/4.26/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.004 m | IT.03.30306 | B | 6784Obj0000164168 | Objekt | 4.256/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.004 | 4 | __ISO | 0.04 | 0,041 W/m.K
152041601604xxxxxx0 | Půdorys 1.NP | Kus | 0 | 152041601604xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30307 | B | 6784Obj0000164172 | Objekt | 120.000/90.718/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16013xxxxxx | Půdorys 1.NP | Kus | 0.081 | 252x16x16013xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/80.6018/160.0000/160.0000/2/80.6018/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/80.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.081 m | IT.03.30308 | B | 6784Obj0000164175 | Objekt | 80.602/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.081 | 81 | __ISO | 0.04 | 0,041 W/m.K
15204160160324xxxxxx0 | Půdorys 1.NP | Kus | 0.167 | 15204160160324xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/166.7821/160.0000/160.0000/2/166.7821/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/166.78/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.167 m | IT.03.30309 | B | 6784Obj0000164318 | Objekt | 166.782/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.167 | 167 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.126 m2
15204160160167xxxxxx0 | Půdorys 1.NP | Kus | 0.047 | 15204160160167xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/47.3621/160.0000/160.0000/2/47.3621/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/47.36/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.047 m | IT.03.30310 | B | 6784Obj0000164321 | Objekt | 47.362/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.047 | 47 | __ISO | 0.04 | 0,041 W/m.K
1520416016047xxxxxx0 | Půdorys 1.NP | Kus | 0 | 1520416016047xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/294.7/160.0000/160.0000/160.0000/2/41.4110/5.4519/0/15.0/0/294.7/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/294.70/0/160.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30311 | B | 6784Obj0000164325 | Objekt | 62.117/82.726/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x160115xxxxx0 | Půdorys 1.NP | Kus | 0.383 | 252x16x160115xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/382.7925/160.0000/160.0000/2/382.7925/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/382.79/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.383 m | IT.03.30312 | B | 6784Obj0000164328 | Objekt | 382.792/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.383 | 383 | __ISO | 0.04 | 0,041 W/m.K
15204160160383xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15204160160383xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/115.5/160.0000/160.0000/160.0000/2/41.4110/5.4519/0/15.0/0/115.5/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/115.50/0/160.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30313 | B | 6784Obj0000164332 | Objekt | 62.117/82.726/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x160115xxxxx0 | Půdorys 1.NP | Kus | 0.047 | 252x16x160115xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/47.3455/160.0000/160.0000/2/47.3455/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/47.35/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.047 m | IT.03.30314 | B | 6784Obj0000164335 | Objekt | 47.345/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.047 | 47 | __ISO | 0.04 | 0,041 W/m.K
15204160160361xxxxxxx | Půdorys 1.NP | Kus | 0.324 | 15204160160361xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/324.1116/160.0000/160.0000/2/324.1116/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/324.11/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.324 m | IT.03.30316 | B | 6784Obj0000164341 | Objekt | 324.112/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.324 | 324 | __ISO | 0.04 | 0,041 W/m.K
15204160160324xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15204160160324xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/329.7/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/329.7/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/329.70/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30317 | B | 6784Obj0000164345 | Objekt | 120.000/90.718/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16013xxxxxx | Půdorys 1.NP | Kus | 0.12 | 252x16x16013xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/119.7643/160.0000/160.0000/2/119.7643/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/119.76/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.120 m | IT.03.30318 | B | 6784Obj0000164348 | Objekt | 119.764/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.12 | 120 | __ISO | 0.04 | 0,041 W/m.K
1520416016012xxxxxxx | Půdorys 1.NP | Kus | 0 | 1520416016012xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/153.2/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/153.2/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/153.20/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30319 | B | 6784Obj0000164352 | Objekt | 120.000/90.718/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16013xxxxxx | Půdorys 1.NP | Kus | 0.324 | 252x16x16013xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/324.1263/160.0000/160.0000/2/324.1263/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/324.13/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.324 m | IT.03.30320 | B | 6784Obj0000164355 | Objekt | 324.126/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.324 | 324 | __ISO | 0.04 | 0,041 W/m.K
macro | Půdorys 1.NP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/-1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/200.00/200.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 |  | DN200 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30322 | B | 6784Obj0000164372 | Objekt | 36534.751/-6720.440/3130.000/36334.751/-7030.440/2930.000/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/03; N_FREI_68: SPIRO POTRUBÍ
152042x2x58xxxxxx0 | Půdorys 1.NP | Kus | 0.117 | 152042x2x58xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/116.7025/200.0000/200.0000/2/116.7025/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/116.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.117 m | IT.03.30324 | B | 6784Obj0000164378 | Objekt | 116.703/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.117 | 117 | __ISO | 0.04 | 0,041 W/m.K
7520425025025x38x19x9xxxx | Půdorys 1.NP | Kus | 0.06 | 7520425025025x38x19x9xxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/60.0000/250.0000/250.0000/2/60.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.060 m | IT.03.30326 | B | 6784Obj0000164385 | Objekt | 60.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 0.06 | 60 | __ISO | 0.04 | 0,041 W/m.K
152042502506xxxxxxx | Půdorys 1.NP | Kus | 0.06 | 152042502506xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/60.0000/250.0000/250.0000/2/60.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.060 m | IT.03.30327 | B | 6784Obj0000164388 | Objekt | 60.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 0.06 | 60 | __ISO | 0.04 | 0,041 W/m.K
152042502506xxxxxxx | Půdorys 1.NP | Kus | 0.219 | 152042502506xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/218.7000/200.0000/200.0000/2/218.7000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/218.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.219 m | IT.03.30328 | B | 6784Obj0000164391 | Objekt | 218.700/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.219 | 219 | __ISO | 0.04 | 0,041 W/m.K
152042x2x219xxxxxx0 | Půdorys 1.NP | Kus | 0.103 | 152042x2x219xxxxxx0 | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/2/103.3000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/250.00/0/0/200.00/250.00/0/103.30/25.00/25.00/25.00/25.00/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 250 | 250 | 200 | 0.000 | 0 | 1.0 | IT.03.30329 | B | 6784Obj0000164394 | Objekt | 103.300/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 1 | 103 | __ISO | 0.04 | 0,041 W/m.K
302042x25x02x25x103252525253xx | Půdorys 1.NP | Kus | 0.117 | 302042x25x02x25x103252525253xx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/116.7000/200.0000/200.0000/2/116.7000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/116.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.117 m | IT.03.30330 | B | 6784Obj0000164397 | Objekt | 116.700/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.117 | 117 | __ISO | 0.04 | 0,041 W/m.K
152042x2x117xxxxxx0 | Půdorys 1.NP | Kus | 0 | 152042x2x117xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/168.2/200.0000/200.0000/200.0000/2/141.4214/58.5786/0/45.0/0/168.2/200.0000/200.0000/200.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/168.20/0/200.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | IT.03.30331 | B | 6784Obj0000164401 | Objekt | 212.132/129.289/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x2x02x145xxxxx0 | Půdorys 1.NP | Kus | 0.112 | 252x2x02x145xxxxx0 | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/2/112.0000/0.0399/-0.1415/0/0/0/200.0000/200.0000/200.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/0/0/200.00/200.00/0/112.00/-0.04/0.04/-0.14/0.14/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | IT.03.30332 | B | 6784Obj0000164404 | Objekt | 112.000/100.040/100.000/0.000/-100.000/-100.141/0.000/0.000/0.000/1.000 | 1 | 112 | __ISO | 0.04 | 0,041 W/m.K
302042x2xx2x2x0112-x-x3xx | Půdorys 1.NP | Kus | 0.117 | 302042x2xx2x2x0112-x-x3xx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/116.7000/200.0000/200.0000/2/116.7000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/116.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.117 m | IT.03.30333 | B | 6784Obj0000164407 | Objekt | 116.700/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.117 | 117 | __ISO | 0.04 | 0,041 W/m.K
