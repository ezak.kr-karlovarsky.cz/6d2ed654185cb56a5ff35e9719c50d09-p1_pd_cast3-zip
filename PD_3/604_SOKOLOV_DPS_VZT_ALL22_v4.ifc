Properties of the parts of a building model (IFC2X3), part 36 of 51

# IfcFlowFitting (2887)
Name | In | Jednotka | Délka (m) | Označení | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_DIM | L_BES_DIM_A2 | L_BES_DIM_B2 | L_BES_DIM_A | K_VOLSTROM | K_MLH_GOST = K_MLD_GOST | K_LISTVALUE | Kód prvku | Třída reakce na oheň | Allright_Stavebni_dil_ID | Název_objektu | K_EBT_BOX_WC | Plocha | L_BES_LAENGE | K_INTERNAL_ISO | Tloušťka (m) | Součinitel tepelné vodivost
101052802x15xxxxxxx0 | Půdorys 1.NP | Kus | 1.5 | 101052802x15xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/250.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/250.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x200 | 250 | 200 | 250 | 0.000 | 0 | 1.350 m2 | IT.03.30896 | A2 | 6784Obj0000156498 | Objekt | 1500.000/145.000/120.000/0.000/-145.000/-120.000/0.000/0.000/0.000/1.000 | 1.35 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.62; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.830 m2
101052502x15xxxxxxx0 | Půdorys 1.NP | Kus | 1.093 | 101052502x15xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/200.0000/1/1093.4000/0/0/0/0/0/1.0000/315.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/200.00/1093.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x200 | 315 | 200 | 315 | 0.000 | 0 | 1.130 m2 | IT.03.30897 | A2 | 6784Obj0000156512 | Objekt | 1093.400/177.500/120.000/0.000/-177.500/-120.000/0.000/0.000/0.000/1.000 | 1.13 | 1093 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.70; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.480 m2
101053152x1093xxxxxx0 | Půdorys 1.NP | Kus | 1.313 | 101053152x1093xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/280.0000/200.0000/1/1312.5000/0/0/0/0/0/1.0000/280.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/200.00/1312.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 280x200 | 280 | 200 | 280 | 0.000 | 0 | 1.260 m2 | IT.03.30898 | A2 | 6784Obj0000156526 | Objekt | 1312.500/160.000/120.000/0.000/-160.000/-120.000/0.000/0.000/0.000/1.000 | 1.26 | 1313 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.69; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.680 m2
101052802x1313xxxxxx0 | Půdorys 1.NP | Kus | 0.981 | 101052802x1313xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/355.0000/200.0000/1/980.7000/0/0/0/0/0/1.0000/355.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/355.00/200.00/980.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 355x200 | 355 | 200 | 355 | 0.000 | 0 | 1.090 m2 | IT.03.30899 | A2 | 6784Obj0000156540 | Objekt | 980.700/197.500/120.000/0.000/-197.500/-120.000/0.000/0.000/0.000/1.000 | 1.09 | 981 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.49; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.400 m2
101043552x981xxxxxx0 | Půdorys 1.NP | Kus | 0.753 | 101043552x981xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/450.0000/355.0000/1/753.0000/0/0/0/0/0/1.0000/450.0000/355.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/355.00/753.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x355 | 450 | 355 | 450 | 0.000 | 0 | 1.210 m2 | IT.03.30900 | A2 | 6784Obj0000156554 | Objekt | 753.000/245.000/197.500/0.000/-245.000/-197.500/0.000/0.000/0.000/1.000 | 1.21 | 753 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.48; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355; K_LISTVALUE_ISO: 1.450 m2
10104450355753xxxxxx0 | Půdorys 1.NP | Kus | 1.5 | 10104450355753xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/315.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x200 | 315 | 200 | 315 | 0.000 | 0 | 1.550 m2 | IT.03.30901 | A2 | 6784Obj0000156568 | Objekt | 1500.000/177.500/120.000/0.000/-177.500/-120.000/0.000/0.000/0.000/1.000 | 1.55 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.12; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 2.030 m2
macro | Půdorys 1.NP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/160.00/160.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN160 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30907 | A2 | 6784Obj0000156627 | Objekt | 43525.000/20458.584/2860.000/43215.000/20298.584/2700.000/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/12; N_FREI_68: SPIRO POTRUBÍ
 | Půdorys 1.NP | Kus | 0.171 |  | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/200.0000/200.0000/201.0000/1/170.5000/0/0/0/0/0/0/160.0000/160.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/160.00/35.00/100.00/201.00/160.00/160.00/170.50/-20.00/-20.00/-20.50/-20.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x201 | 160 | 160 | 200 | 0.000 | 0 | 1.000 m2 | IT.03.30908 | A2 | 6784Obj0000156649 | Objekt | 170.500/100.000/100.500/0.000/-100.000/-100.500/0.000/0.000/0.000/1.000 | 1 | 171 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.5; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 201; K_LISTVALUE_ISO: 1.000 m2
501052x160351x201160160171-20-20 | Půdorys 1.NP | Kus | 0.4 | 501052x160351x201160160171-20-20 | T-STCK. GERADE | 20 | 1016 | 3/0/0/0/180.0/0/180.0/315.0000/315.0000/200.0000/1/400.0000/42.5000/0/0/0/180.0/200.0000/400.0000/200.0000/1/200.0000/342.5000/0/90.0/0/180.0/200.0000/200.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/400.00/200.00/200.00/0/85.00/0/0/200.00/0/0/180.00/400.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x200 | 400 | 200 | 315 | 0.000 | 0 | 1.000 m2 | IT.03.30909 | A2 | 6784Obj0000156699 | Objekt | 400.000/342.500/120.000/0.000/-177.500/-120.000/0.000/0.000/0.000/1.000 | 1 | 400 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.39; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
711043154x2x2x085x2xx4x01x1x90 | Půdorys 1.NP | Kus | 0 | 711043154x2x2x085x2xx4x01x1x90 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30910 | A2 | 6784Obj0000156702 | Objekt | 169.706/103.431/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x160145xxxxx0 | Půdorys 1.NP | Kus | 0.334 | 252x16x160145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/334.1422/160.0000/160.0000/2/334.1422/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/334.14/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.334 m | IT.03.30911 | A2 | 6784Obj0000156705 | Objekt | 334.142/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.334 | 334 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.252 m2
15205160160334xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15205160160334xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/270.0/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30912 | A2 | 6784Obj0000156708 | Objekt | 169.706/103.431/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x160145xxxxx0 | Půdorys 1.NP | Kus | 0.125 | 252x16x160145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/160.0000/160.0000/2/125.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/125.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.125 m | IT.03.30913 | A2 | 6784Obj0000156711 | Objekt | 125.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.125 | 125 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.094 m2
15204160160125xxxxxx0 | Půdorys 1.NP | Kus | 0.842 | 15204160160125xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/400.0000/200.0000/1/842.0000/0/0/0/0/0/1.0000/400.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/200.00/842.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x200 | 400 | 200 | 400 | 0.000 | 0 | 1.010 m2 | IT.03.30914 | A2 | 6784Obj0000156725 | Objekt | 842.000/220.000/120.000/0.000/-220.000/-120.000/0.000/0.000/0.000/1.000 | 1.01 | 842 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.15; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200
152042x2x109xxxxxx0 | Půdorys 1.NP | Kus | 0.178 | 152042x2x109xxxxxx0 | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/200.0000/200.0000/200.0000/2/178.3000/0/0/0/0/0/0/250.0000/200.0000/1/ | 50/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/200.00/250.00/35.00/100.00/200.00/200.00/200.00/178.30/25.00/25.00/0/0/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 250 | 200 | 200 | 0.000 | 0 | 1.000 m2 | IT.03.30921 | A2 | 6784Obj0000156765 | Objekt | 178.300/125.000/100.000/0.000/-125.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 178 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.73; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); K_LISTVALUE_ISO: 1.000 m2
502162x250351x2x2x2x1782525x3xx | Půdorys 1.NP | Kus | 0.4 | 502162x250351x2x2x2x1782525x3xx | T-STCK. GERADE | 20 | 1016 | 3/0/0/0/180.0/0/0/250.0000/250.0000/200.0000/1/400.0000/0/0/0/0/0/1.0000/250.0000/200.0000/1/200.0000/225.0000/0/90.0/0/0/200.0000/200.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/200.00/200.00/0/0/0/0/200.00/0/0/0/400.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x200 | 250 | 200 | 250 | 0.000 | 0 | 1.000 m2 | IT.03.30922 | A2 | 6784Obj0000156813 | Objekt | 400.000/225.000/120.000/0.000/-145.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 400 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.75; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
701042502502x2xxx2xx4x01x1x90 | Půdorys 1.NP | Kus | 0.136 | 701042502502x2xxx2xx4x01x1x90 | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/200.0000/201.0000/1/135.9000/0/0/0/0/0/0/200.0000/200.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/35.00/100.00/201.00/200.00/200.00/135.90/0/0/-0.50/-0.50/29.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x201 | 200 | 200 | 200 | 0.000 | 0 | 1.000 m2 | IT.03.30923 | A2 | 6784Obj0000156835 | Objekt | 135.900/100.000/100.500/0.000/-100.000/-100.500/0.000/0.000/0.000/1.000 | 1 | 136 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.76; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 201; K_LISTVALUE_ISO: 1.000 m2
macro | Půdorys 1.NP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/200.00/200.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN200 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30924 | A2 | 6784Obj0000156849 | Objekt | 42511.251/24733.882/3210.000/42201.251/24533.882/3010.000/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/10; N_FREI_68: SPIRO POTRUBÍ
10152062x2x31xxxxxxx | Půdorys 1.NP | Kus | 0.16 | 10152062x2x31xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/159.6000/200.0000/200.0000/2/159.6000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/159.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.160 m | IT.03.30925 | A2 | 6784Obj0000156852 | Objekt | 159.600/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.16 | 160 | __ISO | 0.04 | 0,041 W/m.K
152042x2x16xxxxxxx | Půdorys 1.NP | Kus | 0.464 | 152042x2x16xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/463.7323/200.0000/200.0000/2/463.7323/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/463.73/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.464 m | IT.03.30926 | A2 | 6784Obj0000156855 | Objekt | 463.732/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.464 | 464 | __ISO | 0.04 | 0,041 W/m.K
152062x2x464xxxxxx0 | Půdorys 1.NP | Kus | 0 | 152062x2x464xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/200.0000/200.0000/200.0000/2/141.4214/58.5786/0/45.0/0/180.0/200.0000/200.0000/200.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/180.00/0/200.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | IT.03.30927 | A2 | 6784Obj0000156858 | Objekt | 212.132/129.289/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x2x02x145xxxxx0 | Půdorys 1.NP | Kus | 0.309 | 252x2x02x145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/309.4904/200.0000/200.0000/2/309.4904/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/309.49/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.309 m | IT.03.30928 | A2 | 6784Obj0000156861 | Objekt | 309.490/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.309 | 309 | __ISO | 0.04 | 0,041 W/m.K
152062x2x309xxxxxx0 | Půdorys 1.NP | Kus | 0 | 152062x2x309xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/200.0000/200.0000/200.0000/2/141.4214/58.5786/0/45.0/0/0/200.0000/200.0000/200.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/0/0/200.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | IT.03.30929 | A2 | 6784Obj0000156864 | Objekt | 212.132/129.289/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x2x02x145xxxxx0 | Půdorys 1.NP | Kus | 0.464 | 252x2x02x145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/463.6541/200.0000/200.0000/2/463.6541/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/463.65/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.464 m | IT.03.30930 | A2 | 6784Obj0000156867 | Objekt | 463.654/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.464 | 464 | __ISO | 0.04 | 0,041 W/m.K
152062x2x464xxxxxx0 | Půdorys 1.NP | Kus | 0.356 | 152062x2x464xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/356.4000/125.0000/125.0000/2/356.4000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/356.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.356 m | IT.03.30931 | A2 | 6784Obj0000156870 | Objekt | 356.400/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.356 | 356 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.230 m2
15205125125356xxxxxx0 | Půdorys 1.NP | Kus | 0.295 | 15205125125356xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/295.4000/125.0000/125.0000/2/295.4000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/295.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.295 m | IT.03.30932 | A2 | 6784Obj0000156873 | Objekt | 295.400/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.295 | 295 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.190 m2
macro | Půdorys 1.NP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30933 | A2 | 6784Obj0000156887 | Objekt | 62225.554/19206.221/3322.500/61915.554/19081.221/3197.500/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/10; N_FREI_68: SPIRO POTRUBÍ
 | Půdorys 1.NP | Kus | 0.299 |  | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/299.4000/125.0000/125.0000/2/299.4000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/299.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.299 m | IT.03.30934 | A2 | 6784Obj0000156890 | Objekt | 299.400/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.299 | 299 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.193 m2
15205125125299xxxxxx0 | Půdorys 1.NP | Kus | 0.28 | 15205125125299xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/280.4000/125.0000/125.0000/2/280.4000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/280.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.280 m | IT.03.30935 | A2 | 6784Obj0000156893 | Objekt | 280.400/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.28 | 280 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.181 m2
macro | Půdorys 1.NP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30936 | A2 | 6784Obj0000156907 | Objekt | 62255.554/12213.221/3322.500/61945.554/12088.221/3197.500/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/10; N_FREI_68: SPIRO POTRUBÍ
 | Půdorys 1.NP | Kus | 0.275 |  | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/275.4000/125.0000/125.0000/2/275.4000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/275.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.275 m | IT.03.30937 | A2 | 6784Obj0000156910 | Objekt | 275.400/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.275 | 275 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.177 m2
macro | Půdorys 1.NP | Kus | 0.28 | macro | Absperrklappe elektrisch NAK-E | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/-1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/100.00/100.00/280.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN100 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30938 | A2 | 6784Obj0000156924 | Objekt | 47120.485/873.251/2998.000/46995.485/593.251/2898.000/0.000/0.000/0.000/1.000 | 1 | 280 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_DP_EBT: 0.00; K_DATE: 2023/01/10; N_FREI_68: SPIRO POTRUBÍ
10152041x1x28xxxxxxx | Půdorys 1.NP | Kus | 0.22 | 10152041x1x28xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/220.0000/100.0000/100.0000/2/220.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/220.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 0.220 m | IT.03.30939 | A2 | 6784Obj0000156927 | Objekt | 220.000/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.22 | 220 | __ISO | 0.04 | 0,041 W/m.K
152061x1x22xxxxxxx | Půdorys 1.NP | Kus | 1.013 | 152061x1x22xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1013.3000/100.0000/100.0000/2/1013.3000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/1013.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.013 m | IT.03.30940 | A2 | 6784Obj0000156930 | Objekt | 1013.300/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1.013 | 1013 | __ISO | 0.04 | 0,041 W/m.K
macro | Půdorys 1.NP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30941 | A2 | 6784Obj0000156944 | Objekt | 54099.914/-8419.289/3322.500/53789.914/-8544.289/3197.500/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/10; N_FREI_68: SPIRO POTRUBÍ
 | Půdorys 1.NP | Kus | 0.207 |  | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/206.6134/125.0000/125.0000/2/206.6134/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/206.61/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.207 m | IT.03.30942 | A2 | 6784Obj0000156947 | Objekt | 206.613/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.207 | 207 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.133 m2
15205125125207xxxxxx0 | Půdorys 1.NP | Kus | 0.146 | 15205125125207xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/146.0000/125.0000/125.0000/2/146.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/146.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.146 m | IT.03.30943 | A2 | 6784Obj0000156950 | Objekt | 146.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.146 | 146 | __ISO | 0.04 | 0,041 W/m.K
15205125125146xxxxxx0 | Půdorys 1.NP | Kus | 0.008 | 15205125125146xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/7.9160/125.0000/125.0000/2/7.9160/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/7.92/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.008 m | IT.03.30944 | A2 | 6784Obj0000156953 | Objekt | 7.916/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.008 | 8 | __ISO | 0.04 | 0,041 W/m.K
152051251258xxxxxx0 | Půdorys 1.NP | Kus | 0 | 152051251258xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/205.8/125.0000/125.0000/125.0000/2/110.0597/65.7390/0/61.7/0/205.8/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/205.80/0/125.00/1.00/61.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.03.30945 | A2 | 6784Obj0000156956 | Objekt | 165.090/95.369/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125162xxxxx0 | Půdorys 1.NP | Kus | 0.75 | 252x1250125162xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/750.2148/125.0000/125.0000/2/750.2148/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/750.21/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.750 m | IT.03.30946 | A2 | 6784Obj0000156959 | Objekt | 750.215/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.75 | 750 | __ISO | 0.04 | 0,041 W/m.K
1520512512575xxxxxxx | Půdorys 1.NP | Kus | 0 | 1520512512575xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/147.3/125.0000/125.0000/125.0000/2/76.0952/25.8308/0/37.5/0/147.3/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/147.30/0/125.00/1.00/37.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.03.30947 | A2 | 6784Obj0000156962 | Objekt | 114.143/75.415/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125138xxxxx0 | Půdorys 1.NP | Kus | 0.03 | 252x1250125138xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.030 m | IT.03.30948 | A2 | 6784Obj0000156965 | Objekt | 30.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.019 m2
152041251253xxxxxxx | Půdorys 1.NP | Kus | 0.03 | 152041251253xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.030 m | IT.03.30949 | A2 | 6784Obj0000156968 | Objekt | 30.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.019 m2
152041251253xxxxxxx | Půdorys 1.NP | Kus | 0 | 152041251253xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.03.30950 | A2 | 6784Obj0000156971 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125145xxxxx0 | Půdorys 1.NP | Kus | 0.367 | 252x1250125145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/366.6726/125.0000/125.0000/2/366.6726/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/366.67/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.367 m | IT.03.30951 | A2 | 6784Obj0000156974 | Objekt | 366.673/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.367 | 367 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.236 m2
15205125125367xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15205125125367xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.03.30952 | A2 | 6784Obj0000156977 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125145xxxxx0 | Půdorys 1.NP | Kus | 0.961 | 252x1250125145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/961.3000/125.0000/125.0000/2/961.3000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/961.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.961 m | IT.03.30953 | A2 | 6784Obj0000156980 | Objekt | 961.300/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.961 | 961 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.619 m2
15205125125961xxxxxx0 | Půdorys 1.NP | Kus | 0.225 | 15205125125961xxxxxx0 | T-STCK. GERADE | 20 | 1016 | 3/0/0/0/180.0/0/90.0/200.0000/200.0000/280.0000/1/225.0000/0/0/0/0/90.0/1.0000/200.0000/280.0000/1/112.5000/190.0000/0/90.0/0/90.0/200.0000/200.0000/125.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/280.00/125.00/125.00/0/0/0/0/200.00/0/0/90.00/225.00/0/50.00/50.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x280 | 200 | 280 | 200 | 0.000 | 0 | 1.000 m2 | IT.03.30954 | A2 | 6784Obj0000157004 | Objekt | 225.000/190.000/120.000/0.000/-160.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 225 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 280; K_LISTVALUE_ISO: 1.000 m2
70104280280125125xx2xx2250505090 | Půdorys 1.NP | Kus | 0.136 | 70104280280125125xx2xx2250505090 | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/200.0000/200.0000/125.0000/1/135.9000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/125.00/35.00/100.00/125.00/125.00/125.00/135.90/-37.50/-37.50/0/0/89.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x125 | 125 | 125 | 200 | 0.000 | 0 | 1.000 m2 | IT.03.30955 | A2 | 6784Obj0000157026 | Objekt | 135.900/100.000/62.500/0.000/-100.000/-62.500/0.000/0.000/0.000/1.000 | 1 | 136 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 125; K_LISTVALUE_ISO: 1.000 m2
501052x125351x125125125136-38-38 | Půdorys 1.NP | Kus | 0.003 | 501052x125351x125125125136-38-38 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/3.1227/125.0000/125.0000/2/3.1227/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/3.12/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.003 m | IT.03.30956 | A2 | 6784Obj0000157029 | Objekt | 3.123/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.003 | 3 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.002 m2
152051251253xxxxxx0 | Půdorys 1.NP | Kus | 0 | 152051251253xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.03.30957 | A2 | 6784Obj0000157032 | Objekt | 93.750/70.873/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012513xxxxxx | Půdorys 1.NP | Kus | 0.31 | 252x125012513xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/310.0000/125.0000/125.0000/2/310.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.310 m | IT.03.30958 | A2 | 6784Obj0000157035 | Objekt | 310.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.31 | 310 | __ISO | 0.04 | 0,041 W/m.K
macro | Půdorys 1.NP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30959 | A2 | 6784Obj0000157049 | Objekt | 53216.521/-1647.370/3322.500/52906.521/-1772.370/3197.500/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/17; N_FREI_68: SPIRO POTRUBÍ
 | Půdorys 1.NP | Kus | 1.5 |  | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/200.0000/280.0000/1/1500.0000/0/0/0/0/0/1.0000/200.0000/280.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/280.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x280 | 200 | 280 | 200 | 0.000 | 0 | 1.440 m2 | IT.03.30960 | A2 | 6784Obj0000157063 | Objekt | 1500.000/120.000/160.000/0.000/-120.000/-160.000/0.000/0.000/0.000/1.000 | 1.44 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.5; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 280
101052x28015xxxxxxx0 | Půdorys 1.NP | Kus | 0.269 | 101052x28015xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/200.0000/280.0000/1/268.9000/0/0/0/0/0/1.0000/200.0000/280.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/280.00/268.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x280 | 200 | 280 | 200 | 0.000 | 0 | 1.000 m2 | IT.03.30961 | A2 | 6784Obj0000157077 | Objekt | 268.900/120.000/160.000/0.000/-120.000/-160.000/0.000/0.000/0.000/1.000 | 1 | 269 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.6; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 280
101052x280269xxxxxx0 | Půdorys 1.NP | Kus | 1.03 | 101052x280269xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/200.0000/280.0000/1/1030.3000/0/0/0/0/0/1.0000/200.0000/280.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/280.00/1030.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x280 | 200 | 280 | 200 | 0.000 | 0 | 0.990 m2 | IT.03.30962 | A2 | 6784Obj0000157091 | Objekt | 1030.300/120.000/160.000/0.000/-120.000/-160.000/0.000/0.000/0.000/1.000 | 0.99 | 1030 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.7; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 280
101052x280103xxxxxxx | Půdorys 1.NP | Kus | 0.385 | 101052x280103xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/385.3000/160.0000/160.0000/2/385.3000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/385.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.385 m | IT.03.30963 | A2 | 6784Obj0000157094 | Objekt | 385.300/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.385 | 385 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.291 m2
15204160160385xxxxxx0 | Půdorys 1.NP | Kus | 0.429 | 15204160160385xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/429.2000/200.0000/200.0000/2/429.2000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/429.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.429 m | IT.03.30964 | A2 | 6784Obj0000157097 | Objekt | 429.200/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.429 | 429 | __ISO | 0.04 | 0,041 W/m.K
152052x2x429xxxxxx0 | Půdorys 1.NP | Kus | 0.752 | 152052x2x429xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/752.0000/200.0000/200.0000/2/752.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/752.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.752 m | IT.03.30965 | A2 | 6784Obj0000157100 | Objekt | 752.000/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.752 | 752 | __ISO | 0.04 | 0,041 W/m.K
152052x2x752xxxxxx0 | Půdorys 1.NP | Kus | 0.03 | 152052x2x752xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/160.0000/160.0000/2/30.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.030 m | IT.03.30966 | A2 | 6784Obj0000157103 | Objekt | 30.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.023 m2
152041601603xxxxxxx | Půdorys 1.NP | Kus | 0.26 | 152041601603xxxxxxx | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/45.0/200.0000/200.0000/200.0000/2/260.0000/0/0/0/0/45.0/1.0000/200.0000/200.0000/2/130.0000/150.0000/0/90.0/0/45.0/160.0000/160.0000/160.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/160.00/0/45.00/260.00/0/150.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | IT.03.30967 | A2 | 6784Obj0000157107 | Objekt | 260.000/150.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 260 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
752042x2x16x26x15x9xxxx | Půdorys 1.NP | Kus | 0 | 752042x2x16x26x15x9xxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/315.0/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/315.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/315.00/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30968 | A2 | 6784Obj0000157110 | Objekt | 240.000/160.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16019xxxxxx | Půdorys 1.NP | Kus | 0.096 | 252x16x16019xxxxxx | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/2/96.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/0/160.00/160.00/0/96.00/0/0/0/0/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30969 | A2 | 6784Obj0000157113 | Objekt | 96.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 96 | __ISO | 0.04 | 0,041 W/m.K
3020416016x016016x96xx3xx | Půdorys 1.NP | Kus | 0.123 | 3020416016x016016x96xx3xx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/123.2031/160.0000/160.0000/2/123.2031/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/123.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.123 m | IT.03.30970 | A2 | 6784Obj0000157116 | Objekt | 123.203/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.123 | 123 | __ISO | 0.04 | 0,041 W/m.K
15204160160123xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15204160160123xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30971 | A2 | 6784Obj0000157119 | Objekt | 169.706/103.431/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x160145xxxxx0 | Půdorys 1.NP | Kus | 0.67 | 252x16x160145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/669.5000/200.0000/200.0000/2/669.5000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/669.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.669 m | IT.03.30972 | A2 | 6784Obj0000157122 | Objekt | 669.500/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.669 | 670 | __ISO | 0.04 | 0,041 W/m.K
152042x2x67xxxxxxx | Půdorys 1.NP | Kus | 2.125 | 152042x2x67xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/2125.2000/200.0000/200.0000/2/2125.2000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/2125.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 2.125 m | IT.03.30973 | A2 | 6784Obj0000157125 | Objekt | 2125.200/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 2.125 | 2125 | __ISO | 0.04 | 0,041 W/m.K
152042x2x2125xxxxxx0 | Půdorys 1.NP | Kus | 0.779 | 152042x2x2125xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/778.6000/160.0000/160.0000/2/778.6000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/778.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.779 m | IT.03.30974 | A2 | 6784Obj0000157128 | Objekt | 778.600/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.779 | 779 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
macro | Půdorys 1.NP | Kus | 0.35 | macro | ABL Regler konst. EN mit Antrieb | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/0/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/250.00/200.00/350.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 |  | 250x200 | 1 | 1 | 1 | 0.000 | 0 |  | IT.03.30975 | A2 | 6784Obj0000157142 | Objekt | 52422.651/-5258.277/3360.000/52172.651/-5608.277/3160.000/0.000/0.000/0.000/1.000 | 0 | 350 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1; K_LISTVALUE_ISO: 0.320 m2; K_DWGNAME: ${PROD}l\einbauteile\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/17; N_FREI_68: Blech ST37 verzinkt
macro | Půdorys 1.NP | Kus | 0.31 | macro | Absperrklappe elektrisch NAK-E | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/200.00/200.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN200 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30976 | A2 | 6784Obj0000157156 | Objekt | 51477.753/-6283.877/3360.000/51227.753/-6593.877/3160.000/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_DP_EBT: 0.00; K_DATE: 2023/01/17; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.NP | Kus | 0.31 | macro | Absperrklappe elektrisch NAK-E | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/200.00/200.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN200 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30977 | A2 | 6784Obj0000157170 | Objekt | 49069.753/-6308.877/3360.000/48819.753/-6618.877/3160.000/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_DP_EBT: 0.00; K_DATE: 2023/01/17; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.NP | Kus | 0.31 | macro | Absperrklappe elektrisch NAK-E | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/200.00/200.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN200 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30978 | A2 | 6784Obj0000157184 | Objekt | 46440.753/-6928.277/3360.000/46130.753/-7178.277/3160.000/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_DP_EBT: 0.00; K_DATE: 2023/01/17; N_FREI_68: SPIRO POTRUBÍ
10152052x2x31xxxxxxx | Půdorys 1.NP | Kus | 1.15 | 10152052x2x31xxxxxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/250.0000/200.0000/1/1150.0000/0/0/0/0/0/1.0000/250.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/200.00/1150.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x200 | 250 | 200 | 250 | 0.000 | 0 | 1.040 m2 | IT.03.30979 | A2 | 6784Obj0000157198 | Objekt | 1150.000/145.000/120.000/0.000/-145.000/-120.000/0.000/0.000/0.000/1.000 | 1.04 | 1150 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.040 m2
macro | Půdorys 1.NP | Kus | 0.35 | macro | ABL Regler konst. EN mit Antrieb | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/0/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/250.00/200.00/350.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 |  | 250x200 | 1 | 1 | 1 | 0.000 | 0 |  | IT.03.30980 | A2 | 6784Obj0000157212 | Objekt | 51813.914/-8294.289/3360.000/51463.914/-8544.289/3160.000/0.000/0.000/0.000/1.000 | 0 | 350 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1; K_LISTVALUE_ISO: 0.320 m2; K_DWGNAME: ${PROD}l\einbauteile\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/17; N_FREI_68: Blech ST37 verzinkt
macro | Půdorys 1.NP | Kus | 0.31 | macro | Absperrklappe elektrisch NAK-E | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/200.00/200.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN200 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30981 | A2 | 6784Obj0000157240 | Objekt | 42580.014/-7028.300/3200.000/42330.014/-7338.300/3000.000/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_DP_EBT: 0.00; K_DATE: 2023/01/17; N_FREI_68: SPIRO POTRUBÍ
10152052x2x31xxxxxxx | Půdorys 1.NP | Kus | 1.5 | 10152052x2x31xxxxxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/200.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x200 | 200 | 200 | 200 | 0.000 | 0 | 1.200 m2 | IT.03.30982 | A2 | 6784Obj0000157254 | Objekt | 1500.000/120.000/120.000/0.000/-120.000/-120.000/0.000/0.000/0.000/1.000 | 1.2 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.54; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.680 m2
101052x2x15xxxxxxx0 | Půdorys 1.NP | Kus | 1.15 | 101052x2x15xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/250.0000/200.0000/1/1150.0000/0/0/0/0/0/1.0000/250.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/200.00/1150.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x200 | 250 | 200 | 250 | 0.000 | 0 | 1.040 m2 | IT.03.30983 | A2 | 6784Obj0000157268 | Objekt | 1150.000/145.000/120.000/0.000/-145.000/-120.000/0.000/0.000/0.000/1.000 | 1.04 | 1150 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.040 m2
101052502x115xxxxxxx | Půdorys 1.NP | Kus | 1.5 | 101052502x115xxxxxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/355.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/355.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/355.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 355x200 | 355 | 200 | 355 | 0.000 | 0 | 1.660 m2 | IT.03.30984 | A2 | 6784Obj0000157282 | Objekt | 1500.000/197.500/120.000/0.000/-197.500/-120.000/0.000/0.000/0.000/1.000 | 1.66 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.20; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 2.150 m2
101043552x15xxxxxxx0 | Půdorys 1.NP | Kus | 1.5 | 101043552x15xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/280.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/280.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 280x200 | 280 | 200 | 280 | 0.000 | 0 | 1.440 m2 | IT.03.30985 | A2 | 6784Obj0000157296 | Objekt | 1500.000/160.000/120.000/0.000/-160.000/-120.000/0.000/0.000/0.000/1.000 | 1.44 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.6; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.920 m2
101042802x15xxxxxxx0 | Půdorys 1.NP | Kus | 0.004 | 101042802x15xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/4.0000/125.0000/125.0000/2/4.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/4.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.004 m | IT.03.30986 | A2 | 6784Obj0000157299 | Objekt | 4.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.004 | 4 | __ISO | 0.04 | 0,041 W/m.K
152051251254xxxxxx0 | Půdorys 1.NP | Kus | 1.151 | 152051251254xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/500.0000/200.0000/1/1150.8000/0/0/0/0/0/1.0000/500.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/200.00/1150.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 500x200 | 500 | 200 | 500 | 0.000 | 0 | 1.610 m2 | IT.03.30987 | A2 | 6784Obj0000157313 | Objekt | 1150.800/270.000/120.000/0.000/-270.000/-120.000/0.000/0.000/0.000/1.000 | 1.61 | 1151 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.980 m2
101045x2x1151xxxxxx0 | Půdorys 1.NP | Kus | 0.837 | 101045x2x1151xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/500.0000/200.0000/1/836.5000/0/0/0/0/0/1.0000/500.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/200.00/836.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 500x200 | 500 | 200 | 500 | 0.000 | 0 | 1.170 m2 | IT.03.30988 | A2 | 6784Obj0000157327 | Objekt | 836.500/270.000/120.000/0.000/-270.000/-120.000/0.000/0.000/0.000/1.000 | 1.17 | 837 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200
101045x2x837xxxxxx0 | Půdorys 1.NP | Kus | 0.6 | 101045x2x837xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/500.0000/200.0000/1/600.0000/0/0/0/0/0/1.0000/500.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/200.00/600.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 500x200 | 500 | 200 | 500 | 0.000 | 0 | 1.000 m2 | IT.03.30989 | A2 | 6784Obj0000157341 | Objekt | 600.000/270.000/120.000/0.000/-270.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 600 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200
