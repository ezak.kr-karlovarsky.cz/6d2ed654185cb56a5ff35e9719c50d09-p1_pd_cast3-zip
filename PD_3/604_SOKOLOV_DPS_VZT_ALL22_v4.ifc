Properties of the parts of a building model (IFC2X3), part 34 of 51

# IfcFlowFitting (2887)
Name | In | Jednotka | Délka (m) | Označení | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_DIM | L_BES_DIM_A2 | L_BES_DIM_B2 | L_BES_DIM_A | K_VOLSTROM | K_MLH_GOST = K_MLD_GOST | K_LISTVALUE | Kód prvku | Třída reakce na oheň | Allright_Stavebni_dil_ID | Název_objektu | K_EBT_BOX_WC | Plocha | L_BES_LAENGE | K_INTERNAL_ISO | Tloušťka (m) | Součinitel tepelné vodivost
252x1x01x19xxxxxx | Půdorys 1.NP | Kus | 0.31 | 252x1x01x19xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/310.0000/100.0000/100.0000/2/310.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 0.310 m | IT.03.30729 | A2 | 6784Obj0000154598 | Objekt | 310.000/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.31 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.175 m2
152041x1x31xxxxxxx | Půdorys 1.NP | Kus | 0.03 | 152041x1x31xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/160.0000/160.0000/2/30.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.030 m | IT.03.30730 | A2 | 6784Obj0000154601 | Objekt | 30.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.023 m2
152041601603xxxxxxx | Půdorys 1.NP | Kus | 0 | 152041601603xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/224.9/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/224.9/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/224.90/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30731 | A2 | 6784Obj0000154604 | Objekt | 240.000/160.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16019xxxxxx | Půdorys 1.NP | Kus | 0.22 | 252x16x16019xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/219.9826/160.0000/160.0000/2/219.9826/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/219.98/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.220 m | IT.03.30732 | A2 | 6784Obj0000154607 | Objekt | 219.983/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.22 | 220 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.166 m2
1520416016022xxxxxxx | Půdorys 1.NP | Kus | 0 | 1520416016022xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30733 | A2 | 6784Obj0000154610 | Objekt | 169.706/103.431/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x160145xxxxx0 | Půdorys 1.NP | Kus | 0.26 | 252x16x160145xxxxx0 | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/315.0/200.0000/200.0000/200.0000/2/260.0000/0/0/0/0/315.0/1.0000/200.0000/200.0000/2/130.0000/150.0000/0/90.0/0/315.0/160.0000/160.0000/160.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/160.00/0/315.00/260.00/0/150.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | IT.03.30734 | A2 | 6784Obj0000154614 | Objekt | 260.000/150.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 260 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
752042x2x16x26x15x9xxxx | Půdorys 1.NP | Kus | 0.03 | 752042x2x16x26x15x9xxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/160.0000/160.0000/2/30.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.030 m | IT.03.30735 | A2 | 6784Obj0000154617 | Objekt | 30.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.023 m2
152041601603xxxxxxx | Půdorys 1.NP | Kus | 0.26 | 152041601603xxxxxxx | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/315.0/200.0000/200.0000/200.0000/2/260.0000/0/0/0/0/315.0/1.0000/200.0000/200.0000/2/130.0000/150.0000/0/90.0/0/315.0/160.0000/160.0000/160.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/160.00/0/315.00/260.00/0/150.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | IT.03.30736 | A2 | 6784Obj0000154621 | Objekt | 260.000/150.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 260 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
752042x2x16x26x15x9xxxx | Půdorys 1.NP | Kus | 0.133 | 752042x2x16x26x15x9xxxx | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/133.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/200.00/0/0/125.00/200.00/0/133.00/37.50/37.50/37.50/37.50/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 200 | 200 | 125 | 0.000 | 0 | 1.0 | IT.03.30737 | A2 | 6784Obj0000154624 | Objekt | 133.000/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 133 | __ISO | 0.04 | 0,041 W/m.K
302041252xx1252x0133383838383xx | Půdorys 1.NP | Kus | 0 | 302041252xx1252x0133383838383xx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/289.8/160.0000/160.0000/160.0000/2/96.5133/32.3866/0/37.1/0/289.8/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/289.80/0/160.00/1.00/37.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30738 | A2 | 6784Obj0000154627 | Objekt | 144.770/96.193/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x160137xxxxx0 | Půdorys 1.NP | Kus | 0 | 252x16x160137xxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/8.3/160.0000/160.0000/160.0000/2/156.6188/127.2806/0/78.2/0/8.3/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/8.30/0/160.00/1.00/78.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30739 | A2 | 6784Obj0000154630 | Objekt | 234.928/143.640/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x160178xxxxx0 | Půdorys 1.NP | Kus | 0.067 | 252x16x160178xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/66.5485/160.0000/160.0000/2/66.5485/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/66.55/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.067 m | IT.03.30740 | A2 | 6784Obj0000154633 | Objekt | 66.549/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.067 | 67 | __ISO | 0.04 | 0,041 W/m.K
1520416016067xxxxxx0 | Půdorys 1.NP | Kus | 0.133 | 1520416016067xxxxxx0 | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/133.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/200.00/0/0/125.00/200.00/0/133.00/37.50/37.50/37.50/37.50/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 200 | 200 | 125 | 0.000 | 0 | 1.0 | IT.03.30741 | A2 | 6784Obj0000154636 | Objekt | 133.000/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 133 | __ISO | 0.04 | 0,041 W/m.K
302041252xx1252x0133383838383xx | Půdorys 1.NP | Kus | 1.405 | 302041252xx1252x0133383838383xx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1405.0000/200.0000/200.0000/2/1405.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/1405.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.405 m | IT.03.30742 | A2 | 6784Obj0000154639 | Objekt | 1405.000/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1.405 | 1405 | __ISO | 0.04 | 0,041 W/m.K
152042x2x1405xxxxxx0 | Půdorys 1.NP | Kus | 2.912 | 152042x2x1405xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/2911.5000/125.0000/125.0000/2/2911.5000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/2911.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 2.912 m | IT.03.30743 | A2 | 6784Obj0000154642 | Objekt | 2911.500/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 2.912 | 2912 | __ISO | 0.04 | 0,041 W/m.K
 | Půdorys 1.NP | Kus | 4.368 |  | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/4367.7000/200.0000/200.0000/2/4367.7000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/4367.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 4.368 m | IT.03.30744 | A2 | 6784Obj0000154645 | Objekt | 4367.700/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 4.368 | 4368 | __ISO | 0.04 | 0,041 W/m.K
152042x2x4368xxxxxx0 | Půdorys 1.NP | Kus | 0 | 152042x2x4368xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/270.0/450.0000/450.0000/200.0000/1/230.1961/99.8534/0/46.9/0/270.0/1.0000/450.0000/200.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/0/50.00/50.00/450.00/100.00/46.90/270.00/1.00/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.120 m2 | IT.03.30745 | A2 | 6784Obj0000154727 | Objekt | 317.816/181.846/245.000/0.000/-120.000/-245.000/0.000/0.000/0.000/1.000 | 1.12 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200
201042x2x050504501x4745xxxx | Půdorys 1.NP | Kus | 0.192 | 201042x2x050504501x4745xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/192.1398/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/192.14/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.000 m2 | IT.03.30746 | A2 | 6784Obj0000154741 | Objekt | 192.140/245.000/120.000/0.000/-245.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 192 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200
101044502x192xxxxxx0 | Půdorys 1.NP | Kus | 0 | 101044502x192xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/270.0/450.0000/450.0000/200.0000/1/230.1961/99.8534/0/46.9/0/270.0/1.0000/450.0000/200.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/0/50.00/50.00/450.00/100.00/46.90/270.00/1.00/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.120 m2 | IT.03.30747 | A2 | 6784Obj0000154823 | Objekt | 317.816/181.846/245.000/0.000/-120.000/-245.000/0.000/0.000/0.000/1.000 | 1.12 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200
macro | Půdorys 1.NP | Kus | 0.29 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/290.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30748 | A2 | 6784Obj0000154851 | Objekt | 46961.985/1265.751/3010.500/46671.985/1140.751/2885.500/0.000/0.000/0.000/1.000 | 1 | 290 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/10; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.NP | Kus | 0.3 | macro | ZG Klappe | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/-1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/100.00/100.00/300.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN100 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30749 | A2 | 6784Obj0000154865 | Objekt | 47110.485/-420.000/2998.000/47010.485/-720.000/2898.000/0.000/0.000/0.000/1.000 | 1 | 300 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\zentralgeräte\zg klappen\; K_DP_EBT: 0.00; K_DATE: 2023/01/11; N_FREI_68: SPIRO POTRUBÍ
10152041x1x3xxxxxxx0 | Půdorys 1.NP | Kus | 0 | 10152041x1x3xxxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/270.0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/270.00/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | IT.03.30750 | A2 | 6784Obj0000154868 | Objekt | 150.000/100.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1x01x19xxxxxx | Půdorys 1.NP | Kus | 0.05 | 252x1x01x19xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/50.0000/100.0000/100.0000/2/50.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 0.050 m | IT.03.30751 | A2 | 6784Obj0000154871 | Objekt | 50.000/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.05 | 50 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.028 m2
152041x1x5xxxxxxx | Půdorys 1.NP | Kus | 0.198 | 152041x1x5xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/198.0000/100.0000/100.0000/2/198.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/198.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 0.198 m | IT.03.30752 | A2 | 6784Obj0000154874 | Objekt | 198.000/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.198 | 198 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.112 m2
152051x1x198xxxxxx0 | Půdorys 1.NP | Kus | 0.19 | 152051x1x198xxxxxx0 | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/190.0000/0/0/0/0/0/1.0000/125.0000/125.0000/2/95.0000/110.0000/0/90.0/0/0/100.0000/100.0000/100.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/100.00/0/0/190.00/0/110.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.03.30753 | A2 | 6784Obj0000154878 | Objekt | 190.000/110.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 | 190 | __ISO | 0.04 | 0,041 W/m.K
752041251251x019x11x9xxxx | Půdorys 1.NP | Kus | 0.03 | 752041251251x019x11x9xxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.030 m | IT.03.30754 | A2 | 6784Obj0000154881 | Objekt | 30.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.019 m2
152041251253xxxxxxx | Půdorys 1.NP | Kus | 0 | 152041251253xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.03.30755 | A2 | 6784Obj0000154884 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125145xxxxx0 | Půdorys 1.NP | Kus | 0.208 | 252x1250125145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/208.2806/125.0000/125.0000/2/208.2806/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/208.28/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.208 m | IT.03.30756 | A2 | 6784Obj0000154887 | Objekt | 208.281/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.208 | 208 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.134 m2
15204125125208xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15204125125208xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.03.30757 | A2 | 6784Obj0000154890 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125145xxxxx0 | Půdorys 1.NP | Kus | 0.004 | 252x1250125145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/3.5000/125.0000/125.0000/2/3.5000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/3.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.004 m | IT.03.30758 | A2 | 6784Obj0000154893 | Objekt | 3.500/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.004 | 4 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.002 m2
152051251254xxxxxx0 | Půdorys 1.NP | Kus | 0.504 | 152051251254xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/504.3000/100.0000/100.0000/2/504.3000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/504.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 0.504 m | IT.03.30759 | A2 | 6784Obj0000154896 | Objekt | 504.300/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.504 | 504 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.285 m2
152041x1x504xxxxxx0 | Půdorys 1.NP | Kus | 5.342 | 152041x1x504xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/5342.3000/125.0000/125.0000/2/5342.3000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/5342.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 5.342 m | IT.03.30760 | A2 | 6784Obj0000154899 | Objekt | 5342.300/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 5.342 | 5342 | __ISO | 0.04 | 0,041 W/m.K
 | Půdorys 1.NP | Kus | 0.03 |  | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/160.0000/160.0000/2/30.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.030 m | IT.03.30761 | A2 | 6784Obj0000154902 | Objekt | 30.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.023 m2
152041601603xxxxxxx | Půdorys 1.NP | Kus | 0.17 | 152041601603xxxxxxx | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/200.0000/200.0000/200.0000/1/169.6000/0/0/0/0/0/0/160.0000/160.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/160.00/35.00/100.00/200.00/160.00/160.00/169.60/-20.00/-20.00/-20.00/-20.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x200 | 160 | 160 | 200 | 0.000 | 0 | 1.000 m2 | IT.03.30762 | A2 | 6784Obj0000154924 | Objekt | 169.600/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 170 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.35; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
501052x160351x2x160160170-20-20- | Půdorys 1.NP | Kus | 0 | 501052x160351x2x160160170-20-20- | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/315.0/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/315.0/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/315.00/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30763 | A2 | 6784Obj0000154927 | Objekt | 240.000/160.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16019xxxxxx | Půdorys 1.NP | Kus | 0.22 | 252x16x16019xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/219.6934/160.0000/160.0000/2/219.6934/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/219.69/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.220 m | IT.03.30764 | A2 | 6784Obj0000154930 | Objekt | 219.693/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.22 | 220 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.166 m2
1520516016022xxxxxxx | Půdorys 1.NP | Kus | 0 | 1520516016022xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/89.9/160.0000/160.0000/160.0000/2/112.5432/46.2721/0/44.7/0/89.9/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/89.90/0/160.00/1.00/44.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30765 | A2 | 6784Obj0000154933 | Objekt | 168.815/103.136/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x160145xxxxx0 | Půdorys 1.NP | Kus | 0.074 | 252x16x160145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/73.8000/160.0000/160.0000/2/73.8000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/73.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.074 m | IT.03.30766 | A2 | 6784Obj0000154936 | Objekt | 73.800/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.074 | 74 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.056 m2
1520516016074xxxxxx0 | Půdorys 1.NP | Kus | 0.787 | 1520516016074xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/1/786.5000/0/0/0/0/0/1.0000/200.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/786.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x200 | 200 | 200 | 200 | 0.000 | 0 | 1.000 m2 | IT.03.30767 | A2 | 6784Obj0000154950 | Objekt | 786.500/120.000/120.000/0.000/-120.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 787 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200
101042x2x787xxxxxx0 | Půdorys 1.NP | Kus | 0.4 | 101042x2x787xxxxxx0 | T-STCK. GERADE | 20 | 1016 | 3/0/0/0/180.0/0/180.0/200.0000/200.0000/200.0000/1/400.0000/0/0/0/0/180.0/125.0000/200.0000/200.0000/1/200.0000/200.0000/0/90.0/0/180.0/200.0000/200.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/200.00/200.00/0/0/0/0/200.00/0/0/180.00/400.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x200 | 200 | 200 | 200 | 0.000 | 0 | 1.000 m2 | IT.03.30768 | A2 | 6784Obj0000154998 | Objekt | 400.000/200.000/120.000/0.000/-120.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 400 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200
701042x2x2x2xxx2xx4x01x1x90 | Půdorys 1.NP | Kus | 0.136 | 701042x2x2x2xxx2xx4x01x1x90 | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/2/135.9000/0/0/0/0/0/0/200.0000/201.0000/1/ | 50/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/200.00/200.00/35.00/100.00/200.00/201.00/200.00/135.90/0/0/0.50/0.50/29.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 201 | 200 | 0.000 | 0 | 1.000 m2 | IT.03.30769 | A2 | 6784Obj0000155020 | Objekt | 135.900/100.000/100.500/0.000/-100.000/-100.500/0.000/0.000/0.000/1.000 | 1 | 136 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.33; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); K_LISTVALUE_ISO: 1.000 m2
502162x2x351x2x2012x136x1129x0 | Půdorys 1.NP | Kus | 0.064 | 502162x2x351x2x2012x136x1129x0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/64.1000/200.0000/200.0000/2/64.1000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/64.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.064 m | IT.03.30770 | A2 | 6784Obj0000155023 | Objekt | 64.100/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.064 | 64 | __ISO | 0.04 | 0,041 W/m.K
152042x2x64xxxxxx0 | Půdorys 1.NP | Kus | 0 | 152042x2x64xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/200.0000/200.0000/200.0000/2/200.0000/200.0000/0/90.0/0/0/200.0000/200.0000/200.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/0/0/200.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | IT.03.30771 | A2 | 6784Obj0000155026 | Objekt | 300.000/200.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x2x02x19xxxxxx | Půdorys 1.NP | Kus | 0.136 | 252x2x02x19xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/135.9000/200.0000/200.0000/2/135.9000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/135.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.136 m | IT.03.30772 | A2 | 6784Obj0000155029 | Objekt | 135.900/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.136 | 136 | __ISO | 0.04 | 0,041 W/m.K
macro | Půdorys 1.NP | Kus | 0.31 | macro | Absperrklappe elektrisch NAK-E | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/-1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/100.00/100.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN100 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30773 | A2 | 6784Obj0000155100 | Objekt | 44630.134/28245.000/3160.000/44505.134/27935.000/3060.000/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_DP_EBT: 0.00; K_DATE: 2023/01/09; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.NP | Kus | 0.31 | macro | Absperrklappe elektrisch NAK-E | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/-1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/100.00/100.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN100 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30774 | A2 | 6784Obj0000155114 | Objekt | 46945.134/28340.000/3160.000/46820.134/28030.000/3060.000/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_DP_EBT: 0.00; K_DATE: 2023/01/09; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.NP | Kus | 0.31 | macro | Absperrklappe elektrisch NAK-E | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/160.00/160.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN160 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30775 | A2 | 6784Obj0000155128 | Objekt | 48596.000/23289.862/3190.000/48396.000/22979.862/3030.000/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_DP_EBT: 0.00; K_DATE: 2023/01/09; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.NP | Kus | 0.31 | macro | Absperrklappe elektrisch NAK-E | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/100.00/100.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN100 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30776 | A2 | 6784Obj0000155142 | Objekt | 48565.000/24449.981/3160.000/48440.000/24139.981/3060.000/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_DP_EBT: 0.00; K_DATE: 2023/01/09; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.NP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/-1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/200.00/200.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN200 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30777 | A2 | 6784Obj0000155156 | Objekt | 47640.900/20978.584/3209.500/47330.900/20778.584/3009.500/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/10; N_FREI_68: SPIRO POTRUBÍ
1x1-1035xxxxxxxx | Půdorys 1.NP | Kus | 1.5 | 1x1-1035xxxxxxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.950 m2 | IT.03.30778 | A2 | 6784Obj0000155170 | Objekt | 1500.000/245.000/120.000/0.000/-245.000/-120.000/0.000/0.000/0.000/1.000 | 1.95 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.117; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 2.430 m2
101044502x15xxxxxxx0 | Půdorys 1.NP | Kus | 0.057 | 101044502x15xxxxxxx0 | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/57.0000/0/0/0/0/0/180.0000/180.0000/180.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/180.00/0/0/160.00/180.00/0/57.00/10.00/10.00/10.00/10.00/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 180 | 180 | 160 | 0.000 | 0 | 1.0 | IT.03.30779 | A2 | 6784Obj0000155173 | Objekt | 57.000/90.000/90.000/0.000/-90.000/-90.000/0.000/0.000/0.000/1.000 | 1 | 57 | __ISO | 0.04 | 0,041 W/m.K
3020416018x016018x57101010103xx | Půdorys 1.NP | Kus | 0.215 | 3020416018x016018x57101010103xx | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/0/180.0000/180.0000/180.0000/2/215.0000/0/0/0/0/0/180.0000/180.0000/180.0000/2/107.5000/135.0000/0/90.0/0/0/125.0000/125.0000/125.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/180.00/180.00/125.00/0/0/215.00/0/135.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN180 | 180 | 180 | 180 | 0.000 | 0 | 1.0 | IT.03.30780 | A2 | 6784Obj0000155177 | Objekt | 215.000/135.000/90.000/0.000/-90.000/-90.000/0.000/0.000/0.000/1.000 | 1 | 215 | __ISO | 0.04 | 0,041 W/m.K
752041801801250215013509xxxx | Půdorys 1.NP | Kus | 0.152 | 752041801801250215013509xxxx | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/180.0000/180.0000/180.0000/2/152.3000/0/0/0/0/0/0/200.0000/200.0000/1/ | 50/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/180.00/200.00/35.00/100.00/180.00/200.00/180.00/152.30/10.00/10.00/10.00/10.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN180 | 200 | 200 | 180 | 0.000 | 0 | 1.000 m2 | IT.03.30781 | A2 | 6784Obj0000155199 | Objekt | 152.300/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 152 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.23; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); K_LISTVALUE_ISO: 1.000 m2
502161802x351x1802x1801521010101 | Půdorys 1.NP | Kus | 0.4 | 502161802x351x1802x1801521010101 | T-STCK. GERADE | 20 | 1016 | 3/0/0/0/180.0/0/0/200.0000/200.0000/200.0000/1/400.0000/0/0/0/0/0/1.0000/200.0000/200.0000/1/200.0000/200.0000/0/90.0/0/0/200.0000/200.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/200.00/200.00/0/0/0/0/200.00/0/0/0/400.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x200 | 200 | 200 | 200 | 0.000 | 0 | 1.000 m2 | IT.03.30782 | A2 | 6784Obj0000155247 | Objekt | 400.000/200.000/120.000/0.000/-120.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 400 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.24; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
701042x2x2x2xxx2xx4x01x1x90 | Půdorys 1.NP | Kus | 0.17 | 701042x2x2x2xxx2xx4x01x1x90 | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/200.0000/200.0000/200.0000/1/169.6000/0/0/0/0/0/0/160.0000/160.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/160.00/35.00/100.00/200.00/160.00/160.00/169.60/-20.00/-20.00/-20.00/-20.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x200 | 160 | 160 | 200 | 0.000 | 0 | 1.000 m2 | IT.03.30783 | A2 | 6784Obj0000155269 | Objekt | 169.600/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 170 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.25; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
501052x160351x2x160160170-20-20- | Půdorys 1.NP | Kus | 0.26 | 501052x160351x2x160160170-20-20- | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/260.0000/0/0/0/0/180.0/1.0000/160.0000/160.0000/2/130.0000/130.0000/0/90.0/0/180.0/160.0000/160.0000/160.0000/2/ | 75/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/160.00/0/180.00/260.00/0/130.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30784 | A2 | 6784Obj0000155273 | Objekt | 260.000/130.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 260 | __ISO | 0.04 | 0,041 W/m.K
7520516016016x26x13x9xxxx | Půdorys 1.NP | Kus | 0.26 | 7520516016016x26x13x9xxxx | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/260.0000/0/0/0/0/180.0/1.0000/160.0000/160.0000/2/130.0000/130.0000/0/90.0/0/180.0/160.0000/160.0000/160.0000/2/ | 75/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/160.00/0/180.00/260.00/0/130.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30785 | A2 | 6784Obj0000155277 | Objekt | 260.000/130.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 260 | __ISO | 0.04 | 0,041 W/m.K
7520516016016x26x13x9xxxx | Půdorys 1.NP | Kus | 0.112 | 7520516016016x26x13x9xxxx | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/112.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 30/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/100.00/0/0/160.00/100.00/0/112.00/-30.00/-30.00/-30.00/-30.00/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 100 | 100 | 160 | 0.000 | 0 | 1.0 | IT.03.30786 | A2 | 6784Obj0000155280 | Objekt | 112.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 112 | __ISO | 0.04 | 0,041 W/m.K
302051601xx1601x0112-30-30-30-30 | Půdorys 1.NP | Kus | 0 | 302051601xx1601x0112-30-30-30-30 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/180.0/100.0000/100.0000/100.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/180.00/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | IT.03.30787 | A2 | 6784Obj0000155283 | Objekt | 150.000/100.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1x01x19xxxxxx | Půdorys 1.NP | Kus | 1.5 | 252x1x01x19xxxxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/200.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x200 | 200 | 200 | 200 | 0.000 | 0 | 1.200 m2 | IT.03.30788 | A2 | 6784Obj0000155297 | Objekt | 1500.000/120.000/120.000/0.000/-120.000/-120.000/0.000/0.000/0.000/1.000 | 1.2 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.38; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.680 m2
101052x2x15xxxxxxx0 | Půdorys 1.NP | Kus | 0.136 | 101052x2x15xxxxxxx0 | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/200.0000/201.0000/1/135.9000/0/0/0/0/0/0/200.0000/200.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/35.00/100.00/201.00/200.00/200.00/135.90/0/0/-0.50/-0.50/29.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x201 | 200 | 200 | 200 | 0.000 | 0 | 1.000 m2 | IT.03.30789 | A2 | 6784Obj0000155319 | Objekt | 135.900/100.000/100.500/0.000/-100.000/-100.500/0.000/0.000/0.000/1.000 | 1 | 136 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.42; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 201; K_LISTVALUE_ISO: 1.000 m2
501052x2x351x2012x2x136x-1-129x0 | Půdorys 1.NP | Kus | 0.4 | 501052x2x351x2012x2x136x-1-129x0 | T-STCK. GERADE | 20 | 1016 | 3/0/0/0/180.0/0/0/200.0000/200.0000/200.0000/1/400.0000/57.5000/0/0/0/0/200.0000/315.0000/200.0000/1/200.0000/315.0000/0/90.0/0/0/200.0000/200.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/315.00/200.00/200.00/0/115.00/0/0/200.00/0/0/0/400.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x200 | 315 | 200 | 200 | 0.000 | 0 | 1.000 m2 | IT.03.30790 | A2 | 6784Obj0000155369 | Objekt | 400.000/315.000/120.000/0.000/-120.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 400 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.38; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
711042x3152x2x0115x2xx4x01x1x90 | Půdorys 1.NP | Kus | 0.1 | 711042x3152x2x0115x2xx4x01x1x90 | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/100.0000/100.0000/2/100.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/160.00/0/0/100.00/160.00/0/100.00/30.00/30.00/30.00/30.00/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 160 | 160 | 100 | 0.000 | 0 | 1.0 | IT.03.30791 | A2 | 6784Obj0000155372 | Objekt | 100.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 100 | __ISO | 0.04 | 0,041 W/m.K
302041x16x01x16x1x303030303xx | Půdorys 1.NP | Kus | 0.19 | 302041x16x01x16x1x303030303xx | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/190.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/95.0000/125.0000/0/90.0/0/0/100.0000/100.0000/100.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/100.00/0/0/190.00/0/125.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30792 | A2 | 6784Obj0000155376 | Objekt | 190.000/125.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 190 | __ISO | 0.04 | 0,041 W/m.K
752041601601x019x12509xxxx | Půdorys 1.NP | Kus | 0.19 | 752041601601x019x12509xxxx | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/190.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/95.0000/125.0000/0/90.0/0/0/100.0000/100.0000/100.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/100.00/0/0/190.00/0/125.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30793 | A2 | 6784Obj0000155380 | Objekt | 190.000/125.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 190 | __ISO | 0.04 | 0,041 W/m.K
752041601601x019x12509xxxx | Půdorys 1.NP | Kus | 0 | 752041601601x019x12509xxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/0/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | IT.03.30794 | A2 | 6784Obj0000155383 | Objekt | 150.000/100.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1x01x19xxxxxx | Půdorys 1.NP | Kus | 0.05 | 252x1x01x19xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/50.0000/100.0000/100.0000/2/50.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 0.050 m | IT.03.30795 | A2 | 6784Obj0000155386 | Objekt | 50.000/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.05 | 50 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.028 m2
152041x1x5xxxxxxx | Půdorys 1.NP | Kus | 0 | 152041x1x5xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/180.0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/180.00/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | IT.03.30796 | A2 | 6784Obj0000155389 | Objekt | 150.000/100.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
252x1x01x19xxxxxx | Půdorys 1.NP | Kus | 0.36 | 252x1x01x19xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/360.0000/100.0000/100.0000/2/360.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/360.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 0.360 m | IT.03.30797 | A2 | 6784Obj0000155392 | Objekt | 360.000/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.36 | 360 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.204 m2
152041x1x36xxxxxxx | Půdorys 1.NP | Kus | 2.09 | 152041x1x36xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/2090.0000/100.0000/100.0000/2/2090.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/2090.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 2.090 m | IT.03.30798 | A2 | 6784Obj0000155395 | Objekt | 2090.000/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 2.09 | 2090 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 1.182 m2
152041x1x209xxxxxxx | Půdorys 1.NP | Kus | 0.05 | 152041x1x209xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/50.0000/100.0000/100.0000/2/50.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 0.050 m | IT.03.30799 | A2 | 6784Obj0000155398 | Objekt | 50.000/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.05 | 50 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.028 m2
152041x1x5xxxxxxx | Půdorys 1.NP | Kus | 0 | 152041x1x5xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/180.0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/180.00/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | IT.03.30800 | A2 | 6784Obj0000155401 | Objekt | 150.000/100.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
252x1x01x19xxxxxx | Půdorys 1.NP | Kus | 0.36 | 252x1x01x19xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/360.0000/100.0000/100.0000/2/360.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/360.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 0.360 m | IT.03.30801 | A2 | 6784Obj0000155404 | Objekt | 360.000/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.36 | 360 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.204 m2
152041x1x36xxxxxxx | Půdorys 1.NP | Kus | 0.03 | 152041x1x36xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/200.0000/200.0000/2/30.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.030 m | IT.03.30802 | A2 | 6784Obj0000155407 | Objekt | 30.000/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.026 m2
152042x2x3xxxxxxx | Půdorys 1.NP | Kus | 0 | 152042x2x3xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/200.0000/200.0000/200.0000/2/141.4214/58.5786/0/45.0/0/270.0/200.0000/200.0000/200.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/270.00/0/200.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | IT.03.30803 | A2 | 6784Obj0000155410 | Objekt | 212.132/129.289/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x2x02x145xxxxx0 | Půdorys 1.NP | Kus | 0.322 | 252x2x02x145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/322.2183/200.0000/200.0000/2/322.2183/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/322.22/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.322 m | IT.03.30804 | A2 | 6784Obj0000155413 | Objekt | 322.218/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.322 | 322 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.283 m2
152052x2x322xxxxxx0 | Půdorys 1.NP | Kus | 0 | 152052x2x322xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/200.0000/200.0000/200.0000/2/141.4214/58.5786/0/45.0/0/90.0/200.0000/200.0000/200.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/90.00/0/200.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | IT.03.30805 | A2 | 6784Obj0000155416 | Objekt | 212.132/129.289/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x2x02x145xxxxx0 | Půdorys 1.NP | Kus | 0 | 252x2x02x145xxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/117.0/200.0000/200.0000/200.0000/2/141.4214/58.5786/0/45.0/0/117.0/200.0000/200.0000/200.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/117.00/0/200.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | IT.03.30806 | A2 | 6784Obj0000155419 | Objekt | 212.132/129.289/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x2x02x145xxxxx0 | Půdorys 1.NP | Kus | 0.381 | 252x2x02x145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/381.1573/200.0000/200.0000/2/381.1573/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/381.16/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.381 m | IT.03.30807 | A2 | 6784Obj0000155422 | Objekt | 381.157/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.381 | 381 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.335 m2
152042x2x381xxxxxx0 | Půdorys 1.NP | Kus | 0 | 152042x2x381xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/305.8/200.0000/200.0000/200.0000/2/141.4214/58.5786/0/45.0/0/305.8/200.0000/200.0000/200.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/305.80/0/200.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | IT.03.30808 | A2 | 6784Obj0000155425 | Objekt | 212.132/129.289/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x2x02x145xxxxx0 | Půdorys 1.NP | Kus | 0 | 252x2x02x145xxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/200.0000/200.0000/200.0000/2/100.0000/26.7949/0/30.0/0/0/200.0000/200.0000/200.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/0/0/200.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | IT.03.30809 | A2 | 6784Obj0000155428 | Objekt | 150.000/113.397/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x2x02x13xxxxxx | Půdorys 1.NP | Kus | 0.319 | 252x2x02x13xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/318.9317/200.0000/200.0000/2/318.9317/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/318.93/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.319 m | IT.03.30810 | A2 | 6784Obj0000155431 | Objekt | 318.932/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.319 | 319 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.281 m2
152062x2x319xxxxxx0 | Půdorys 1.NP | Kus | 0 | 152062x2x319xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/200.0000/200.0000/200.0000/2/100.0000/26.7949/0/30.0/0/180.0/200.0000/200.0000/200.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/180.00/0/200.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | IT.03.30811 | A2 | 6784Obj0000155434 | Objekt | 150.000/113.397/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x2x02x13xxxxxx | Půdorys 1.NP | Kus | 0.422 | 252x2x02x13xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/422.0000/100.0000/100.0000/2/422.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/422.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 0.422 m | IT.03.30812 | A2 | 6784Obj0000155437 | Objekt | 422.000/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.422 | 422 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.239 m2
