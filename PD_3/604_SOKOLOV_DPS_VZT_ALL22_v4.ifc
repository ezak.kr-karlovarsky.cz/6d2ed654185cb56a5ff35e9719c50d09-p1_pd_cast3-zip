Properties of the parts of a building model (IFC2X3), part 30 of 51

# IfcFlowFitting (2887)
Name | In | Jednotka | Délka (m) | Označení | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_DIM | L_BES_DIM_A2 | L_BES_DIM_B2 | L_BES_DIM_A | K_VOLSTROM | K_MLH_GOST = K_MLD_GOST | K_LISTVALUE | Kód prvku | Třída reakce na oheň | Allright_Stavebni_dil_ID | Název_objektu | K_EBT_BOX_WC | Plocha | L_BES_LAENGE | K_INTERNAL_ISO | Tloušťka (m) | Součinitel tepelné vodivost
50105160160351x2x16016017x0-20-2 | Půdorys 1.NP | Kus | 0 | 50105160160351x2x16016017x0-20-2 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/330.0/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/330.0/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/330.00/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30412 | A2 | 6784Obj0000149382 | Objekt | 240.000/160.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16019xxxxxx | Půdorys 1.NP | Kus | 0 | 252x16x16019xxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30413 | A2 | 6784Obj0000149385 | Objekt | 120.000/90.718/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16013xxxxxx | Půdorys 1.NP | Kus | 0.063 | 252x16x16013xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/62.6321/160.0000/160.0000/2/62.6321/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/62.63/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.063 m | IT.03.30414 | A2 | 6784Obj0000149388 | Objekt | 62.632/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.063 | 63 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.047 m2
1520516016063xxxxxx0 | Půdorys 1.NP | Kus | 0.325 | 1520516016063xxxxxx0 | T-STCK. GERADE | 20 | 1016 | 3/0/0/0/180.0/0/0/200.0000/200.0000/200.0000/1/325.0000/0/0/0/0/0/160.0000/200.0000/200.0000/1/162.5000/200.0000/0/90.0/0/0/125.0000/125.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/125.00/125.00/0/0/0/0/200.00/0/0/0/325.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x200 | 200 | 200 | 200 | 0.000 | 0 | 1.000 m2 | IT.03.30415 | A2 | 6784Obj0000149436 | Objekt | 325.000/200.000/120.000/0.000/-120.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 325 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.40; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
701042x2x125125xx2xx32501x1x90 | Půdorys 1.NP | Kus | 0.2 | 701042x2x125125xx2xx32501x1x90 | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/200.0000/1/200.0000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/35.00/100.00/200.00/125.00/125.00/200.00/0/0/-37.50/-37.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 125x200 | 125 | 125 | 125 | 0.000 | 0 | 1.000 m2 | IT.03.30416 | A2 | 6784Obj0000149458 | Objekt | 200.000/62.500/100.000/0.000/-62.500/-100.000/0.000/0.000/0.000/1.000 | 1 | 200 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.23; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
50105125125351x2x1251252xx-38-38 | Půdorys 1.NP | Kus | 0.325 | 50105125125351x2x1251252xx-38-38 | T-STCK. GERADE | 20 | 1016 | 3/0/0/0/180.0/0/0/200.0000/200.0000/200.0000/1/325.0000/25.0000/0/0/0/0/1.0000/250.0000/200.0000/1/162.5000/250.0000/0/90.0/0/0/125.0000/125.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/250.00/125.00/125.00/0/50.00/0/0/200.00/0/0/0/325.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x200 | 250 | 200 | 200 | 0.000 | 0 | 1.000 m2 | IT.03.30417 | A2 | 6784Obj0000149508 | Objekt | 325.000/250.000/120.000/0.000/-120.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 325 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
711042x25012512505x02xx32501x1x9 | Půdorys 1.NP | Kus | 0.2 | 711042x25012512505x02xx32501x1x9 | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/200.0000/1/200.0000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/35.00/100.00/200.00/125.00/125.00/200.00/0/0/-37.50/-37.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 125x200 | 125 | 125 | 125 | 0.000 | 0 | 1.000 m2 | IT.03.30418 | A2 | 6784Obj0000149530 | Objekt | 200.000/62.500/100.000/0.000/-62.500/-100.000/0.000/0.000/0.000/1.000 | 1 | 200 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.23; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
50105125125351x2x1251252xx-38-38 | Půdorys 1.NP | Kus | 1.5 | 50105125125351x2x1251252xx-38-38 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/200.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x200 | 200 | 200 | 200 | 0.000 | 0 | 1.200 m2 | IT.03.30419 | A2 | 6784Obj0000149544 | Objekt | 1500.000/120.000/120.000/0.000/-120.000/-120.000/0.000/0.000/0.000/1.000 | 1.2 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.19; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.680 m2
101042x2x15xxxxxxx0 | Půdorys 1.NP | Kus | 1.5 | 101042x2x15xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/200.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x200 | 200 | 200 | 200 | 0.000 | 0 | 1.200 m2 | IT.03.30420 | A2 | 6784Obj0000149558 | Objekt | 1500.000/120.000/120.000/0.000/-120.000/-120.000/0.000/0.000/0.000/1.000 | 1.2 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.55; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.680 m2
101052x2x15xxxxxxx0 | Půdorys 1.NP | Kus | 0.17 | 101052x2x15xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/1/170.0000/0/0/0/0/0/1.0000/200.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/170.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x200 | 200 | 200 | 200 | 0.000 | 0 | 1.000 m2 | IT.03.30421 | A2 | 6784Obj0000149572 | Objekt | 170.000/120.000/120.000/0.000/-120.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 170 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.56; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
101052x2x17xxxxxxx | Půdorys 1.NP | Kus | 1.5 | 101052x2x17xxxxxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/250.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/250.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x200 | 250 | 200 | 250 | 0.000 | 0 | 1.350 m2 | IT.03.30422 | A2 | 6784Obj0000149586 | Objekt | 1500.000/145.000/120.000/0.000/-145.000/-120.000/0.000/0.000/0.000/1.000 | 1.35 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.16; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.830 m2
101042502x15xxxxxxx0 | Půdorys 1.NP | Kus | 0.325 | 101042502x15xxxxxxx0 | T-STCK. GERADE | 20 | 1016 | 3/0/0/0/180.0/0/0/250.0000/250.0000/200.0000/1/325.0000/0/0/0/0/0/160.0000/250.0000/200.0000/1/162.5000/225.0000/0/90.0/0/0/125.0000/125.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/125.00/125.00/0/0/0/0/200.00/0/0/0/325.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x200 | 250 | 200 | 250 | 0.000 | 0 | 1.000 m2 | IT.03.30423 | A2 | 6784Obj0000149634 | Objekt | 325.000/225.000/120.000/0.000/-145.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 325 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.48; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
70104250250125125xx2xx32501x1x90 | Půdorys 1.NP | Kus | 0.2 | 70104250250125125xx2xx32501x1x90 | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/200.0000/1/200.0000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/35.00/100.00/200.00/125.00/125.00/200.00/0/0/-37.50/-37.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 125x200 | 125 | 125 | 125 | 0.000 | 0 | 1.000 m2 | IT.03.30424 | A2 | 6784Obj0000149656 | Objekt | 200.000/62.500/100.000/0.000/-62.500/-100.000/0.000/0.000/0.000/1.000 | 1 | 200 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.23; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
50105125125351x2x1251252xx-38-38 | Půdorys 1.NP | Kus | 0.182 | 50105125125351x2x1251252xx-38-38 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/250.0000/200.0000/1/182.0000/0/0/0/0/0/1.0000/250.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/200.00/182.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x200 | 250 | 200 | 250 | 0.000 | 0 | 1.000 m2 | IT.03.30425 | A2 | 6784Obj0000149670 | Objekt | 182.000/145.000/120.000/0.000/-145.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 182 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.58; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
101052502x182xxxxxx0 | Půdorys 1.NP | Kus | 0.325 | 101052502x182xxxxxx0 | T-STCK. GERADE | 20 | 1016 | 3/0/0/0/180.0/0/0/250.0000/250.0000/200.0000/1/325.0000/15.0000/0/0/0/0/160.0000/280.0000/200.0000/1/162.5000/255.0000/0/90.0/0/0/125.0000/125.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/280.00/125.00/125.00/0/30.00/0/0/200.00/0/0/0/325.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x200 | 280 | 200 | 250 | 0.000 | 0 | 1.000 m2 | IT.03.30426 | A2 | 6784Obj0000149720 | Objekt | 325.000/255.000/120.000/0.000/-145.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 325 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.52; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
7110425028012512503x02xx32501x1x | Půdorys 1.NP | Kus | 0.325 | 7110425028012512503x02xx32501x1x | T-STCK. GERADE | 20 | 1016 | 3/0/0/0/180.0/0/0/280.0000/280.0000/200.0000/1/325.0000/0/0/0/0/0/160.0000/280.0000/200.0000/1/162.5000/240.0000/0/90.0/0/0/125.0000/125.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/280.00/125.00/125.00/0/0/0/0/200.00/0/0/0/325.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 280x200 | 280 | 200 | 280 | 0.000 | 0 | 1.000 m2 | IT.03.30427 | A2 | 6784Obj0000149768 | Objekt | 325.000/240.000/120.000/0.000/-160.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 325 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.56; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
70104280280125125xx2xx32501x1x90 | Půdorys 1.NP | Kus | 1.5 | 70104280280125125xx2xx32501x1x90 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/250.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/250.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x200 | 250 | 200 | 250 | 0.000 | 0 | 1.350 m2 | IT.03.30428 | A2 | 6784Obj0000149782 | Objekt | 1500.000/145.000/120.000/0.000/-145.000/-120.000/0.000/0.000/0.000/1.000 | 1.35 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.63; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.830 m2
101052502x15xxxxxxx0 | Půdorys 1.NP | Kus | 0.162 | 101052502x15xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/250.0000/200.0000/1/162.0000/0/0/0/0/0/1.0000/250.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/200.00/162.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x200 | 250 | 200 | 250 | 0.000 | 0 | 1.000 m2 | IT.03.30429 | A2 | 6784Obj0000149796 | Objekt | 162.000/145.000/120.000/0.000/-145.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 162 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.64; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
101052502x162xxxxxx0 | Půdorys 1.NP | Kus | 1.5 | 101052502x162xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/280.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/280.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 280x200 | 280 | 200 | 280 | 0.000 | 0 | 1.440 m2 | IT.03.30430 | A2 | 6784Obj0000149810 | Objekt | 1500.000/160.000/120.000/0.000/-160.000/-120.000/0.000/0.000/0.000/1.000 | 1.44 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.65; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.920 m2
101052802x15xxxxxxx0 | Půdorys 1.NP | Kus | 0.181 | 101052802x15xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/280.0000/200.0000/1/181.0000/0/0/0/0/0/1.0000/280.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/200.00/181.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 280x200 | 280 | 200 | 280 | 0.000 | 0 | 1.000 m2 | IT.03.30431 | A2 | 6784Obj0000149824 | Objekt | 181.000/160.000/120.000/0.000/-160.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 181 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.67; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
101052802x181xxxxxx0 | Půdorys 1.NP | Kus | 1.5 | 101052802x181xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/280.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/280.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 280x200 | 280 | 200 | 280 | 0.000 | 0 | 1.440 m2 | IT.03.30432 | A2 | 6784Obj0000149838 | Objekt | 1500.000/160.000/120.000/0.000/-160.000/-120.000/0.000/0.000/0.000/1.000 | 1.44 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.68; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.920 m2
101052802x15xxxxxxx0 | Půdorys 1.NP | Kus | 0.2 | 101052802x15xxxxxxx0 | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/200.0000/1/200.0000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/35.00/100.00/200.00/125.00/125.00/200.00/0/0/-37.50/-37.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 125x200 | 125 | 125 | 125 | 0.000 | 0 | 1.000 m2 | IT.03.30433 | A2 | 6784Obj0000149860 | Objekt | 200.000/62.500/100.000/0.000/-62.500/-100.000/0.000/0.000/0.000/1.000 | 1 | 200 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.23; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
50105125125351x2x1251252xx-38-38 | Půdorys 1.NP | Kus | 0.2 | 50105125125351x2x1251252xx-38-38 | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/200.0000/1/200.0000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/35.00/100.00/200.00/125.00/125.00/200.00/0/0/-37.50/-37.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 125x200 | 125 | 125 | 125 | 0.000 | 0 | 1.000 m2 | IT.03.30434 | A2 | 6784Obj0000149882 | Objekt | 200.000/62.500/100.000/0.000/-62.500/-100.000/0.000/0.000/0.000/1.000 | 1 | 200 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.23; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
50105125125351x2x1251252xx-38-38 | Půdorys 1.NP | Kus | 0.03 | 50105125125351x2x1251252xx-38-38 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/160.0000/160.0000/2/30.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.030 m | IT.03.30435 | A2 | 6784Obj0000149885 | Objekt | 30.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.023 m2
152041601603xxxxxxx | Půdorys 1.NP | Kus | 0 | 152041601603xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/224.9/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/224.9/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/224.90/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30436 | A2 | 6784Obj0000149888 | Objekt | 240.000/160.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16019xxxxxx | Půdorys 1.NP | Kus | 0.22 | 252x16x16019xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/219.9826/160.0000/160.0000/2/219.9826/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/219.98/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.220 m | IT.03.30437 | A2 | 6784Obj0000149891 | Objekt | 219.983/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.22 | 220 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.166 m2
1520516016022xxxxxxx | Půdorys 1.NP | Kus | 0 | 1520516016022xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30438 | A2 | 6784Obj0000149894 | Objekt | 169.706/103.431/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x160145xxxxx0 | Půdorys 1.NP | Kus | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.03.30439 | A2 | 6784Obj0000149897 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125145xxxxx0 | Půdorys 1.NP | Kus | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.03.30440 | A2 | 6784Obj0000149900 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125145xxxxx0 | Půdorys 1.NP | Kus | 0.03 | 252x1250125145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.030 m | IT.03.30441 | A2 | 6784Obj0000149903 | Objekt | 30.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.019 m2
152041251253xxxxxxx | Půdorys 1.NP | Kus | 0.021 | 152041251253xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/21.4000/125.0000/125.0000/2/21.4000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/21.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.021 m | IT.03.30442 | A2 | 6784Obj0000149906 | Objekt | 21.400/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.021 | 21 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.014 m2
1520512512521xxxxxx0 | Půdorys 1.NP | Kus | 0 | 1520512512521xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.03.30443 | A2 | 6784Obj0000149909 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125145xxxxx0 | Půdorys 1.NP | Kus | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.03.30444 | A2 | 6784Obj0000149912 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125145xxxxx0 | Půdorys 1.NP | Kus | 0.03 | 252x1250125145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.030 m | IT.03.30445 | A2 | 6784Obj0000149915 | Objekt | 30.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.019 m2
152041251253xxxxxxx | Půdorys 1.NP | Kus | 0.2 | 152041251253xxxxxxx | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/200.0000/1/200.0000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/35.00/100.00/200.00/125.00/125.00/200.00/0/0/-37.50/-37.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 125x200 | 125 | 125 | 125 | 0.000 | 0 | 1.000 m2 | IT.03.30446 | A2 | 6784Obj0000149937 | Objekt | 200.000/62.500/100.000/0.000/-62.500/-100.000/0.000/0.000/0.000/1.000 | 1 | 200 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.23; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
50105125125351x2x1251252xx-38-38 | Půdorys 1.NP | Kus | 0.301 | 50105125125351x2x1251252xx-38-38 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/300.5451/125.0000/125.0000/2/300.5451/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/300.55/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.301 m | IT.03.30447 | A2 | 6784Obj0000149940 | Objekt | 300.545/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.301 | 301 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.194 m2
15205125125301xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15205125125301xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.03.30448 | A2 | 6784Obj0000149943 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125145xxxxx0 | Půdorys 1.NP | Kus | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.03.30449 | A2 | 6784Obj0000149946 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125145xxxxx0 | Půdorys 1.NP | Kus | 0.03 | 252x1250125145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.030 m | IT.03.30450 | A2 | 6784Obj0000149949 | Objekt | 30.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.019 m2
152041251253xxxxxxx | Půdorys 1.NP | Kus | 0 | 152041251253xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.03.30451 | A2 | 6784Obj0000149952 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125145xxxxx0 | Půdorys 1.NP | Kus | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.03.30452 | A2 | 6784Obj0000149955 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125145xxxxx0 | Půdorys 1.NP | Kus | 0.03 | 252x1250125145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.030 m | IT.03.30453 | A2 | 6784Obj0000149958 | Objekt | 30.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.019 m2
152041251253xxxxxxx | Půdorys 1.NP | Kus | 0 | 152041251253xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.03.30454 | A2 | 6784Obj0000149961 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125145xxxxx0 | Půdorys 1.NP | Kus | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.03.30455 | A2 | 6784Obj0000149964 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125145xxxxx0 | Půdorys 1.NP | Kus | 0.03 | 252x1250125145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.030 m | IT.03.30456 | A2 | 6784Obj0000149967 | Objekt | 30.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.019 m2
152041251253xxxxxxx | Půdorys 1.NP | Kus | 0.069 | 152041251253xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/69.4000/125.0000/125.0000/2/69.4000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/69.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.069 m | IT.03.30457 | A2 | 6784Obj0000149970 | Objekt | 69.400/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.069 | 69 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.045 m2
1520512512569xxxxxx0 | Půdorys 1.NP | Kus | 0.057 | 1520512512569xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/57.4000/125.0000/125.0000/2/57.4000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/57.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.057 m | IT.03.30458 | A2 | 6784Obj0000149973 | Objekt | 57.400/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.057 | 57 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.037 m2
1520512512557xxxxxx0 | Půdorys 1.NP | Kus | 0.02 | 1520512512557xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/20.4000/125.0000/125.0000/2/20.4000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/20.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.020 m | IT.03.30459 | A2 | 6784Obj0000149976 | Objekt | 20.400/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.02 | 20 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.013 m2
152051251252xxxxxxx | Půdorys 1.NP | Kus | 0.027 | 152051251252xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/27.4000/125.0000/125.0000/2/27.4000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/27.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.027 m | IT.03.30460 | A2 | 6784Obj0000149979 | Objekt | 27.400/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.027 | 27 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.018 m2
1520512512527xxxxxx0 | Půdorys 1.NP | Kus | 0.03 | 1520512512527xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/200.0000/200.0000/2/30.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.030 m | IT.03.30461 | A2 | 6784Obj0000149982 | Objekt | 30.000/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.026 m2
152042x2x3xxxxxxx | Půdorys 1.NP | Kus | 0.126 | 152042x2x3xxxxxxx | UEBERGANG SYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/250.0000/250.0000/200.0000/1/126.0000/0/-0/0/0/0/0/280.0000/200.0000/1/ | 40/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/280.00/50.00/50.00/200.00/200.00/0/126.00/15.00/15.00/0/0/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x200 | 280 | 200 | 250 | 0.000 | 0 | 1.000 m2 | IT.03.30462 | A2 | 6784Obj0000150004 | Objekt | 126.000/160.000/120.000/0.000/-160.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 126 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.18; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
4010425028050502x2x01261515x3xx | Půdorys 1.NP | Kus | 0.325 | 4010425028050502x2x01261515x3xx | T-STCK. GERADE | 20 | 1016 | 3/0/0/0/180.0/0/270.0/280.0000/280.0000/200.0000/1/325.0000/0/0/0/0/90.0/1.0000/280.0000/200.0000/1/162.5000/200.0000/0/90.0/0/270.0/280.0000/280.0000/125.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/125.00/125.00/0/0/0/0/280.00/0/0/270.00/325.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 280x200 | 280 | 200 | 280 | 0.000 | 0 | 1.000 m2 | IT.03.30463 | A2 | 6784Obj0000150052 | Objekt | 325.000/200.000/160.000/0.000/-120.000/-160.000/0.000/0.000/0.000/1.000 | 1 | 325 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.19; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
701042x2x125125xx28x032501x1x90 | Půdorys 1.NP | Kus | 0 | 701042x2x125125xx28x032501x1x90 | BOGEN ASY. | 20 | 1016 | 2/0/0/0/180.0/0/0/280.0000/280.0000/125.0000/1/112.5000/190.0000/0/90.0/0/270.0/1.0000/125.0000/125.0000/1/ | 21/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/125.00/0/50.00/50.00/125.00/0/90.00/0/0/125.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 280x125 | 125 | 125 | 280 | 0.000 | 0 | 1.000 m2 | IT.03.30464 | A2 | 6784Obj0000150102 | Objekt | 195.000/190.000/82.500/0.000/-160.000/-82.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 125; K_LISTVALUE_ISO: 1.000 m2
2110428012505050125090125xxx0 | Půdorys 1.NP | Kus | 0.136 | 2110428012505050125090125xxx0 | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/125.0000/126.0000/1/135.9000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/35.00/100.00/126.00/125.00/125.00/135.90/0/0/-0.50/-0.50/29.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 125x126 | 125 | 125 | 125 | 0.000 | 0 | 1.000 m2 | IT.03.30465 | A2 | 6784Obj0000150124 | Objekt | 135.900/62.500/63.000/0.000/-62.500/-63.000/0.000/0.000/0.000/1.000 | 1 | 136 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.21; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 126; K_LISTVALUE_ISO: 1.000 m2
50105125125351x126125125136x-1-1 | Půdorys 1.NP | Kus | 1.29 | 50105125125351x126125125136x-1-1 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/280.0000/200.0000/1/1290.2000/0/0/0/0/0/1.0000/280.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/200.00/1290.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 280x200 | 280 | 200 | 280 | 0.000 | 0 | 1.240 m2 | IT.03.30466 | A2 | 6784Obj0000150138 | Objekt | 1290.200/160.000/120.000/0.000/-160.000/-120.000/0.000/0.000/0.000/1.000 | 1.24 | 1290 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.47; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.650 m2
101052802x129xxxxxxx | Půdorys 1.NP | Kus | 0.136 | 101052802x129xxxxxxx | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/200.0000/200.0000/201.0000/1/135.9000/0/0/0/0/0/0/200.0000/200.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/35.00/100.00/201.00/200.00/200.00/135.90/0/0/-0.50/-0.50/29.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x201 | 200 | 200 | 200 | 0.000 | 0 | 1.000 m2 | IT.03.30467 | A2 | 6784Obj0000150160 | Objekt | 135.900/100.000/100.500/0.000/-100.000/-100.500/0.000/0.000/0.000/1.000 | 1 | 136 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.6; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 201; K_LISTVALUE_ISO: 1.000 m2
501052x2x351x2012x2x136x-1-129x0 | Půdorys 1.NP | Kus | 0.4 | 501052x2x351x2012x2x136x-1-129x0 | T-STCK. GERADE | 20 | 1016 | 3/0/0/0/180.0/0/180.0/200.0000/200.0000/200.0000/1/400.0000/25.0000/0/0/0/180.0/200.0000/250.0000/200.0000/1/200.0000/250.0000/0/90.0/0/180.0/200.0000/200.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/250.00/200.00/200.00/0/50.00/0/0/200.00/0/0/180.00/400.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x200 | 250 | 200 | 200 | 0.000 | 0 | 1.000 m2 | IT.03.30468 | A2 | 6784Obj0000150210 | Objekt | 400.000/250.000/120.000/0.000/-120.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 400 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.13; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
711042x2502x2x05x02xx4x01x1x90 | Půdorys 1.NP | Kus | 0.03 | 711042x2502x2x05x02xx4x01x1x90 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/200.0000/200.0000/2/30.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.030 m | IT.03.30469 | A2 | 6784Obj0000150213 | Objekt | 30.000/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.026 m2
152042x2x3xxxxxxx | Půdorys 1.NP | Kus | 0.136 | 152042x2x3xxxxxxx | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/200.0000/200.0000/200.0000/2/135.9000/0/0/0/0/0/0/200.0000/201.0000/1/ | 50/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/200.00/200.00/35.00/100.00/200.00/201.00/200.00/135.90/0/0/0.50/0.50/29.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 201 | 200 | 0.000 | 0 | 1.000 m2 | IT.03.30470 | A2 | 6784Obj0000150235 | Objekt | 135.900/100.000/100.500/0.000/-100.000/-100.500/0.000/0.000/0.000/1.000 | 1 | 136 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.24; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); K_LISTVALUE_ISO: 1.000 m2
502162x2x351x2x2012x136x1129x0 | Půdorys 1.NP | Kus | 0.136 | 502162x2x351x2x2012x136x1129x0 | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/200.0000/200.0000/201.0000/1/135.9000/0/0/0/0/0/0/200.0000/200.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/35.00/100.00/201.00/200.00/200.00/135.90/0/0/-0.50/-0.50/29.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x201 | 200 | 200 | 200 | 0.000 | 0 | 1.000 m2 | IT.03.30471 | A2 | 6784Obj0000150257 | Objekt | 135.900/100.000/100.500/0.000/-100.000/-100.500/0.000/0.000/0.000/1.000 | 1 | 136 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.27; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 201; K_LISTVALUE_ISO: 1.000 m2
501052x2x351x2012x2x136x-1-129x0 | Půdorys 1.NP | Kus | 0.4 | 501052x2x351x2012x2x136x-1-129x0 | T-STCK. GERADE | 20 | 1016 | 3/0/0/0/180.0/0/180.0/200.0000/200.0000/200.0000/1/400.0000/0/0/0/0/180.0/200.0000/200.0000/200.0000/1/200.0000/200.0000/0/90.0/0/180.0/200.0000/200.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/200.00/200.00/0/0/0/0/200.00/0/0/180.00/400.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x200 | 200 | 200 | 200 | 0.000 | 0 | 1.000 m2 | IT.03.30472 | A2 | 6784Obj0000150305 | Objekt | 400.000/200.000/120.000/0.000/-120.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 400 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.10; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
701042x2x2x2xxx2xx4x01x1x90 | Půdorys 1.NP | Kus | 0.03 | 701042x2x2x2xxx2xx4x01x1x90 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/200.0000/200.0000/2/30.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.030 m | IT.03.30473 | A2 | 6784Obj0000150308 | Objekt | 30.000/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.026 m2
152042x2x3xxxxxxx | Půdorys 1.NP | Kus | 0 | 152042x2x3xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/225.0/200.0000/200.0000/200.0000/2/200.0000/200.0000/0/90.0/0/225.0/200.0000/200.0000/200.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/225.00/0/200.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | IT.03.30474 | A2 | 6784Obj0000150311 | Objekt | 300.000/200.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x2x02x19xxxxxx | Půdorys 1.NP | Kus | 0.134 | 252x2x02x19xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/134.3503/200.0000/200.0000/2/134.3503/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/134.35/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.134 m | IT.03.30475 | A2 | 6784Obj0000150314 | Objekt | 134.350/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.134 | 134 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.118 m2
152052x2x134xxxxxx0 | Půdorys 1.NP | Kus | 0 | 152052x2x134xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/200.0000/200.0000/200.0000/2/141.4214/58.5786/0/45.0/0/90.0/200.0000/200.0000/200.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/90.00/0/200.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | IT.03.30476 | A2 | 6784Obj0000150317 | Objekt | 212.132/129.289/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x2x02x145xxxxx0 | Půdorys 1.NP | Kus | 0.832 | 252x2x02x145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/832.1573/200.0000/200.0000/2/832.1573/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/832.16/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.832 m | IT.03.30477 | A2 | 6784Obj0000150320 | Objekt | 832.157/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.832 | 832 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.732 m2
152052x2x832xxxxxx0 | Půdorys 1.NP | Kus | 0 | 152052x2x832xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/180.0/250.0000/250.0000/200.0000/1/275.0000/275.0000/0/90.0/0/180.0/200.0000/250.0000/200.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/0/50.00/50.00/200.00/100.00/90.00/180.00/0/200.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x200 | 250 | 200 | 250 | 0.000 | 0 | 1.000 m2 | IT.03.30478 | A2 | 6784Obj0000150402 | Objekt | 420.000/275.000/120.000/0.000/-145.000/-120.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.15; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
2010425025x50502x1x902xxxx0 | Půdorys 1.NP | Kus | 0.556 | 2010425025x50502x1x902xxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/250.0000/200.0000/1/555.5000/0/0/0/0/0/1.0000/250.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/200.00/555.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x200 | 250 | 200 | 250 | 0.000 | 0 | 1.000 m2 | IT.03.30479 | A2 | 6784Obj0000150416 | Objekt | 555.500/145.000/120.000/0.000/-145.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 556 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.52; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
101052502x556xxxxxx0 | Půdorys 1.NP | Kus | 0.474 | 101052502x556xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/250.0000/200.0000/1/474.4000/0/0/0/0/0/1.0000/250.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/200.00/474.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x200 | 250 | 200 | 250 | 0.000 | 0 | 1.000 m2 | IT.03.30480 | A2 | 6784Obj0000150430 | Objekt | 474.400/145.000/120.000/0.000/-145.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 474 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.53; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
101052502x474xxxxxx0 | Půdorys 1.NP | Kus | 0.509 | 101052502x474xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/1/508.5000/0/0/0/0/0/1.0000/200.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/508.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x200 | 200 | 200 | 200 | 0.000 | 0 | 1.000 m2 | IT.03.30481 | A2 | 6784Obj0000150444 | Objekt | 508.500/120.000/120.000/0.000/-120.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 509 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.55; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
101052x2x509xxxxxx0 | Půdorys 1.NP | Kus | 0.48 | 101052x2x509xxxxxx0 | T-STCK. GERADE | 20 | 1016 | 3/0/0/0/180.0/0/0/250.0000/250.0000/200.0000/1/480.0000/-62.5000/0/0/0/0/1.0000/125.0000/200.0000/1/240.0000/225.0000/0/90.0/0/0/280.0000/280.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/125.00/280.00/280.00/0/0/125.00/0/200.00/0/0/0/480.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x200 | 125 | 200 | 250 | 0.000 | 0 | 1.000 m2 | IT.03.30482 | A2 | 6784Obj0000150494 | Objekt | 480.000/225.000/120.000/0.000/-145.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 480 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
7010425012528028x012502xx48x1x1x | Půdorys 1.NP | Kus | 0.2 | 7010425012528028x012502xx48x1x1x | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/200.0000/1/200.0000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/35.00/100.00/200.00/125.00/125.00/200.00/0/0/-37.50/-37.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 125x200 | 125 | 125 | 125 | 0.000 | 0 | 1.000 m2 | IT.03.30483 | A2 | 6784Obj0000150516 | Objekt | 200.000/62.500/100.000/0.000/-62.500/-100.000/0.000/0.000/0.000/1.000 | 1 | 200 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.6; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
50105125125351x2x1251252xx-38-38 | Půdorys 1.NP | Kus | 1.03 | 50105125125351x2x1251252xx-38-38 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/280.0000/200.0000/1/1029.6000/0/0/0/0/0/1.0000/280.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/200.00/1029.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 280x200 | 280 | 200 | 280 | 0.000 | 0 | 0.990 m2 | IT.03.30484 | A2 | 6784Obj0000150530 | Objekt | 1029.600/160.000/120.000/0.000/-160.000/-120.000/0.000/0.000/0.000/1.000 | 0.99 | 1030 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.62; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.320 m2
101052802x103xxxxxxx | Půdorys 1.NP | Kus | 0.117 | 101052802x103xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/117.1000/160.0000/160.0000/2/117.1000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/117.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.117 m | IT.03.30485 | A2 | 6784Obj0000150533 | Objekt | 117.100/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.117 | 117 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.088 m2
15205160160117xxxxxx0 | Půdorys 1.NP | Kus | 0.057 | 15205160160117xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/56.7000/125.0000/125.0000/2/56.7000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/56.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.057 m | IT.03.30486 | A2 | 6784Obj0000150536 | Objekt | 56.700/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.057 | 57 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.037 m2
1520512512557xxxxxx0 | Půdorys 1.NP | Kus | 0.057 | 1520512512557xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/56.7000/125.0000/125.0000/2/56.7000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/56.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.057 m | IT.03.30487 | A2 | 6784Obj0000150539 | Objekt | 56.700/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.057 | 57 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.037 m2
1520512512557xxxxxx0 | Půdorys 1.NP | Kus | 0.057 | 1520512512557xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/56.7000/125.0000/125.0000/2/56.7000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/56.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.057 m | IT.03.30488 | A2 | 6784Obj0000150542 | Objekt | 56.700/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.057 | 57 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.037 m2
1520512512557xxxxxx0 | Půdorys 1.NP | Kus | 0.057 | 1520512512557xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/56.7000/125.0000/125.0000/2/56.7000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/56.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.057 m | IT.03.30489 | A2 | 6784Obj0000150545 | Objekt | 56.700/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.057 | 57 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.037 m2
