Properties of the parts of a building model (IFC2X3), part 16 of 51

# IfcFlowFitting (2887)
Name | In | Jednotka | Délka (m) | Označení | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_DIM | L_BES_DIM_A2 | L_BES_DIM_B2 | L_BES_DIM_A | K_VOLSTROM | K_MLH_GOST = K_MLD_GOST | K_LISTVALUE | Kód prvku | Třída reakce na oheň | Allright_Stavebni_dil_ID | Název_objektu | K_EBT_BOX_WC | Plocha | L_BES_LAENGE | K_INTERNAL_ISO | Tloušťka (m) | Součinitel tepelné vodivost
101065x160551xxxxxx0 | Půdorys 1.PP | Kus | 0.157 | 101065x160551xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/500.0000/160.0000/1/157.0000/0/0/0/0/0/1.0000/500.0000/160.0000/1/ | 10/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/160.00/157.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 500x160 | 500 | 160 | 500 | 0.000 | 0 | 1.000 m2 | IT.02.30587 | A1 | 6774Obj0000047720 | Objekt | 157.000/270.000/100.000/0.000/-270.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 157 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.11; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
101065x160157xxxxxx0 | Půdorys 1.PP | Kus | 0 | 101065x160157xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/270.0/400.0000/400.0000/300.0000/1/300.0000/300.0000/0/90.0/0/270.0/1.0000/400.0000/300.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/300.00/300.00/0/50.00/50.00/400.00/100.00/90.00/270.00/0/400.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x300 | 400 | 300 | 400 | 0.000 | 0 | 1.020 m2 | IT.02.30588 | A1 | 6774Obj0000047802 | Objekt | 470.000/300.000/220.000/0.000/-170.000/-220.000/0.000/0.000/0.000/1.000 | 1.02 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 300; K_LISTVALUE_ISO: 1.360 m2
201043x3x050504x1x904xxxx0 | Půdorys 1.PP | Kus | 0.834 | 201043x3x050504x1x904xxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/300.0000/400.0000/1/834.3000/0/0/0/0/0/1.0000/300.0000/400.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/300.00/400.00/834.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 300x400 | 300 | 400 | 300 | 0.000 | 0 | 1.170 m2 | IT.02.30589 | A1 | 6774Obj0000047816 | Objekt | 834.300/170.000/220.000/0.000/-170.000/-220.000/0.000/0.000/0.000/1.000 | 1.17 | 834 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; K_LISTVALUE_ISO: 1.430 m2
macro | Půdorys 1.PP | Kus | 0.26 | macro | ABL Regler konst. EN mit Antrieb | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/0/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/160.00/160.00/260.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 |  | 160x160 | 1 | 1 | 1 | 0.000 | 0 |  | IT.02.30590 | A1 | 6774Obj0000047830 | Objekt | 26880.600/8194.111/-393.000/26720.600/7934.111/-553.000/0.000/0.000/0.000/1.000 | 0 | 260 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1; K_LISTVALUE_ISO: 0.250 m2; K_DWGNAME: ${PROD}l\einbauteile\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2022/11/04; N_FREI_68: Blech ST37 verzinkt
1x010516016026xxxxxxx | Půdorys 1.PP | Kus | 0.524 | 1x010516016026xxxxxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/524.0372/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/524.04/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30591 | A1 | 6774Obj0000047844 | Objekt | 524.037/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 524 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
10105160160524xxxxxx0 | Půdorys 1.PP | Kus | 0 | 10105160160524xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/1/212.6346/88.0761/0/45.0/0/90.0/1.0000/160.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/160.00/100.00/45.00/90.00/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30592 | A1 | 6774Obj0000047926 | Objekt | 283.345/158.787/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
2010416016x50501601x4516xxxx | Půdorys 1.PP | Kus | 0.034 | 2010416016x50501601x4516xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/33.7259/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/33.73/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30593 | A1 | 6774Obj0000047940 | Objekt | 33.726/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 34 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
1010416016034xxxxxx0 | Půdorys 1.PP | Kus | 0 | 1010416016034xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/1/212.6346/88.0761/0/45.0/0/90.0/1.0000/160.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/160.00/100.00/45.00/90.00/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30594 | A1 | 6774Obj0000048022 | Objekt | 283.345/158.787/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
2010416016x50501601x4516xxxx | Půdorys 1.PP | Kus | 0.943 | 2010416016x50501601x4516xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/942.9991/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/943.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 0.600 m2 | IT.02.30595 | A1 | 6774Obj0000048036 | Objekt | 942.999/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.6 | 943 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
10104160160943xxxxxx0 | Půdorys 1.PP | Kus | 0.46 | 10104160160943xxxxxx0 | T-STCK. GERADE | 20 | 1016 | 3/0/0/0/180.0/0/180.0/500.0000/500.0000/160.0000/1/460.0000/0/0/0/0/180.0/1.0000/500.0000/160.0000/1/230.0000/400.0000/0/90.0/0/180.0/160.0000/160.0000/160.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/500.00/160.00/160.00/50.00/50.00/50.00/50.00/160.00/0/0/180.00/460.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 500x160 | 500 | 160 | 500 | 0.000 | 0 | 1.000 m2 | IT.02.30596 | A1 | 6774Obj0000048092 | Objekt | 460.000/400.000/100.000/0.000/-270.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 460 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.30; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; K_DATANORM: ";"
701045x5x1601605050505016x046x1x | Půdorys 1.PP | Kus | 0.165 | 701045x5x1601605050505016x046x1x | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/165.3000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/35.00/100.00/160.00/125.00/125.00/165.30/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 125 | 125 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30597 | A1 | 6774Obj0000048114 | Objekt | 165.300/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 165 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.5; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
50105160125351x160125125165-18-1 | Půdorys 1.PP | Kus | 0.62 | 50105160125351x160125125165-18-1 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/500.0000/160.0000/1/620.0000/0/0/0/0/0/1.0000/500.0000/160.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/160.00/620.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 500x160 | 500 | 160 | 500 | 0.000 | 0 | 1.000 m2 | IT.02.30598 | A1 | 6774Obj0000048128 | Objekt | 620.000/270.000/100.000/0.000/-270.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 620 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.25; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.020 m2
101055x16062xxxxxxx | Půdorys 1.PP | Kus | 0 | 101055x16062xxxxxxx | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/180.0/400.0000/400.0000/300.0000/1/350.0000/350.0000/0/90.0/0/180.0/1.0000/400.0000/300.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/400.00/0/50.00/50.00/300.00/100.00/90.00/180.00/0/300.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x300 | 400 | 300 | 400 | 0.000 | 0 | 1.240 m2 | IT.02.30599 | A1 | 6774Obj0000048210 | Objekt | 570.000/350.000/170.000/0.000/-220.000/-170.000/0.000/0.000/0.000/1.000 | 1.24 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 300; K_LISTVALUE_ISO: 1.630 m2
201044x4x050503x1x903xxxx0 | Půdorys 1.PP | Kus | 0 | 201044x4x050503x1x903xxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/270.0/560.0000/560.0000/160.0000/1/230.0000/230.0000/0/90.0/0/270.0/1.0000/560.0000/160.0000/1/ | 20/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/560.00/100.00/90.00/270.00/1.00/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 560 | 160 | 560 | 0.000 | 0 | 1.210 m2 | IT.02.30600 | A1 | 6774Obj0000048292 | Objekt | 330.000/230.000/300.000/0.000/-100.000/-300.000/0.000/0.000/0.000/1.000 | 1.21 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.210 m2
2010616016x50505601x9056xxxx | Půdorys 1.PP | Kus | 0.221 | 2010616016x50505601x9056xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/400.0000/300.0000/1/221.0910/0/0/0/0/0/1.0000/400.0000/300.0000/1/ | 10/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/300.00/221.09/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x300 | 400 | 300 | 400 | 0.000 | 0 | 1.000 m2 | IT.02.30601 | A1 | 6774Obj0000048306 | Objekt | 221.091/220.000/170.000/0.000/-220.000/-170.000/0.000/0.000/0.000/1.000 | 1 | 221 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 300; K_LISTVALUE_ISO: 1.000 m2
101064x3x221xxxxxx0 | Půdorys 1.PP | Kus | 0.239 | 101064x3x221xxxxxx0 | UEBERGANG SYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/160.0000/1/238.5641/0/-0/0/0/0/0/400.0000/300.0000/1/ | 40/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/50.00/50.00/160.00/300.00/0/238.56/-80.00/-80.00/70.00/70.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 400 | 300 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30602 | A1 | 6774Obj0000048328 | Objekt | 238.564/300.000/170.000/0.000/-300.000/-170.000/0.000/0.000/0.000/1.000 | 1 | 239 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
401065604x50501603x0239-80-80707 | Půdorys 1.PP | Kus | 1.287 | 401065604x50501603x0239-80-80707 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/400.0000/300.0000/1/1287.3000/0/0/0/0/0/1.0000/400.0000/300.0000/1/ | 10/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/300.00/1287.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x300 | 400 | 300 | 400 | 0.000 | 0 | 1.800 m2 | IT.02.30603 | A1 | 6774Obj0000048342 | Objekt | 1287.300/220.000/170.000/0.000/-220.000/-170.000/0.000/0.000/0.000/1.000 | 1.8 | 1287 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.7; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 300; K_LISTVALUE_ISO: 2.210 m2
101064x3x1287xxxxxx0 | Půdorys 1.PP | Kus | 0 | 101064x3x1287xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/1/212.6346/88.0761/0/45.0/0/270.0/1.0000/160.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/160.00/100.00/45.00/270.00/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30604 | A1 | 6774Obj0000048424 | Objekt | 283.345/158.787/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
2010416016x50501601x4516xxxx | Půdorys 1.PP | Kus | 0.034 | 2010416016x50501601x4516xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/33.7259/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/33.73/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30605 | A1 | 6774Obj0000048438 | Objekt | 33.726/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 34 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
1010416016034xxxxxx0 | Půdorys 1.PP | Kus | 0 | 1010416016034xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/1/212.6346/88.0761/0/45.0/0/270.0/1.0000/160.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/160.00/100.00/45.00/270.00/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30606 | A1 | 6774Obj0000048520 | Objekt | 283.345/158.787/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
2010416016x50501601x4516xxxx | Půdorys 1.PP | Kus | 0 | 2010416016x50501601x4516xxxx | BOGEN ASY. | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/1/230.0000/230.0000/0/90.0/0/0/125.0000/160.0000/160.0000/1/ | 21/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/160.00/100.00/90.00/0/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30607 | A1 | 6774Obj0000048602 | Objekt | 330.000/230.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.22; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
2110416016x50501601x9016xxxx | Půdorys 1.PP | Kus | 0.46 | 2110416016x50501601x9016xxxx | T-STCK. SCHRÄG | 20 | 1016 | 3/0/0/0/180.0/0/0/560.0000/560.0000/160.0000/1/460.0000/30.0000/0/0/0/0/1.0000/500.0000/160.0000/1/230.0000/430.0000/0/90.0/0/0/160.0000/160.0000/160.0000/1/ | 71/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/500.00/160.00/160.00/50.00/50.00/50.00/50.00/160.00/0/0/0/460.00/60.00/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 500 | 160 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30608 | A1 | 6774Obj0000048658 | Objekt | 460.000/430.000/100.000/0.000/-300.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 460 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
711045605x1601605050505016x04606 | Půdorys 1.PP | Kus | 0.016 | 711045605x1601605050505016x04606 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/500.0000/160.0000/1/15.7700/0/0/0/0/0/1.0000/500.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/160.00/15.77/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 500x160 | 500 | 160 | 500 | 0.000 | 0 | 1.000 m2 | IT.02.30609 | A1 | 6774Obj0000048672 | Objekt | 20.000/270.000/100.000/-4.230/-270.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 16 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
101045x16016xxxxxx0 | Půdorys 1.PP | Kus | 0 | 101045x16016xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/180.0/500.0000/500.0000/160.0000/1/400.0000/400.0000/0/90.0/0/180.0/1.0000/500.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/500.00/0/50.00/50.00/160.00/100.00/90.00/180.00/1.00/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 500x160 | 500 | 160 | 500 | 0.000 | 0 | 1.380 m2 | IT.02.30610 | A1 | 6774Obj0000048754 | Objekt | 670.000/400.000/100.000/0.000/-270.000/-100.000/0.000/0.000/0.000/1.000 | 1.38 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.810 m2
201045x5x050501601x9016xxxx | Půdorys 1.PP | Kus | 0.06 | 201045x5x050501601x9016xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/500.0000/160.0000/1/60.0000/0/0/0/0/0/1.0000/500.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/160.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 500x160 | 500 | 160 | 500 | 0.000 | 0 | 1.000 m2 | IT.02.30611 | A1 | 6774Obj0000048768 | Objekt | 60.000/270.000/100.000/0.000/-270.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 60 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
101045x1606xxxxxxx | Půdorys 1.PP | Kus | 0.88 | 101045x1606xxxxxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/500.0000/160.0000/1/880.0000/0/0/0/0/0/1.0000/500.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/160.00/880.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 500x160 | 500 | 160 | 500 | 0.000 | 0 | 1.160 m2 | IT.02.30612 | A1 | 6774Obj0000048782 | Objekt | 880.000/270.000/100.000/0.000/-270.000/-100.000/0.000/0.000/0.000/1.000 | 1.16 | 880 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160
101045x16088xxxxxxx | Půdorys 1.PP | Kus | 0.562 | 101045x16088xxxxxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/561.5000/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/561.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30613 | A1 | 6774Obj0000048796 | Objekt | 561.500/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 562 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.5; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160
10104160160562xxxxxx0 | Půdorys 1.PP | Kus | 0.467 | 10104160160562xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/467.2000/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/467.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30614 | A1 | 6774Obj0000048810 | Objekt | 467.200/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 467 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.6; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160
10104160160467xxxxxx0 | Půdorys 1.PP | Kus | 0 | 10104160160467xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/1/230.8846/133.3013/0/60.0/0/90.0/1.0000/160.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/160.00/100.00/60.00/90.00/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30615 | A1 | 6774Obj0000048892 | Objekt | 317.487/183.301/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160
2010416016x50501601x6016xxxx | Půdorys 1.PP | Kus | 0 | 2010416016x50501601x6016xxxx | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/1/230.8846/133.3013/0/60.0/0/90.0/1.0000/160.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/160.00/100.00/60.00/90.00/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30616 | A1 | 6774Obj0000048974 | Objekt | 317.487/183.301/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160
2010416016x50501601x6016xxxx | Půdorys 1.PP | Kus | 0.18 | 2010416016x50501601x6016xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/180.0000/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/180.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30617 | A1 | 6774Obj0000048988 | Objekt | 180.000/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 180 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
1010416016018xxxxxxx | Půdorys 1.PP | Kus | 0 | 1010416016018xxxxxxx | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/1/183.3013/49.1154/0/30.0/0/0/1.0000/160.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/160.00/100.00/30.00/0/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30618 | A1 | 6774Obj0000049070 | Objekt | 233.301/135.718/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.10; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
2010416016x50501601x3016xxxx | Půdorys 1.PP | Kus | 0 | 2010416016x50501601x3016xxxx | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/1/183.3013/49.1154/0/30.0/0/180.0/1.0000/160.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/160.00/100.00/30.00/180.00/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30619 | A1 | 6774Obj0000049152 | Objekt | 233.301/135.718/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.12; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
2010416016x50501601x3016xxxx | Půdorys 1.PP | Kus | 0.17 | 2010416016x50501601x3016xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/169.7000/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/169.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30620 | A1 | 6774Obj0000049166 | Objekt | 169.700/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 170 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.13; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
1010416016017xxxxxxx | Půdorys 1.PP | Kus | 0.187 | 1010416016017xxxxxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/186.6154/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/186.62/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30621 | A1 | 6774Obj0000049180 | Objekt | 186.615/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 187 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.6; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160
10104160160187xxxxxx0 | Půdorys 1.PP | Kus | 0 | 10104160160187xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/1/230.8846/133.3013/0/60.0/0/90.0/1.0000/160.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/160.00/100.00/60.00/90.00/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30622 | A1 | 6774Obj0000049262 | Objekt | 317.487/183.301/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160
2010416016x50501601x6016xxxx | Půdorys 1.PP | Kus | 0 | 2010416016x50501601x6016xxxx | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/1/230.8846/133.3013/0/60.0/0/270.0/1.0000/160.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/160.00/100.00/60.00/270.00/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30623 | A1 | 6774Obj0000049344 | Objekt | 317.487/183.301/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.7; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160
2010416016x50501601x6016xxxx | Půdorys 1.PP | Kus | 0.392 | 2010416016x50501601x6016xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/392.3000/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/392.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30624 | A1 | 6774Obj0000049358 | Objekt | 392.300/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 392 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.10; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160
10104160160392xxxxxx0 | Půdorys 1.PP | Kus | 0.03 | 10104160160392xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.030 m | IT.02.30625 | A1 | 6774Obj0000049361 | Objekt | 30.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.019 m2
macro | Půdorys 1.PP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.02.30626 | A1 | 6774Obj0000049375 | Objekt | 24309.018/6543.770/-460.500/24184.018/6233.770/-585.500/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2022/11/04; N_FREI_68: SPIRO POTRUBÍ
 | Půdorys 1.PP | Kus | 0.027 |  | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/26.7000/125.0000/125.0000/2/26.7000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/26.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.027 m | IT.02.30627 | A1 | 6774Obj0000049378 | Objekt | 26.700/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.027 | 27 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.017 m2
1520412512527xxxxxx0 | Půdorys 1.PP | Kus | 0 | 1520412512527xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30628 | A1 | 6774Obj0000049381 | Objekt | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012519xxxxxx | Půdorys 1.PP | Kus | 0.091 | 252x125012519xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/91.3020/125.0000/125.0000/2/91.3020/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/91.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.091 m | IT.02.30629 | A1 | 6774Obj0000049384 | Objekt | 91.302/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.091 | 91 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.059 m2
1520512512591xxxxxx0 | Půdorys 1.PP | Kus | 0 | 1520512512591xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30630 | A1 | 6774Obj0000049387 | Objekt | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012519xxxxxx | Půdorys 1.PP | Kus | 0.1 | 252x125012519xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/100.1411/125.0000/125.0000/2/100.1411/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/100.14/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.100 m | IT.02.30631 | A1 | 6774Obj0000049390 | Objekt | 100.141/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.1 | 100 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.064 m2
152051251251xxxxxxx0 | Půdorys 1.PP | Kus | 0.139 | 152051251251xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/138.8085/125.0000/125.0000/2/138.8085/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/138.81/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.139 m | IT.02.30632 | A1 | 6774Obj0000049393 | Objekt | 138.809/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.139 | 139 | __ISO | 0.04 | 0,041 W/m.K
15204125125139xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15204125125139xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30633 | A1 | 6774Obj0000049396 | Objekt | 93.750/70.873/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012513xxxxxx | Půdorys 1.PP | Kus | 0.033 | 252x125012513xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/33.0219/125.0000/125.0000/2/33.0219/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/33.02/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.033 m | IT.02.30634 | A1 | 6774Obj0000049399 | Objekt | 33.022/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.033 | 33 | __ISO | 0.04 | 0,041 W/m.K
1520412512533xxxxxx0 | Půdorys 1.PP | Kus | 0 | 1520412512533xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30635 | A1 | 6774Obj0000049402 | Objekt | 93.750/70.873/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012513xxxxxx | Půdorys 1.PP | Kus | 0.139 | 252x125012513xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/138.8112/125.0000/125.0000/2/138.8112/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/138.81/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.139 m | IT.02.30636 | A1 | 6774Obj0000049405 | Objekt | 138.811/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.139 | 139 | __ISO | 0.04 | 0,041 W/m.K
15204125125139xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15204125125139xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/180.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/180.00/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.02.30637 | A1 | 6774Obj0000049408 | Objekt | 240.000/160.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
 | Půdorys 1.PP | Kus | 0.798 |  | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/798.1000/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/798.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.02.30638 | A1 | 6774Obj0000049780 | Objekt | 798.100/177.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1 | 798 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.22; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.010 m2
10104315160798xxxxxx0 | Půdorys 1.PP | Kus | 0.485 | 10104315160798xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/485.0000/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/485.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.02.30639 | A1 | 6774Obj0000049794 | Objekt | 485.000/177.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1 | 485 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.47; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
10105315160485xxxxxx0 | Půdorys 1.PP | Kus | 0 | 10105315160485xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/315.0000/315.0000/160.0000/1/307.5000/307.5000/0/90.0/0/0/1.0000/315.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/0/50.00/50.00/160.00/100.00/90.00/0/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.02.30640 | A1 | 6774Obj0000049876 | Objekt | 485.000/307.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.23; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.030 m2
20104315315050501601x9016xxxx | Půdorys 1.PP | Kus | 0.316 | 20104315315050501601x9016xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/315.5000/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/315.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.02.30641 | A1 | 6774Obj0000049890 | Objekt | 315.500/177.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1 | 316 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.9; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
10106315160316xxxxxx0 | Půdorys 1.PP | Kus | 0.748 | 10106315160316xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/747.5000/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/747.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.02.30642 | A1 | 6774Obj0000049904 | Objekt | 747.500/177.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1 | 748 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.15; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160
10104315160748xxxxxx0 | Půdorys 1.PP | Kus | 0.5 | 10104315160748xxxxxx0 | T-STCK. GERADE | 20 | 1016 | 3/0/0/0/180.0/0/0/200.0000/200.0000/160.0000/1/230.0000/-250.0000/0/270.0/0/0/0/160.0000/160.0000/1/230.0000/250.0000/0/90.0/0/0/160.0000/160.0000/160.0000/1/ | 70/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/200.00/200.00/50.00/50.00/50.00/50.00/160.00/0/0/0/500.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x160 | 160 | 160 | 200 | 0.000 | 0 | 1.000 m2 | IT.02.30643 | A1 | 6774Obj0000049960 | Objekt | 330.000/250.000/100.000/0.000/-250.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.11; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
701061601602x2x5050505016x05x01x | Půdorys 1.PP | Kus | 0.142 | 701061601602x2x5050505016x05x01x | UEBERGANG ECK/RU AS | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/125.0000/125.0000/2/142.4000/0.0388/-7.0000/0/0/0/0/160.0000/160.0000/1/ | 51/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/125.00/160.00/50.00/50.00/125.00/160.00/0/142.40/17.46/17.54/10.50/24.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 160 | 160 | 125 | 0.000 | 0 | 1.000 m2 | IT.02.30644 | A1 | 6774Obj0000049982 | Objekt | 142.400/80.039/73.000/0.000/-79.961/-87.000/0.000/0.000/0.000/1.000 | 1 | 142 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.14; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); K_LISTVALUE_ISO: 1.000 m2
51216125160505012516x14217181125 | Půdorys 1.PP | Kus | 0.142 | 51216125160505012516x14217181125 | UEBERGANG ECK/RU AS | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/125.0000/125.0000/2/142.4000/-0.0388/-7.0000/0/0/0/0/160.0000/160.0000/1/ | 51/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/125.00/160.00/50.00/50.00/125.00/160.00/0/142.40/17.54/17.46/10.50/24.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 160 | 160 | 125 | 0.000 | 0 | 1.000 m2 | IT.02.30645 | A1 | 6774Obj0000050004 | Objekt | 142.400/79.961/73.000/0.000/-80.039/-87.000/0.000/0.000/0.000/1.000 | 1 | 142 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); K_LISTVALUE_ISO: 1.000 m2
51216125160505012516x14218171125 | Půdorys 1.PP | Kus | 0.03 | 51216125160505012516x14218171125 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.030 m | IT.02.30646 | A1 | 6774Obj0000050007 | Objekt | 30.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.019 m2
152041251253xxxxxxx | Půdorys 1.PP | Kus | 0.03 | 152041251253xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.030 m | IT.02.30647 | A1 | 6774Obj0000050010 | Objekt | 30.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.019 m2
152041251253xxxxxxx | Půdorys 1.PP | Kus | 0.103 | 152041251253xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/102.8960/125.0000/125.0000/2/102.8960/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/102.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.103 m | IT.02.30648 | A1 | 6774Obj0000050013 | Objekt | 102.896/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.103 | 103 | __ISO | 0.04 | 0,041 W/m.K
15204125125103xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15204125125103xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30649 | A1 | 6774Obj0000050016 | Objekt | 48.529/64.630/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125115xxxxx0 | Půdorys 1.PP | Kus | 0.092 | 252x1250125115xxxxx0 | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/125.0000/125.0000/2/92.0000/0/0.0278/0/0/0/125.0000/125.0000/125.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/0/0/125.00/125.00/0/92.00/0/0/0.03/-0.03/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30650 | A1 | 6774Obj0000050019 | Objekt | 92.000/62.500/62.528/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 | 92 | __ISO | 0.04 | 0,041 W/m.K
30204125125x125125092x0-03xx | Půdorys 1.PP | Kus | 0.068 | 30204125125x125125092x0-03xx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/68.1682/125.0000/125.0000/2/68.1682/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/68.17/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.068 m | IT.02.30651 | A1 | 6774Obj0000050022 | Objekt | 68.168/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.068 | 68 | __ISO | 0.04 | 0,041 W/m.K
1520412512568xxxxxx0 | Půdorys 1.PP | Kus | 0 | 1520412512568xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30652 | A1 | 6774Obj0000050025 | Objekt | 48.529/64.630/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125115xxxxx0 | Půdorys 1.PP | Kus | 0.103 | 252x1250125115xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/102.8959/125.0000/125.0000/2/102.8959/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/102.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.103 m | IT.02.30653 | A1 | 6774Obj0000050028 | Objekt | 102.896/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.103 | 103 | __ISO | 0.04 | 0,041 W/m.K
15204125125103xxxxxx0 | Půdorys 1.PP | Kus | 0.064 | 15204125125103xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/64.2960/125.0000/125.0000/2/64.2960/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/64.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.064 m | IT.02.30654 | A1 | 6774Obj0000050031 | Objekt | 64.296/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.064 | 64 | __ISO | 0.04 | 0,041 W/m.K
1520412512564xxxxxx0 | Půdorys 1.PP | Kus | 0 | 1520412512564xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30655 | A1 | 6774Obj0000050034 | Objekt | 48.529/64.630/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125115xxxxx0 | Půdorys 1.PP | Kus | 0.092 | 252x1250125115xxxxx0 | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/125.0000/125.0000/2/92.0000/0/0.0278/0/0/0/125.0000/125.0000/125.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/0/0/125.00/125.00/0/92.00/0/0/0.03/-0.03/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30656 | A1 | 6774Obj0000050037 | Objekt | 92.000/62.500/62.528/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 | 92 | __ISO | 0.04 | 0,041 W/m.K
30204125125x125125092x0-03xx | Půdorys 1.PP | Kus | 0.068 | 30204125125x125125092x0-03xx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/68.1682/125.0000/125.0000/2/68.1682/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/68.17/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.068 m | IT.02.30657 | A1 | 6774Obj0000050040 | Objekt | 68.168/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.068 | 68 | __ISO | 0.04 | 0,041 W/m.K
1520412512568xxxxxx0 | Půdorys 1.PP | Kus | 0 | 1520412512568xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30658 | A1 | 6774Obj0000050043 | Objekt | 48.529/64.630/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125115xxxxx0 | Půdorys 1.PP | Kus | 0.064 | 252x1250125115xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/64.2959/125.0000/125.0000/2/64.2959/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/64.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.064 m | IT.02.30659 | A1 | 6774Obj0000050046 | Objekt | 64.296/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.064 | 64 | __ISO | 0.04 | 0,041 W/m.K
1520412512564xxxxxx0 | Půdorys 1.PP | Kus | 0.627 | 1520412512564xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/200.0000/160.0000/1/626.6000/0/0/0/0/0/1.0000/200.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/160.00/626.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x160 | 200 | 160 | 200 | 0.000 | 0 | 1.000 m2 | IT.02.30660 | A1 | 6774Obj0000050060 | Objekt | 626.600/120.000/100.000/0.000/-120.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 627 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.14; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160
-1104xxxxxxxx | Půdorys 1.PP | Kus | 0 | -1104xxxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/90.0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/0/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 |  | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 100 | 100 | 100 | 120.000 |  | 1.0 | IT.02.30661 | A1 | 6774Obj0000050064 | Objekt | 150.000/100.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; L_BES_DIM_B: 100
252x1x01x19xxxxxx | Půdorys 1.PP | Kus | 0.381 | 252x1x01x19xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/380.5000/100.0000/100.0000/2/380.5000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/380.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 0.381 m | IT.02.30662 | A1 | 6774Obj0000050067 | Objekt | 380.500/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.381 | 381 | __ISO | 0.04 | 0,041 W/m.K
152041x1x381xxxxxx0 | Půdorys 1.PP | Kus | 0 | 152041x1x381xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/180.0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/180.00/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 1.0 | IT.02.30663 | A1 | 6774Obj0000050071 | Objekt | 150.000/100.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1x01x19xxxxxx | Půdorys 1.PP | Kus | 0.07 | 252x1x01x19xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/69.5576/100.0000/100.0000/2/69.5576/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/69.56/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 0.070 m | IT.02.30664 | A1 | 6774Obj0000050074 | Objekt | 69.558/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.07 | 70 | __ISO | 0.04 | 0,041 W/m.K
152041x1x7xxxxxxx | Půdorys 1.PP | Kus | 0 | 152041x1x7xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/22.3/100.0000/100.0000/100.0000/2/50.0000/13.3975/0/30.0/0/22.3/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/22.30/0/100.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 1.0 | IT.02.30665 | A1 | 6774Obj0000050078 | Objekt | 75.000/56.699/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
