Properties of the parts of a building model (IFC2X3), part 43 of 51

# IfcFlowSegment (1090)
Name | In | Jednotka | Délka (m) | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_LAENGE | L_BES_DIM | L_BES_DIM_A2 = L_BES_DIM_A | L_BES_DIM_B2 | K_VOLSTROM | K_LISTVALUE | Kód prvku | Podlaží | Průměr | Teplonosná látka | Allright_Stavebni_dil_ID | Název_objektu | Označení | K_LISTVALUE_ISO
15205125125205xxxxxx0 | Půdorys 1.PP | m | 0.205 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/204.6089/125.0000/125.0000/2/204.6089/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/204.61/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 205 | DN125 | 125 | 125 | 0.000 | 0.205 m | PO.02.30409 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000142917 | Kruhové potrubí | 15205125125205xxxxxx0
15205125125133xxxxxx0 | Půdorys 1.PP | m | 0.133 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/133.2260/125.0000/125.0000/2/133.2260/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/133.23/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 133 | DN125 | 125 | 125 | 0.000 | 0.133 m | PO.02.30410 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000142927 | Kruhové potrubí | 15205125125133xxxxxx0
15205125125205xxxxxx0 | Půdorys 1.PP | m | 0.205 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/204.5063/125.0000/125.0000/2/204.5063/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/204.51/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 205 | DN125 | 125 | 125 | 0.000 | 0.205 m | PO.02.30411 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000142937 | Kruhové potrubí | 15205125125205xxxxxx0
1520412512513xxxxxxx | Půdorys 1.PP | m | 0.13 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/129.6700/125.0000/125.0000/2/129.6700/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/129.67/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 130 | DN125 | 125 | 125 | 0.000 | 0.130 m | PO.02.30412 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000142942 | Kruhové potrubí | 1520412512513xxxxxxx
1520412512519xxxxxxx | Půdorys 1.PP | m | 0.19 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/190.0431/125.0000/125.0000/2/190.0431/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/190.04/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 190 | DN125 | 125 | 125 | 0.000 | 0.190 m | PO.02.30413 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000142952 | Kruhové potrubí | 1520412512519xxxxxxx
1520412512513xxxxxxx | Půdorys 1.PP | m | 0.13 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/129.6618/125.0000/125.0000/2/129.6618/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/129.66/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 130 | DN125 | 125 | 125 | 0.000 | 0.130 m | PO.02.30414 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000142962 | Kruhové potrubí | 1520412512513xxxxxxx
15204125125223xxxxxx0 | Půdorys 1.PP | m | 0.223 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/223.3755/125.0000/125.0000/2/223.3755/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/223.38/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 223 | DN125 | 125 | 125 | 0.000 | 0.223 m | PO.02.30415 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000142967 | Kruhové potrubí | 15204125125223xxxxxx0
1520412512568xxxxxx0 | Půdorys 1.PP | m | 0.068 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/68.1682/125.0000/125.0000/2/68.1682/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/68.17/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 68 | DN125 | 125 | 125 | 0.000 | 0.068 m | PO.02.30416 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000142982 | Kruhové potrubí | 1520412512568xxxxxx0
15204125125223xxxxxx0 | Půdorys 1.PP | m | 0.223 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/223.3754/125.0000/125.0000/2/223.3754/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/223.38/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 223 | DN125 | 125 | 125 | 0.000 | 0.223 m | PO.02.30417 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000142992 | Kruhové potrubí | 15204125125223xxxxxx0
15204125125211xxxxxx0 | Půdorys 1.PP | m | 0.211 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/210.7292/125.0000/125.0000/2/210.7292/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/210.73/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 211 | DN125 | 125 | 125 | 0.000 | 0.211 m | PO.02.30418 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000142997 | Kruhové potrubí | 15204125125211xxxxxx0
1520412512516xxxxxxx | Půdorys 1.PP | m | 0.16 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/160.2719/125.0000/125.0000/2/160.2719/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/160.27/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160 | DN125 | 125 | 125 | 0.000 | 0.160 m | PO.02.30419 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143007 | Kruhové potrubí | 1520412512516xxxxxxx
15204125125211xxxxxx0 | Půdorys 1.PP | m | 0.211 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/210.6216/125.0000/125.0000/2/210.6216/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/210.62/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 211 | DN125 | 125 | 125 | 0.000 | 0.211 m | PO.02.30420 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143017 | Kruhové potrubí | 15204125125211xxxxxx0
15205125125162xxxxxx0 | Půdorys 1.PP | m | 0.162 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/162.2181/125.0000/125.0000/2/162.2181/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/162.22/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 162 | DN125 | 125 | 125 | 0.000 | 0.162 m | PO.02.30421 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143022 | Kruhové potrubí | 15205125125162xxxxxx0
1520512512568xxxxxx0 | Půdorys 1.PP | m | 0.068 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/68.1693/125.0000/125.0000/2/68.1693/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/68.17/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 68 | DN125 | 125 | 125 | 0.000 | 0.068 m | PO.02.30422 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143037 | Kruhové potrubí | 1520512512568xxxxxx0
15205125125162xxxxxx0 | Půdorys 1.PP | m | 0.162 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/162.2180/125.0000/125.0000/2/162.2180/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/162.22/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 162 | DN125 | 125 | 125 | 0.000 | 0.162 m | PO.02.30423 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143047 | Kruhové potrubí | 15205125125162xxxxxx0
15205125125333xxxxxx0 | Půdorys 1.PP | m | 0.333 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/333.0006/125.0000/125.0000/2/333.0006/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/333.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 333 | DN125 | 125 | 125 | 0.000 | 0.333 m | PO.02.30424 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143062 | Kruhové potrubí | 15205125125333xxxxxx0
1520612512564xxxxxx0 | Půdorys 1.PP | m | 0.064 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/64.2960/125.0000/125.0000/2/64.2960/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/64.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 64 | DN125 | 125 | 125 | 0.000 | 0.064 m | PO.02.30425 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143072 | Kruhové potrubí | 1520612512564xxxxxx0
1520612512516xxxxxxx | Půdorys 1.PP | m | 0.16 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/160.2719/125.0000/125.0000/2/160.2719/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/160.27/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160 | DN125 | 125 | 125 | 0.000 | 0.160 m | PO.02.30426 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143082 | Kruhové potrubí | 1520612512516xxxxxxx
1520612512564xxxxxx0 | Půdorys 1.PP | m | 0.064 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/64.1884/125.0000/125.0000/2/64.1884/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/64.19/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 64 | DN125 | 125 | 125 | 0.000 | 0.064 m | PO.02.30427 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143092 | Kruhové potrubí | 1520612512564xxxxxx0
15204125125103xxxxxx0 | Půdorys 1.PP | m | 0.103 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/102.8960/125.0000/125.0000/2/102.8960/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/102.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 103 | DN125 | 125 | 125 | 0.000 | 0.103 m | PO.02.30428 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143097 | Kruhové potrubí | 15204125125103xxxxxx0
1520412512568xxxxxx0 | Půdorys 1.PP | m | 0.068 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/68.1682/125.0000/125.0000/2/68.1682/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/68.17/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 68 | DN125 | 125 | 125 | 0.000 | 0.068 m | PO.02.30429 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143112 | Kruhové potrubí | 1520412512568xxxxxx0
15204125125103xxxxxx0 | Půdorys 1.PP | m | 0.103 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/102.8959/125.0000/125.0000/2/102.8959/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/102.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 103 | DN125 | 125 | 125 | 0.000 | 0.103 m | PO.02.30430 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143122 | Kruhové potrubí | 15204125125103xxxxxx0
15204125125103xxxxxx0 | Půdorys 1.PP | m | 0.103 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/102.8960/125.0000/125.0000/2/102.8960/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/102.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 103 | DN125 | 125 | 125 | 0.000 | 0.103 m | PO.02.30431 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143127 | Kruhové potrubí | 15204125125103xxxxxx0
1520412512568xxxxxx0 | Půdorys 1.PP | m | 0.068 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/68.1682/125.0000/125.0000/2/68.1682/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/68.17/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 68 | DN125 | 125 | 125 | 0.000 | 0.068 m | PO.02.30432 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143142 | Kruhové potrubí | 1520412512568xxxxxx0
15204125125103xxxxxx0 | Půdorys 1.PP | m | 0.103 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/102.8959/125.0000/125.0000/2/102.8959/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/102.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 103 | DN125 | 125 | 125 | 0.000 | 0.103 m | PO.02.30433 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143152 | Kruhové potrubí | 15204125125103xxxxxx0
1520412512564xxxxxx0 | Půdorys 1.PP | m | 0.064 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/64.2960/125.0000/125.0000/2/64.2960/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/64.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 64 | DN125 | 125 | 125 | 0.000 | 0.064 m | PO.02.30434 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143157 | Kruhové potrubí | 1520412512564xxxxxx0
1520412512568xxxxxx0 | Půdorys 1.PP | m | 0.068 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/68.1682/125.0000/125.0000/2/68.1682/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/68.17/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 68 | DN125 | 125 | 125 | 0.000 | 0.068 m | PO.02.30435 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143172 | Kruhové potrubí | 1520412512568xxxxxx0
1520412512564xxxxxx0 | Půdorys 1.PP | m | 0.064 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/64.2959/125.0000/125.0000/2/64.2959/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/64.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 64 | DN125 | 125 | 125 | 0.000 | 0.064 m | PO.02.30436 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143182 | Kruhové potrubí | 1520412512564xxxxxx0
1520412512532xxxxxx0 | Půdorys 1.PP | m | 0.032 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/32.2663/125.0000/125.0000/2/32.2663/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/32.27/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 32 | DN125 | 125 | 125 | 0.000 | 0.032 m | PO.02.30437 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143187 | Kruhové potrubí | 1520412512532xxxxxx0
15204125125157xxxxxx0 | Půdorys 1.PP | m | 0.157 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/156.7099/125.0000/125.0000/2/156.7099/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/156.71/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 157 | DN125 | 125 | 125 | 0.000 | 0.157 m | PO.02.30438 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143197 | Kruhové potrubí | 15204125125157xxxxxx0
1520412512532xxxxxx0 | Půdorys 1.PP | m | 0.032 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/32.2910/125.0000/125.0000/2/32.2910/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/32.29/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 32 | DN125 | 125 | 125 | 0.000 | 0.032 m | PO.02.30439 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143207 | Kruhové potrubí | 1520412512532xxxxxx0
15204125125146xxxxxx0 | Půdorys 1.PP | m | 0.146 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/146.3460/125.0000/125.0000/2/146.3460/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/146.35/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 146 | DN125 | 125 | 125 | 0.000 | 0.146 m | PO.02.30440 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143237 | Kruhové potrubí | 15204125125146xxxxxx0
1520412512568xxxxxx0 | Půdorys 1.PP | m | 0.068 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/68.1682/125.0000/125.0000/2/68.1682/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/68.17/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 68 | DN125 | 125 | 125 | 0.000 | 0.068 m | PO.02.30441 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143252 | Kruhové potrubí | 1520412512568xxxxxx0
15204125125146xxxxxx0 | Půdorys 1.PP | m | 0.146 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/146.3459/125.0000/125.0000/2/146.3459/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/146.35/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 146 | DN125 | 125 | 125 | 0.000 | 0.146 m | PO.02.30442 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143262 | Kruhové potrubí | 15204125125146xxxxxx0
1520412512542xxxxxx0 | Půdorys 1.PP | m | 0.042 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/41.9594/125.0000/125.0000/2/41.9594/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/41.96/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 42 | DN125 | 125 | 125 | 0.000 | 0.042 m | PO.02.30443 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143267 | Kruhové potrubí | 1520412512542xxxxxx0
1520412512568xxxxxx0 | Půdorys 1.PP | m | 0.068 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/68.1682/125.0000/125.0000/2/68.1682/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/68.17/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 68 | DN125 | 125 | 125 | 0.000 | 0.068 m | PO.02.30444 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143282 | Kruhové potrubí | 1520412512568xxxxxx0
1520412512542xxxxxx0 | Půdorys 1.PP | m | 0.042 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/41.9593/125.0000/125.0000/2/41.9593/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/41.96/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 42 | DN125 | 125 | 125 | 0.000 | 0.042 m | PO.02.30445 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143292 | Kruhové potrubí | 1520412512542xxxxxx0
15205125125703xxxxxx0 | Půdorys 1.PP | m | 0.703 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/703.2960/125.0000/125.0000/2/703.2960/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/703.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 703 | DN125 | 125 | 125 | 0.000 | 0.703 m | PO.02.30446 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143297 | Kruhové potrubí | 15205125125703xxxxxx0
1520512512516xxxxxxx | Půdorys 1.PP | m | 0.16 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/160.2719/125.0000/125.0000/2/160.2719/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/160.27/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160 | DN125 | 125 | 125 | 0.000 | 0.160 m | PO.02.30447 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143307 | Kruhové potrubí | 1520512512516xxxxxxx
15205125125703xxxxxx0 | Půdorys 1.PP | m | 0.703 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/703.1884/125.0000/125.0000/2/703.1884/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/703.19/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 703 | DN125 | 125 | 125 | 0.000 | 0.703 m | PO.02.30448 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143317 | Kruhové potrubí | 15205125125703xxxxxx0
 | Půdorys 1.PP | m | 1.018 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1017.9327/125.0000/125.0000/2/1017.9327/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/1017.93/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1018 | DN125 | 125 | 125 | 0.000 | 1.018 m | PO.02.30449 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143322 | Kruhové potrubí
15205125125172xxxxxx0 | Půdorys 1.PP | m | 0.172 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/172.1198/125.0000/125.0000/2/172.1198/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/172.12/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 172 | DN125 | 125 | 125 | 0.000 | 0.172 m | PO.02.30450 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143332 | Kruhové potrubí | 15205125125172xxxxxx0
 | Půdorys 1.PP | m | 1.018 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1017.9248/125.0000/125.0000/2/1017.9248/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/1017.92/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1018 | DN125 | 125 | 125 | 0.000 | 1.018 m | PO.02.30451 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143342 | Kruhové potrubí
1520412512561xxxxxx0 | Půdorys 1.PP | m | 0.061 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/60.6258/125.0000/125.0000/2/60.6258/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/60.63/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 61 | DN125 | 125 | 125 | 0.000 | 0.061 m | PO.02.30452 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143347 | Kruhové potrubí | 1520412512561xxxxxx0
1520412512584xxxxxx0 | Půdorys 1.PP | m | 0.084 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/84.0128/125.0000/125.0000/2/84.0128/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/84.01/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 84 | DN125 | 125 | 125 | 0.000 | 0.084 m | PO.02.30453 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143357 | Kruhové potrubí | 1520412512584xxxxxx0
1520412512561xxxxxx0 | Půdorys 1.PP | m | 0.061 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/60.6116/125.0000/125.0000/2/60.6116/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/60.61/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 61 | DN125 | 125 | 125 | 0.000 | 0.061 m | PO.02.30454 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143367 | Kruhové potrubí | 1520412512561xxxxxx0
15205125125277xxxxxx0 | Půdorys 1.PP | m | 0.277 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/276.5443/125.0000/125.0000/2/276.5443/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/276.54/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 277 | DN125 | 125 | 125 | 0.000 | 0.277 m | PO.02.30455 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143372 | Kruhové potrubí | 15205125125277xxxxxx0
15205125125152xxxxxx0 | Půdorys 1.PP | m | 0.152 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/151.8780/125.0000/125.0000/2/151.8780/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/151.88/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 152 | DN125 | 125 | 125 | 0.000 | 0.152 m | PO.02.30456 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143382 | Kruhové potrubí | 15205125125152xxxxxx0
15205125125277xxxxxx0 | Půdorys 1.PP | m | 0.277 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/276.5361/125.0000/125.0000/2/276.5361/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/276.54/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 277 | DN125 | 125 | 125 | 0.000 | 0.277 m | PO.02.30457 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143392 | Kruhové potrubí | 15205125125277xxxxxx0
15204125125106xxxxxx0 | Půdorys 1.PP | m | 0.106 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/105.7954/125.0000/125.0000/2/105.7954/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/105.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 106 | DN125 | 125 | 125 | 0.000 | 0.106 m | PO.02.30458 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143422 | Kruhové potrubí | 15204125125106xxxxxx0
1520412512511xxxxxxx | Půdorys 1.PP | m | 0.11 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/110.0538/125.0000/125.0000/2/110.0538/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/110.05/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 110 | DN125 | 125 | 125 | 0.000 | 0.110 m | PO.02.30459 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143437 | Kruhové potrubí | 1520412512511xxxxxxx
15204125125106xxxxxx0 | Půdorys 1.PP | m | 0.106 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/105.7952/125.0000/125.0000/2/105.7952/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/105.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 106 | DN125 | 125 | 125 | 0.000 | 0.106 m | PO.02.30460 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143447 | Kruhové potrubí | 15204125125106xxxxxx0
1520612512525xxxxxx0 | Půdorys 1.PP | m | 0.025 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/24.8463/125.0000/125.0000/2/24.8463/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/24.85/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 25 | DN125 | 125 | 125 | 0.000 | 0.025 m | PO.02.30461 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143452 | Kruhové potrubí | 1520612512525xxxxxx0
152061251253xxxxxxx | Půdorys 1.PP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.4854/125.0000/125.0000/2/30.4854/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.49/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.02.30462 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143462 | Kruhové potrubí | 152061251253xxxxxxx
1520612512525xxxxxx0 | Půdorys 1.PP | m | 0.025 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/24.8463/125.0000/125.0000/2/24.8463/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/24.85/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 25 | DN125 | 125 | 125 | 0.000 | 0.025 m | PO.02.30463 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143472 | Kruhové potrubí | 1520612512525xxxxxx0
1520512512561xxxxxx0 | Půdorys 1.PP | m | 0.061 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/61.3830/125.0000/125.0000/2/61.3830/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/61.38/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 61 | DN125 | 125 | 125 | 0.000 | 0.061 m | PO.02.30464 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143477 | Kruhové potrubí | 1520512512561xxxxxx0
15205125125274xxxxxx0 | Půdorys 1.PP | m | 0.274 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/274.3875/125.0000/125.0000/2/274.3875/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/274.39/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 274 | DN125 | 125 | 125 | 0.000 | 0.274 m | PO.02.30465 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143487 | Kruhové potrubí | 15205125125274xxxxxx0
1520512512561xxxxxx0 | Půdorys 1.PP | m | 0.061 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/61.3706/125.0000/125.0000/2/61.3706/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/61.37/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 61 | DN125 | 125 | 125 | 0.000 | 0.061 m | PO.02.30466 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143497 | Kruhové potrubí | 1520512512561xxxxxx0
15204125125221xxxxxx0 | Půdorys 1.PP | m | 0.221 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/220.7225/125.0000/125.0000/2/220.7225/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/220.72/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 221 | DN125 | 125 | 125 | 0.000 | 0.221 m | PO.02.30467 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143512 | Kruhové potrubí | 15204125125221xxxxxx0
152041x1x97xxxxxx0 | Půdorys 1.PP | m | 0.097 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/96.7000/100.0000/100.0000/2/96.7000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/96.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 97 | DN100 | 100 | 100 | 120.000 | 0.097 m | PO.02.30468 | Podzemní podlaží 1.PP | DN100 | vzduch | 6772Obj0000143522 | Kruhové potrubí | 152041x1x97xxxxxx0
152041601604xxxxxx0 | Půdorys 1.PP | m | 0.004 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/3.6838/160.0000/160.0000/2/3.6838/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/3.68/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 4 | DN160 | 160 | 160 | 120.000 | 0.004 m | PO.02.30469 | Podzemní podlaží 1.PP | DN160 | vzduch | 6772Obj0000143527 | Kruhové potrubí | 152041601604xxxxxx0
1520416016054xxxxxx0 | Půdorys 1.PP | m | 0.054 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/54.1453/160.0000/160.0000/2/54.1453/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/54.15/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 54 | DN160 | 160 | 160 | 120.000 | 0.054 m | PO.02.30470 | Podzemní podlaží 1.PP | DN160 | vzduch | 6772Obj0000143537 | Kruhové potrubí | 1520416016054xxxxxx0
152041601604xxxxxx0 | Půdorys 1.PP | m | 0.004 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/3.6306/160.0000/160.0000/2/3.6306/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/3.63/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 4 | DN160 | 160 | 160 | 120.000 | 0.004 m | PO.02.30471 | Podzemní podlaží 1.PP | DN160 | vzduch | 6772Obj0000143547 | Kruhové potrubí | 152041601604xxxxxx0
1520412512582xxxxxx0 | Půdorys 1.PP | m | 0.082 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/81.7000/125.0000/125.0000/2/81.7000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/81.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 82 | DN125 | 125 | 125 | 120.000 | 0.082 m | PO.02.30472 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143557 | Kruhové potrubí | 1520412512582xxxxxx0
1520412512555xxxxxx0 | Půdorys 1.PP | m | 0.055 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/55.3155/125.0000/125.0000/2/55.3155/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/55.32/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 55 | DN125 | 125 | 125 | 120.000 | 0.055 m | PO.02.30473 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143567 | Kruhové potrubí | 1520412512555xxxxxx0
152041251251xxxxxxx | Půdorys 1.PP | m | 0.01 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/9.7800/125.0000/125.0000/2/9.7800/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/9.78/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 10 | DN125 | 125 | 125 | 120.000 | 0.010 m | PO.02.30474 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143577 | Kruhové potrubí | 152041251251xxxxxxx
1520412512546xxxxxx0 | Půdorys 1.PP | m | 0.046 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/46.3303/125.0000/125.0000/2/46.3303/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/46.33/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 46 | DN125 | 125 | 125 | 120.000 | 0.046 m | PO.02.30475 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143587 | Kruhové potrubí | 1520412512546xxxxxx0
152041251255xxxxxxx | Půdorys 1.PP | m | 0.05 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/49.9000/125.0000/125.0000/2/49.9000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/49.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 50 | DN125 | 125 | 125 | 120.000 | 0.050 m | PO.02.30476 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143622 | Kruhové potrubí | 152041251255xxxxxxx
15204125125284xxxxxx0 | Půdorys 1.PP | m | 0.284 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/283.8000/125.0000/125.0000/2/283.8000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/283.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 284 | DN125 | 125 | 125 | 120.000 | 0.284 m | PO.02.30477 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000143632 | Kruhové potrubí | 15204125125284xxxxxx0
152041x1x381xxxxxx0 | Půdorys 1.PP | m | 0.381 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/380.5000/100.0000/100.0000/2/380.5000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/380.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 381 | DN100 | 100 | 100 | 120.000 | 0.381 m | PO.02.30478 | Podzemní podlaží 1.PP | DN100 | vzduch | 6772Obj0000143893 | Kruhové potrubí | 152041x1x381xxxxxx0
152041x1x7xxxxxxx | Půdorys 1.PP | m | 0.07 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/69.5576/100.0000/100.0000/2/69.5576/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/69.56/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 70 | DN100 | 100 | 100 | 120.000 | 0.070 m | PO.02.30479 | Podzemní podlaží 1.PP | DN100 | vzduch | 6772Obj0000143903 | Kruhové potrubí | 152041x1x7xxxxxxx
152041x1x57xxxxxx0 | Půdorys 1.PP | m | 0.057 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/57.1149/100.0000/100.0000/2/57.1149/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/57.11/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 57 | DN100 | 100 | 100 | 120.000 | 0.057 m | PO.02.30480 | Podzemní podlaží 1.PP | DN100 | vzduch | 6772Obj0000143913 | Kruhové potrubí | 152041x1x57xxxxxx0
152041x1x7xxxxxxx | Půdorys 1.PP | m | 0.07 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/69.5488/100.0000/100.0000/2/69.5488/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/69.55/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 70 | DN100 | 100 | 100 | 120.000 | 0.070 m | PO.02.30481 | Podzemní podlaží 1.PP | DN100 | vzduch | 6772Obj0000143923 | Kruhové potrubí | 152041x1x7xxxxxxx
1520412512521xxxxxxx | Půdorys 1.PP | m | 0.21 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/209.6844/125.0000/125.0000/2/209.6844/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/209.68/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 210 | DN125 | 125 | 125 | 0.000 | 0.210 m | PO.02.30482 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000144439 | Kruhové potrubí | 1520412512521xxxxxxx
15204125125149xxxxxx0 | Půdorys 1.PP | m | 0.149 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/149.3730/125.0000/125.0000/2/149.3730/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/149.37/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 149 | DN125 | 125 | 125 | 0.000 | 0.149 m | PO.02.30483 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000144449 | Kruhové potrubí | 15204125125149xxxxxx0
1520412512521xxxxxxx | Půdorys 1.PP | m | 0.21 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/209.6785/125.0000/125.0000/2/209.6785/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/209.68/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 210 | DN125 | 125 | 125 | 0.000 | 0.210 m | PO.02.30484 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000144459 | Kruhové potrubí | 1520412512521xxxxxxx
 | Půdorys 1.PP | m | 1.431 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1430.7000/125.0000/125.0000/2/1430.7000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/1430.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1431 | DN125 | 125 | 125 | 0.000 | 1.431 m | PO.02.30485 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000161805 | Kruhové potrubí
1010456016031xxxxxxx | Půdorys 1.PP | m2 | 0.31 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/160.0000/1/310.0000/0/0/0/0/0/1.0000/560.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/160.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// |  | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 310 | 560x160 | 560 | 160 | 0.000 | 1.000 m2 | PO.02.30486 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000162093 | Objekt | 1010456016031xxxxxxx | NEMSOK - K_POSITION: L.10; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.56 m; Výška: 0.16 m; Plocha: 1
15205250250635xxxxxx0 | Půdorys 1.NP | m | 0.635 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/634.6871/250.0000/250.0000/2/634.6871/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/634.69/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Mineralwolle/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 635 | DN250 | 250 | 250 | 0.000 | 0.635 m | PO.03.30373 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798478905 | Kruhové potrubí | 15205250250635xxxxxx0 | 0.897 m2
15205250250389xxxxxx0 | Půdorys 1.NP | m | 0.389 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/388.5000/250.0000/250.0000/2/388.5000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/388.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Mineralwolle/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 389 | DN250 | 250 | 250 | 0.000 | 0.389 m | PO.03.30374 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798478907 | Kruhové potrubí | 15205250250389xxxxxx0 | 0.549 m2
1520525025021xxxxxx0 | Půdorys 1.NP | m | 0.021 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/21.3000/250.0000/250.0000/2/21.3000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/21.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 21 | DN250 | 250 | 250 | 0.000 | 0.021 m | PO.03.30375 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798478911 | Kruhové potrubí | 1520525025021xxxxxx0 | 0.030 m2
152052502502xxxxxxx0 | Půdorys 1.NP | m | 0.2 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/200.0000/250.0000/250.0000/2/200.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/200.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 200 | DN250 | 250 | 250 | 0.000 | 0.200 m | PO.03.30376 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798478913 | Kruhové potrubí | 152052502502xxxxxxx0 | 0.283 m2
15205250250445xxxxxx0 | Půdorys 1.NP | m | 0.445 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/445.0000/250.0000/250.0000/2/445.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/445.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Alu kaschiert/100.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | 445 | DN250 | 250 | 250 | 0.000 | 0.445 m | PO.03.30377 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798478914 | Kruhové potrubí | 15205250250445xxxxxx0 | 0.629 m2
152041601606xxxxxxx | Půdorys 1.NP | m | 0.06 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/60.0000/160.0000/160.0000/2/60.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 60 | DN160 | 160 | 160 | 0.000 | 0.060 m | PO.03.30378 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798478923 | Kruhové potrubí | 152041601606xxxxxxx | 0.045 m2
15205250250432xxxxxx0 | Půdorys 1.NP | m | 0.432 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/432.0000/250.0000/250.0000/2/432.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/432.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | 432 | DN250 | 250 | 250 | 0.000 | 0.432 m | PO.03.30379 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798478925 | Kruhové potrubí | 15205250250432xxxxxx0 | 0.448 m2
1520525025033xxxxxxx | Půdorys 1.NP | m | 0.33 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/330.0000/250.0000/250.0000/2/330.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/330.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | 330 | DN250 | 250 | 250 | 0.000 | 0.330 m | PO.03.30380 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798478926 | Kruhové potrubí | 1520525025033xxxxxxx | 0.342 m2
152041601606xxxxxxx | Půdorys 1.NP | m | 0.06 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/60.0000/160.0000/160.0000/2/60.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 60 | DN160 | 160 | 160 | 0.000 | 0.060 m | PO.03.30381 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798478928 | Kruhové potrubí | 152041601606xxxxxxx | 0.045 m2
152041x1x6xxxxxxx | Půdorys 1.NP | m | 0.06 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/60.0000/100.0000/100.0000/2/60.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 60 | DN100 | 100 | 100 | 0.000 | 0.060 m | PO.03.30382 | Nadzemní podlaží 1.NP | DN100 | vzduch | 6782Obj0798478936 | Kruhové potrubí | 152041x1x6xxxxxxx | 0.034 m2
152041x1x6xxxxxxx | Půdorys 1.NP | m | 0.06 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/60.0000/100.0000/100.0000/2/60.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 60 | DN100 | 100 | 100 | 0.000 | 0.060 m | PO.03.30383 | Nadzemní podlaží 1.NP | DN100 | vzduch | 6782Obj0798478938 | Kruhové potrubí | 152041x1x6xxxxxxx | 0.034 m2
1520425025023xxxxxxx | Půdorys 1.NP | m | 0.23 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/230.0000/250.0000/250.0000/2/230.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/230.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | 230 | DN250 | 250 | 250 | 0.000 | 0.230 m | PO.03.30384 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798478975 | Kruhové potrubí | 1520425025023xxxxxxx | 0.238 m2
15204250250623xxxxxx0 | Půdorys 1.NP | m | 0.623 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/623.2233/250.0000/250.0000/2/623.2233/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/623.22/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | 623 | DN250 | 250 | 250 | 0.000 | 0.623 m | PO.03.30385 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798478976 | Kruhové potrubí | 15204250250623xxxxxx0 | 0.646 m2
15204250250413xxxxxx0 | Půdorys 1.NP | m | 0.413 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/413.2233/250.0000/250.0000/2/413.2233/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/413.22/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | 413 | DN250 | 250 | 250 | 0.000 | 0.413 m | PO.03.30386 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798478980 | Kruhové potrubí | 15204250250413xxxxxx0 | 0.428 m2
15204125125336xxxxxx0 | Půdorys 1.NP | m | 0.336 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/335.6578/125.0000/125.0000/2/335.6578/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/335.66/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 336 | DN125 | 125 | 125 | 120.000 | 0.336 m | PO.03.30387 | Nadzemní podlaží 1.NP | DN125 | vzduch | 6782Obj0798479032 | Kruhové potrubí | 15204125125336xxxxxx0 | 0.216 m2
15204125125622xxxxxx0 | Půdorys 1.NP | m | 0.622 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/622.2540/125.0000/125.0000/2/622.2540/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/622.25/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 622 | DN125 | 125 | 125 | 120.000 | 0.622 m | PO.03.30388 | Nadzemní podlaží 1.NP | DN125 | vzduch | 6782Obj0798479041 | Kruhové potrubí | 15204125125622xxxxxx0 | 0.401 m2
15204160160361xxxxxxx | Půdorys 1.NP | m | 3.61 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/3610.0000/160.0000/160.0000/2/3610.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/3610.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 3610 | DN160 | 160 | 160 | 0.000 | 3.610 m | PO.03.30389 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798479100 | Kruhové potrubí | 15204160160361xxxxxxx | 2.722 m2
1520425025012xxxxxxx | Půdorys 1.NP | m | 0.12 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/120.0000/250.0000/250.0000/2/120.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/120.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | 120 | DN250 | 250 | 250 | 0.000 | 0.120 m | PO.03.30390 | Nadzemní podlaží 1.NP | DN250 | vzduch | 6782Obj0798479106 | Kruhové potrubí | 1520425025012xxxxxxx | 0.124 m2
152041601606xxxxxxx | Půdorys 1.NP | m | 0.06 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/60.0000/160.0000/160.0000/2/60.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 60 | DN160 | 160 | 160 | 0.000 | 0.060 m | PO.03.30391 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798479109 | Kruhové potrubí | 152041601606xxxxxxx | 0.045 m2
152041x1x6xxxxxxx | Půdorys 1.NP | m | 0.06 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/60.0000/100.0000/100.0000/2/60.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 60 | DN100 | 100 | 100 | 0.000 | 0.060 m | PO.03.30392 | Nadzemní podlaží 1.NP | DN100 | vzduch | 6782Obj0798479111 | Kruhové potrubí | 152041x1x6xxxxxxx | 0.034 m2
152041601606xxxxxxx | Půdorys 1.NP | m | 0.06 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/60.0000/160.0000/160.0000/2/60.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 60 | DN160 | 160 | 160 | 0.000 | 0.060 m | PO.03.30393 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798479135 | Kruhové potrubí | 152041601606xxxxxxx | 0.045 m2
152041601606xxxxxxx | Půdorys 1.NP | m | 0.06 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/60.0000/160.0000/160.0000/2/60.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 60 | DN160 | 160 | 160 | 0.000 | 0.060 m | PO.03.30394 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798479137 | Kruhové potrubí | 152041601606xxxxxxx | 0.045 m2
15204160160142xxxxxx0 | Půdorys 1.NP | m | 0.142 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/141.8842/160.0000/160.0000/2/141.8842/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/141.88/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 142 | DN160 | 160 | 160 | 0.000 | 0.142 m | PO.03.30395 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798480591 | Kruhové potrubí | 15204160160142xxxxxx0 | 0.107 m2
152041x1x16xxxxxx0 | Půdorys 1.NP | m | 0.016 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/16.4077/100.0000/100.0000/2/16.4077/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/16.41/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 16 | DN100 | 100 | 100 | 0.000 | 0.016 m | PO.03.30396 | Nadzemní podlaží 1.NP | DN100 | vzduch | 6782Obj0798480880 | Kruhové potrubí | 152041x1x16xxxxxx0 | 0.009 m2
152041x1x129xxxxxx0 | Půdorys 1.NP | m | 0.129 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/129.2499/100.0000/100.0000/2/129.2499/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/129.25/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 129 | DN100 | 100 | 100 | 0.000 | 0.129 m | PO.03.30397 | Nadzemní podlaží 1.NP | DN100 | vzduch | 6782Obj0798480890 | Kruhové potrubí | 152041x1x129xxxxxx0 | 0.073 m2
15204160160155xxxxxx0 | Půdorys 1.NP | m | 0.155 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/154.9112/160.0000/160.0000/2/154.9112/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/154.91/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 155 | DN160 | 160 | 160 | 0.000 | 0.155 m | PO.03.30398 | Nadzemní podlaží 1.NP | DN160 | vzduch | 6782Obj0798480895 | Kruhové potrubí | 15204160160155xxxxxx0 | 0.117 m2
