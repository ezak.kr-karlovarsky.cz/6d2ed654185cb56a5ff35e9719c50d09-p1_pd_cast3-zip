Properties of the parts of a building model (IFC2X3), part 37 of 51

# IfcFlowFitting (2887)
Name | In | Jednotka | Délka (m) | Označení | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_DIM | L_BES_DIM_A2 | L_BES_DIM_B2 | L_BES_DIM_A | K_VOLSTROM | K_MLH_GOST = K_MLD_GOST | K_LISTVALUE | Kód prvku | Třída reakce na oheň | Allright_Stavebni_dil_ID | Název_objektu | K_EBT_BOX_WC | Plocha | L_BES_LAENGE | K_INTERNAL_ISO | Tloušťka (m) | Součinitel tepelné vodivost
101054502x232xxxxxx0 | Půdorys 1.NP | Kus | 0.524 | 101054502x232xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/523.9000/160.0000/160.0000/2/523.9000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/523.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.524 m | IT.03.30990 | A2 | 6784Obj0000157358 | Objekt | 523.900/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.524 | 524 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
macro | Půdorys 1.NP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/-1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/160.00/160.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN160 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30991 | A2 | 6784Obj0000157372 | Objekt | 50698.089/9453.493/3000.000/50538.089/9143.493/2840.000/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/17; N_FREI_68: SPIRO POTRUBÍ
101054502x15xxxxxxx0 | Půdorys 1.NP | Kus | 1.5 | 101054502x15xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.950 m2 | IT.03.30992 | A2 | 6784Obj0000157400 | Objekt | 1500.000/245.000/120.000/0.000/-245.000/-120.000/0.000/0.000/0.000/1.000 | 1.95 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.17; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200
101044502x15xxxxxxx0 | Půdorys 1.NP | Kus | 1.5 | 101044502x15xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/400.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/400.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x200 | 400 | 200 | 400 | 0.000 | 0 | 1.800 m2 | IT.03.30993 | A2 | 6784Obj0000157414 | Objekt | 1500.000/220.000/120.000/0.000/-220.000/-120.000/0.000/0.000/0.000/1.000 | 1.8 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 2.280 m2
101044x2x15xxxxxxx0 | Půdorys 1.NP | Kus | 0.1 | 101044x2x15xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/200.0000/1/100.0000/0/0/0/0/0/1.0000/315.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/200.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x200 | 315 | 200 | 315 | 0.000 | 0 | 1.000 m2 | IT.03.30994 | A2 | 6784Obj0000157428 | Objekt | 100.000/177.500/120.000/0.000/-177.500/-120.000/0.000/0.000/0.000/1.000 | 1 | 100 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.16; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200
101043152x1xxxxxxx0 | Půdorys 1.NP | Kus | 0.641 | 101043152x1xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/1/641.3000/0/0/0/0/0/1.0000/200.0000/200.0000/1/ | 10/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/641.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x200 | 200 | 200 | 200 | 0.000 | 0 | 1.000 m2 | IT.03.30995 | A2 | 6784Obj0000157442 | Objekt | 641.300/120.000/120.000/0.000/-120.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 641 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
101062x2x641xxxxxx0 | Půdorys 1.NP | Kus | 2.312 | 101062x2x641xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/2312.0000/160.0000/160.0000/2/2312.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/2312.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 2.312 m | IT.03.30996 | A2 | 6784Obj0000157445 | Objekt | 2312.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 2.312 | 2312 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 1.743 m2
 | Půdorys 1.NP | Kus | 1.12 |  | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1120.4000/160.0000/160.0000/2/1120.4000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/1120.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.120 m | IT.03.30997 | A2 | 6784Obj0000157448 | Objekt | 1120.400/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1.12 | 1120 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.845 m2
15205160160112xxxxxxx | Půdorys 1.NP | Kus | 2.687 | 15205160160112xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/2686.8000/180.0000/180.0000/2/2686.8000/0/0/0/0/0/180.0000/180.0000/180.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/180.00/180.00/2686.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN180 | 180 | 180 | 180 | 0.000 | 0 | 2.687 m | IT.03.30998 | A2 | 6784Obj0000157451 | Objekt | 2686.800/90.000/90.000/0.000/-90.000/-90.000/0.000/0.000/0.000/1.000 | 2.687 | 2687 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 2.195 m2
 | Půdorys 1.NP | Kus | 1.009 |  | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1009.0000/160.0000/160.0000/2/1009.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/1009.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.009 m | IT.03.30999 | A2 | 6784Obj0000157454 | Objekt | 1009.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1.009 | 1009 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.761 m2
152041601601x9xxxxxx0 | Půdorys 1.NP | Kus | 1.5 | 152041601601x9xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.950 m2 | IT.03.31000 | A2 | 6784Obj0000157468 | Objekt | 1500.000/245.000/120.000/0.000/-245.000/-120.000/0.000/0.000/0.000/1.000 | 1.95 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.125; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 2.430 m2
101054502x15xxxxxxx0 | Půdorys 1.NP | Kus | 0.18 | 101054502x15xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/180.4000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/180.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.000 m2 | IT.03.31001 | A2 | 6784Obj0000157482 | Objekt | 180.400/245.000/120.000/0.000/-245.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 180 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.11; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200
macro | Půdorys 1.NP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/160.00/160.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN160 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.31002 | A2 | 6784Obj0000157496 | Objekt | 58690.354/7615.000/3340.000/58380.354/7455.000/3180.000/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/10; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.NP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.31003 | A2 | 6784Obj0000157510 | Objekt | 60322.377/10669.500/3227.490/60014.786/10544.500/2919.898/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/10; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.NP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/160.00/160.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN160 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.31004 | A2 | 6784Obj0000157524 | Objekt | 62113.997/8411.118/3190.732/61765.529/8251.118/2897.168/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/10; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.NP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.31005 | A2 | 6784Obj0000157538 | Objekt | 60322.377/14164.500/3227.490/60014.786/14039.500/2919.898/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/10; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.NP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.31006 | A2 | 6784Obj0000157552 | Objekt | 62255.554/15719.221/3322.500/61945.554/15594.221/3197.500/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/10; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.NP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.31007 | A2 | 6784Obj0000157566 | Objekt | 60287.377/21169.500/3227.490/59979.786/21044.500/2919.898/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/10; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.NP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.31008 | A2 | 6784Obj0000157580 | Objekt | 62225.554/22713.221/3322.500/61915.554/22588.221/3197.500/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/10; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.NP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.31009 | A2 | 6784Obj0000157594 | Objekt | 60322.377/17684.500/3227.490/60014.786/17559.500/2919.898/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/10; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.NP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.31010 | A2 | 6784Obj0000157608 | Objekt | 62175.544/26208.202/3322.500/61865.544/26083.202/3197.500/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/10; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.NP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/160.00/160.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN160 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.31011 | A2 | 6784Obj0000157622 | Objekt | 62218.954/30080.000/3340.000/61908.954/29920.000/3180.000/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/10; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.NP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/-1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/160.00/160.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN160 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.31012 | A2 | 6784Obj0000157636 | Objekt | 59649.954/27624.788/3340.000/59339.954/27464.788/3180.000/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/17; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.NP | Kus | 0.28 | macro | Absperrklappe elektrisch NAK-E | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/-1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/100.00/100.00/280.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN100 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.31013 | A2 | 6784Obj0000157650 | Objekt | 57315.041/31025.000/3310.000/57190.041/30745.000/3210.000/0.000/0.000/0.000/1.000 | 1 | 280 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_DP_EBT: 0.00; K_DATE: 2023/01/10; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.NP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/-1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/160.00/160.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN160 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.31014 | A2 | 6784Obj0000157664 | Objekt | 55685.249/31349.434/3260.548/55444.376/30974.509/2952.874/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/16; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.NP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/-1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/160.00/160.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN160 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.31015 | A2 | 6784Obj0000157678 | Objekt | 54572.277/29850.000/3340.000/54412.277/29540.000/3180.000/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/10; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.NP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/-1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.31016 | A2 | 6784Obj0000157692 | Objekt | 52445.541/30662.500/3322.500/52135.541/30537.500/3197.500/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/10; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.NP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/-1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.31017 | A2 | 6784Obj0000157706 | Objekt | 51747.700/30062.500/3322.500/51437.700/29937.500/3197.500/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/09; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.NP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/200.00/200.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN200 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.31018 | A2 | 6784Obj0000157720 | Objekt | 58022.054/26509.390/3360.000/57712.054/26309.390/3160.000/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/10; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.NP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.31019 | A2 | 6784Obj0000157734 | Objekt | 60287.377/24666.500/3227.490/59979.786/24541.500/2919.898/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/10; N_FREI_68: SPIRO POTRUBÍ
 | Půdorys 1.NP | Kus | 0.4 |  | T-STCK. GERADE | 20 | 1016 | 3/0/0/0/180.0/0/180.0/250.0000/250.0000/200.0000/1/400.0000/32.5000/0/0/0/180.0/200.0000/315.0000/200.0000/1/200.0000/290.0000/0/90.0/0/180.0/200.0000/200.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/315.00/200.00/200.00/0/65.00/0/0/200.00/0/0/180.00/400.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x200 | 315 | 200 | 250 | 0.000 | 0 | 1.000 m2 | IT.03.31020 | A2 | 6784Obj0000157784 | Objekt | 400.000/290.000/120.000/0.000/-145.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 400 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.80; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
711042503152x2x065x2xx4x01x1x90 | Půdorys 1.NP | Kus | 0.17 | 711042503152x2x065x2xx4x01x1x90 | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/200.0000/200.0000/200.0000/1/169.6000/0/0/0/0/0/0/160.0000/160.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/160.00/35.00/100.00/200.00/160.00/160.00/169.60/-20.00/-20.00/-20.00/-20.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x200 | 160 | 160 | 200 | 0.000 | 0 | 1.000 m2 | IT.03.31021 | A2 | 6784Obj0000157806 | Objekt | 169.600/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 170 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.81; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
501052x160351x2x160160170-20-20- | Půdorys 1.NP | Kus | 0.36 | 501052x160351x2x160160170-20-20- | T-STCK. GERADE | 20 | 1016 | 3/0/0/0/180.0/0/180.0/400.0000/400.0000/200.0000/1/360.0000/25.0000/0/0/0/180.0/160.0000/450.0000/200.0000/1/180.0000/350.0000/0/90.0/0/180.0/160.0000/160.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/450.00/160.00/160.00/0/50.00/0/0/200.00/0/0/180.00/360.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x200 | 450 | 200 | 400 | 0.000 | 0 | 1.000 m2 | IT.03.31022 | A2 | 6784Obj0000157856 | Objekt | 360.000/350.000/120.000/0.000/-220.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 360 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.105; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
711044x45016016x5x02xx36x1x1x90 | Půdorys 1.NP | Kus | 0 | 711044x45016016x5x02xx36x1x1x90 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/450.0000/450.0000/200.0000/1/315.1650/130.5456/0/45.0/0/0/1.0000/450.0000/200.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/450.00/0/50.00/50.00/200.00/100.00/45.00/0/1.00/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.000 m2 | IT.03.31023 | A2 | 6784Obj0000157938 | Objekt | 488.406/303.787/120.000/0.000/-245.000/-120.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
2010445045x50502x1x452xxxx0 | Půdorys 1.NP | Kus | 1.5 | 2010445045x50502x1x452xxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.950 m2 | IT.03.31024 | A2 | 6784Obj0000157952 | Objekt | 1500.000/245.000/120.000/0.000/-245.000/-120.000/0.000/0.000/0.000/1.000 | 1.95 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 2.430 m2
101044502x15xxxxxxx0 | Půdorys 1.NP | Kus | 0.348 | 101044502x15xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/348.0000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/348.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.000 m2 | IT.03.31025 | A2 | 6784Obj0000157966 | Objekt | 348.000/245.000/120.000/0.000/-245.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 348 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.5; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
macro | Půdorys 1.NP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/-1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/160.00/160.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN160 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.31026 | A2 | 6784Obj0000157980 | Objekt | 41380.751/23389.825/3190.000/41070.751/23229.825/3030.000/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/10; N_FREI_68: SPIRO POTRUBÍ
101044x2x4xxxxxxx0 | Půdorys 1.NP | Kus | 0.924 | 101044x2x4xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/250.0000/200.0000/1/924.1000/0/0/0/0/0/1.0000/250.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/200.00/924.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x200 | 250 | 200 | 250 | 0.000 | 0 | 0.830 m2 | IT.03.31029 | A2 | 6784Obj0000158058 | Objekt | 924.100/145.000/120.000/0.000/-145.000/-120.000/0.000/0.000/0.000/1.000 | 0.83 | 924 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.24; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200
101042502x924xxxxxx0 | Půdorys 1.NP | Kus | 1.355 | 101042502x924xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/200.0000/1/1354.8000/0/0/0/0/0/1.0000/315.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/200.00/1354.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x200 | 315 | 200 | 315 | 0.000 | 0 | 1.400 m2 | IT.03.31030 | A2 | 6784Obj0000158072 | Objekt | 1354.800/177.500/120.000/0.000/-177.500/-120.000/0.000/0.000/0.000/1.000 | 1.4 | 1355 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.22; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200
101043152x1355xxxxxx0 | Půdorys 1.NP | Kus | 1.458 | 101043152x1355xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/400.0000/200.0000/1/1457.5000/0/0/0/0/0/1.0000/400.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/200.00/1457.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x200 | 400 | 200 | 400 | 0.000 | 0 | 1.750 m2 | IT.03.31031 | A2 | 6784Obj0000158086 | Objekt | 1457.500/220.000/120.000/0.000/-220.000/-120.000/0.000/0.000/0.000/1.000 | 1.75 | 1458 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.100; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 2.210 m2
101044x2x15xxxxxxx0 | Půdorys 1.NP | Kus | 2.885 | 101044x2x15xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/2885.0000/160.0000/160.0000/2/2885.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/2885.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 2.885 m | IT.03.31033 | A2 | 6784Obj0000158103 | Konstrukce v aktuální hladině | 2885.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 2.885 | 2885 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 2.175 m2
 | Půdorys 1.NP | Kus | 0.03 |  | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/160.0000/160.0000/2/30.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.030 m | IT.03.31034 | A2 | 6784Obj0000160215 | Objekt | 30.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.023 m2
152041601603xxxxxxx | Půdorys 1.NP | Kus | 0 | 152041601603xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/270.0/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.31035 | A2 | 6784Obj0000160218 | Objekt | 169.706/103.431/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x160145xxxxx0 | Půdorys 1.NP | Kus | 0.384 | 252x16x160145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/383.5689/160.0000/160.0000/2/383.5689/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/383.57/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.384 m | IT.03.31036 | A2 | 6784Obj0000160221 | Objekt | 383.569/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.384 | 384 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.289 m2
15205160160384xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15205160160384xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.31037 | A2 | 6784Obj0000160224 | Objekt | 169.706/103.431/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
1x1-1035xxxxxxxx | Půdorys 1.NP | Kus | 0.05 | 1x1-1035xxxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/50.0000/100.0000/100.0000/2/50.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 0.050 m | IT.03.31038 | A2 | 6784Obj0000160241 | Objekt | 50.000/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.05 | 50 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.028 m2
152041x1x5xxxxxxx | Půdorys 1.NP | Kus | 0 | 152041x1x5xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/270.0/100.0000/100.0000/100.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/270.00/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | IT.03.31039 | A2 | 6784Obj0000160244 | Objekt | 150.000/100.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1x01x19xxxxxx | Půdorys 1.NP | Kus | 0 | 252x1x01x19xxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/270.0/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.00/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.31040 | A2 | 6784Obj0000160247 | Objekt | 240.000/160.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16019xxxxxx | Půdorys 1.NP | Kus | 0.19 | 252x16x16019xxxxxx | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/0/100.0000/100.0000/100.0000/2/190.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/95.0000/95.0000/0/90.0/0/0/100.0000/100.0000/100.0000/2/ | 75/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/100.00/0/0/190.00/0/95.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | IT.03.31041 | A2 | 6784Obj0000160251 | Objekt | 190.000/95.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 | 190 | __ISO | 0.04 | 0,041 W/m.K
752051x1x1x019x9509xxxx | Půdorys 1.NP | Kus | 1.531 | 752051x1x1x019x9509xxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1530.9000/100.0000/100.0000/2/1530.9000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/1530.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.531 m | IT.03.31042 | A2 | 6784Obj0000160254 | Objekt | 1530.900/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1.531 | 1531 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.866 m2
1x010351x1x28xxxxxx0 | Půdorys 1.NP | Kus | 0.05 | 1x010351x1x28xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/50.0000/100.0000/100.0000/2/50.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 0.050 m | IT.03.31043 | A2 | 6784Obj0000160271 | Objekt | 50.000/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.05 | 50 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.028 m2
152041x1x5xxxxxxx | Půdorys 1.NP | Kus | 0 | 152041x1x5xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/270.0/100.0000/100.0000/100.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/270.00/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | IT.03.31044 | A2 | 6784Obj0000160274 | Objekt | 150.000/100.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1x01x19xxxxxx | Půdorys 1.NP | Kus | 0.907 | 252x1x01x19xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/906.9000/100.0000/100.0000/2/906.9000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/906.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 0.907 m | IT.03.31045 | A2 | 6784Obj0000160277 | Objekt | 906.900/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.907 | 907 | __ISO | 0.04 | 0,041 W/m.K
152041x1x907xxxxxx0 | Půdorys 1.NP | Kus | 0.26 | 152041x1x907xxxxxx0 | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/260.0000/0/0/0/0/270.0/1.0000/160.0000/160.0000/2/130.0000/130.0000/0/90.0/0/270.0/160.0000/160.0000/160.0000/2/ | 75/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/160.00/0/270.00/260.00/0/130.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.31046 | A2 | 6784Obj0000160281 | Objekt | 260.000/130.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 260 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
7520516016016x26x13x9xxxx | Půdorys 1.NP | Kus | 0.112 | 7520516016016x26x13x9xxxx | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/112.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 30/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/100.00/0/0/160.00/100.00/0/112.00/-30.00/-30.00/-30.00/-30.00/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 100 | 100 | 160 | 0.000 | 0 | 1.0 | IT.03.31047 | A2 | 6784Obj0000160284 | Objekt | 112.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 112 | __ISO | 0.04 | 0,041 W/m.K
302051601xx1601x0112-30-30-30-30 | Půdorys 1.NP | Kus | 0 | 302051601xx1601x0112-30-30-30-30 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/0/100.0000/100.0000/100.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/0/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | IT.03.31048 | A2 | 6784Obj0000160287 | Objekt | 150.000/100.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1x01x19xxxxxx | Půdorys 1.NP | Kus | 0.432 | 252x1x01x19xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/431.9000/160.0000/160.0000/2/431.9000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/431.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.432 m | IT.03.31049 | A2 | 6784Obj0000160290 | Objekt | 431.900/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.432 | 432 | __ISO | 0.04 | 0,041 W/m.K
15204160160432xxxxxx0 | Půdorys 1.NP | Kus | 0.809 | 15204160160432xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/808.6000/100.0000/100.0000/2/808.6000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/808.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 0.809 m | IT.03.31050 | A2 | 6784Obj0000160293 | Objekt | 808.600/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.809 | 809 | __ISO | 0.04 | 0,041 W/m.K
152041x1x809xxxxxx0 | Půdorys 1.NP | Kus | 1.633 | 152041x1x809xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1633.0000/100.0000/100.0000/2/1633.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/1633.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.633 m | IT.03.31051 | A2 | 6784Obj0000160296 | Objekt | 1633.000/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1.633 | 1633 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.923 m2
152051x1x1633xxxxxx0 | Půdorys 1.NP | Kus | 0.77 | 152051x1x1633xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/770.2000/160.0000/160.0000/2/770.2000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/770.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.770 m | IT.03.31052 | A2 | 6784Obj0000160299 | Objekt | 770.200/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.77 | 770 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.581 m2
10152042x2x3xxxxxxx0 | Půdorys 1.NP | Kus | 0.03 | 10152042x2x3xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/200.0000/200.0000/2/30.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.030 m | IT.03.31053 | A2 | 6784Obj0000161222 | Objekt | 30.000/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.026 m2
152042x2x3xxxxxxx | Půdorys 1.NP | Kus | 0.07 | 152042x2x3xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/69.5272/200.0000/200.0000/2/69.5272/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/69.53/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.070 m | IT.03.31054 | A2 | 6784Obj0000161225 | Objekt | 69.527/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.07 | 70 | __ISO | 0.04 | 0,041 W/m.K
152042x2x7xxxxxxx | Půdorys 1.NP | Kus | 0 | 152042x2x7xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/12.7/200.0000/200.0000/200.0000/2/141.4214/58.5786/0/45.0/0/12.7/200.0000/200.0000/200.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/12.70/0/200.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | IT.03.31055 | A2 | 6784Obj0000161228 | Objekt | 212.132/129.289/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x2x02x145xxxxx0 | Půdorys 1.NP | Kus | 0.112 | 252x2x02x145xxxxx0 | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/2/112.0000/-0.1021/-0.2295/0/0/0/200.0000/200.0000/200.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/0/0/200.00/200.00/0/112.00/0.10/-0.10/-0.23/0.23/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | IT.03.31056 | A2 | 6784Obj0000161231 | Objekt | 112.000/100.000/100.000/0.000/-100.102/-100.229/0.000/0.000/0.000/1.000 | 1 | 112 | __ISO | 0.04 | 0,041 W/m.K
302042x2xx2x2x01120-0-x3xx | Půdorys 1.NP | Kus | 0.07 | 302042x2xx2x2x01120-0-x3xx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/69.5271/200.0000/200.0000/2/69.5271/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/69.53/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.070 m | IT.03.31057 | A2 | 6784Obj0000161234 | Objekt | 69.527/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.07 | 70 | __ISO | 0.04 | 0,041 W/m.K
152042x2x7xxxxxxx | Půdorys 1.NP | Kus | 0.292 | 152042x2x7xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/292.2000/200.0000/200.0000/2/292.2000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/292.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.292 m | IT.03.31058 | A2 | 6784Obj0000161237 | Objekt | 292.200/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.292 | 292 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
macro | Půdorys 1.NP | Kus | 0.3 | macro | Absperrklappe elektrisch NAK-E | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/-1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/200.00/200.00/300.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN200 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.31059 | A2 | 6784Obj0000161251 | Objekt | 42489.626/-5603.701/3185.907/42082.021/-6012.663/2941.702/0.000/0.000/0.000/1.000 | 1 | 300 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_DP_EBT: 0.00; K_DATE: 2023/01/19; N_FREI_68: SPIRO POTRUBÍ
10152042x2x3xxxxxxx0 | Půdorys 1.NP | Kus | 0 | 10152042x2x3xxxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/189.1/200.0000/200.0000/200.0000/2/141.4214/58.5786/0/45.0/0/189.1/200.0000/200.0000/200.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/189.10/0/200.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | IT.03.31060 | A2 | 6784Obj0000161254 | Objekt | 212.132/129.289/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
1520416016xxxxxxx0 | Půdorys 1.NP | Kus | 0.487 | 1520416016xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/487.0000/160.0000/160.0000/2/487.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/487.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.487 m | IT.03.31061 | A2 | 6784Obj0000161257 | Objekt | 487.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.487 | 487 | __ISO | 0.04 | 0,041 W/m.K
1x010352x1x6xxxxxxx | Půdorys 1.NP | Kus | 0.19 | 1x010352x1x6xxxxxxx | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/180.0/100.0000/100.0000/100.0000/2/190.0000/0/0/0/0/180.0/125.0000/100.0000/100.0000/2/95.0000/95.0000/0/90.0/0/180.0/100.0000/100.0000/100.0000/2/ | 75/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/100.00/0/180.00/190.00/0/95.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | IT.03.31062 | A2 | 6784Obj0000163991 | Objekt | 190.000/95.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 | 190 | __ISO | 0.04 | 0,041 W/m.K
152041x1x5xxxxxxx | Půdorys 1.NP | Kus | 0 | 152041x1x5xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/270.0/100.0000/100.0000/100.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/270.00/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | IT.03.31063 | A2 | 6784Obj0000163997 | Objekt | 150.000/100.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
152041x1x5xxxxxxx | Půdorys 1.NP | Kus | 0 | 152041x1x5xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/270.0/100.0000/100.0000/100.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/270.00/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | IT.03.31064 | A2 | 6784Obj0000164017 | Objekt | 150.000/100.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
1x010351x1x28xxxxxx0 | Půdorys 1.NP | Kus | 0.7 | 1x010351x1x28xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/700.0000/100.0000/100.0000/2/700.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/700.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 0.700 m | IT.03.31065 | A2 | 6784Obj0000164034 | Objekt | 700.000/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.7 | 700 | __ISO | 0.04 | 0,041 W/m.K
152041x1x7xxxxxxx0 | Půdorys 1.NP | Kus | 2.56 | 152041x1x7xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/2560.0000/100.0000/100.0000/2/2560.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/2560.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 2.560 m | IT.03.31066 | A2 | 6784Obj0000164037 | Objekt | 2560.000/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 2.56 | 2560 | __ISO | 0.04 | 0,041 W/m.K
152041x1x256xxxxxxx | Půdorys 1.NP | Kus | 1.767 | 152041x1x256xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1767.4000/100.0000/100.0000/2/1767.4000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/1767.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.767 m | IT.03.31067 | A2 | 6784Obj0000164040 | Objekt | 1767.400/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1.767 | 1767 | __ISO | 0.04 | 0,041 W/m.K
752051x1x1x019x9509xxxx | Půdorys 1.NP | Kus | 0.3 | 752051x1x1x019x9509xxxx | T-STCK. GERADE | 20 | 1016 | 3/0/0/0/180.0/0/180.0/450.0000/450.0000/200.0000/1/300.0000/0/0/0/0/180.0/125.0000/450.0000/200.0000/1/150.0000/325.0000/0/90.0/0/180.0/100.0000/100.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/450.00/100.00/100.00/0/0/0/0/200.00/0/0/180.00/300.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.000 m2 | IT.03.31068 | A2 | 6784Obj0000164088 | Objekt | 300.000/325.000/120.000/0.000/-245.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 300 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.63; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
701044504501x1xxx2xx3x01x1x90 | Půdorys 1.NP | Kus | 1.5 | 701044504501x1xxx2xx3x01x1x90 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.950 m2 | IT.03.31069 | A2 | 6784Obj0000164102 | Objekt | 1500.000/245.000/120.000/0.000/-245.000/-120.000/0.000/0.000/0.000/1.000 | 1.95 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200
101044502x15xxxxxxx0 | Půdorys 1.NP | Kus | 0.057 | 101044502x15xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/56.5000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/56.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.000 m2 | IT.03.31070 | A2 | 6784Obj0000164116 | Objekt | 56.500/245.000/120.000/0.000/-245.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 57 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.5; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200
101044502x57xxxxxx0 | Půdorys 1.NP | Kus | 0.793 | 101044502x57xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/793.0000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/793.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.030 m2 | IT.03.31071 | A2 | 6784Obj0000164130 | Objekt | 793.000/245.000/120.000/0.000/-245.000/-120.000/0.000/0.000/0.000/1.000 | 1.03 | 793 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.6; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200
152042x2xxxxxxxx | Půdorys 1.NP | Kus | 0.4 | 152042x2xxxxxxxx | T-STCK. GERADE | 20 | 1016 | 3/0/0/0/180.0/0/0/315.0000/315.0000/200.0000/1/400.0000/42.5000/0/0/0/0/160.0000/400.0000/200.0000/1/200.0000/342.5000/0/90.0/0/0/200.0000/200.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/400.00/200.00/200.00/0/85.00/0/0/200.00/0/0/0/400.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x200 | 400 | 200 | 315 | 0.000 | 0 | 1.000 m2 | IT.03.31072 | A2 | 6784Obj0000444012 | Objekt | 400.000/342.500/120.000/0.000/-177.500/-120.000/0.000/0.000/0.000/1.000 | 1 | 400 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.85; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2
501052x2x351x2012x2x136x-1-129x0 | Půdorys 1.NP | Kus | 0.86 | 501052x2x351x2012x2x136x-1-129x0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/200.0000/1/859.9000/0/0/0/0/0/1.0000/315.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/200.00/859.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x200 | 315 | 200 | 315 | 0.000 | 0 | 1.000 m2 | IT.03.31073 | A2 | 6784Obj0000444048 | Objekt | 859.900/177.500/120.000/0.000/-177.500/-120.000/0.000/0.000/0.000/1.000 | 1 | 860 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.12; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200
152042x2x1157xxxxxx0 | Půdorys 1.NP | Kus | 1.04 | 152042x2x1157xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/400.0000/200.0000/1/1040.1000/0/0/0/0/0/1.0000/400.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/200.00/1040.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x200 | 400 | 200 | 400 | 0.000 | 0 | 1.250 m2 | IT.03.31074 | A2 | 6784Obj0000444088 | Objekt | 1040.100/220.000/120.000/0.000/-220.000/-120.000/0.000/0.000/0.000/1.000 | 1.25 | 1040 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.11; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200
152042x2xxxxxxxx | Půdorys 1.NP | Kus | 0.03 | 152042x2xxxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/200.0000/200.0000/2/30.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.030 m | IT.03.31075 | A2 | 6784Obj0000444091 | Objekt | 30.000/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.026 m2
