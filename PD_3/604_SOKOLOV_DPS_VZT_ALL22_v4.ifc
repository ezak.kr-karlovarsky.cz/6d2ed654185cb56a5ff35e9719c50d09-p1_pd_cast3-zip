Properties of the parts of a building model (IFC2X3), part 18 of 51

# IfcFlowFitting (2887)
Name | In | Jednotka | Délka (m) | Označení | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_DIM | L_BES_DIM_A2 | L_BES_DIM_B2 | L_BES_DIM_A | K_VOLSTROM | K_MLH_GOST = K_MLD_GOST | K_LISTVALUE | Kód prvku | Třída reakce na oheň | Allright_Stavebni_dil_ID | Název_objektu | K_EBT_BOX_WC | Plocha | L_BES_LAENGE | K_INTERNAL_ISO | Tloušťka (m) | Součinitel tepelné vodivost
4110456056050503554x0163x9373xx | Půdorys 1.PP | Kus | 0 | 4110456056050503554x0163x9373xx | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/560.0000/560.0000/355.0000/1/430.0000/430.0000/0/90.0/0/0/1.0000/560.0000/355.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/0/50.00/50.00/355.00/100.00/90.00/0/1.00/355.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 560x355 | 560 | 355 | 560 | 0.000 | 0 | 2.080 m2 | IT.02.30006 | A2 | 6774Obj0000017911 | Objekt | 730.000/430.000/197.500/0.000/-300.000/-197.500/0.000/0.000/0.000/1.000 | 2.08 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355
2010556056x50503551x90355xxx0 | Půdorys 1.PP | Kus | 0.1 | 2010556056x50503551x90355xxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/355.0000/1/100.0000/0/0/0/0/0/1.0000/560.0000/355.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/355.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 560x355 | 560 | 355 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30007 | A2 | 6774Obj0000017925 | Objekt | 100.000/300.000/197.500/0.000/-300.000/-197.500/0.000/0.000/0.000/1.000 | 1 | 100 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355
101045603551xxxxxxx0 | Půdorys 1.PP | Kus | 0.1 | 101045603551xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/355.0000/1/100.0000/0/0/0/0/0/1.0000/560.0000/355.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/355.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 560x355 | 560 | 355 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30008 | A2 | 6774Obj0000017939 | Objekt | 100.000/300.000/197.500/0.000/-300.000/-197.500/0.000/0.000/0.000/1.000 | 1 | 100 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355
101045603551xxxxxxx0 | Půdorys 1.PP | Kus | 0.705 | 101045603551xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/355.0000/1/705.0000/0/0/0/0/0/1.0000/560.0000/355.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/355.00/705.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 560x355 | 560 | 355 | 560 | 0.000 | 0 | 1.290 m2 | IT.02.30009 | A2 | 6774Obj0000017953 | Objekt | 705.000/300.000/197.500/0.000/-300.000/-197.500/0.000/0.000/0.000/1.000 | 1.29 | 705 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.15; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355
10105560355705xxxxxx0 | Půdorys 1.PP | Kus | 0.25 | 10105560355705xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/355.0000/1/250.0000/0/0/0/0/0/1.0000/560.0000/355.0000/1/ | 10/30/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/355.00/250.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 560x355 | 560 | 355 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30010 | A2 | 6774Obj0000017967 | Objekt | 250.000/300.000/197.500/0.000/-300.000/-197.500/0.000/0.000/0.000/1.000 | 1 | 250 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.6; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355
10103556035525xxxxxxx | Půdorys 1.PP | Kus | 0.19 | 10103556035525xxxxxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/355.0000/1/190.0000/0/0/0/0/0/1.0000/560.0000/355.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/355.00/190.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 560x355 | 560 | 355 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30011 | A2 | 6774Obj0000017981 | Objekt | 190.000/300.000/197.500/0.000/-300.000/-197.500/0.000/0.000/0.000/1.000 | 1 | 190 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355
1010556035519xxxxxxx | Půdorys 1.PP | Kus | 0 | 1010556035519xxxxxxx | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/270.0/560.0000/560.0000/355.0000/1/327.5000/327.5000/0/90.0/0/270.0/1.0000/560.0000/355.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/355.00/355.00/0/50.00/50.00/560.00/100.00/90.00/270.00/0/560.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 560x355 | 560 | 355 | 560 | 0.000 | 0 | 1.490 m2 | IT.02.30012 | A2 | 6774Obj0000018063 | Objekt | 525.000/327.500/300.000/0.000/-197.500/-300.000/0.000/0.000/0.000/1.000 | 1.49 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355
20105355355050505601x9056xxxx | Půdorys 1.PP | Kus | 0 | 20105355355050505601x9056xxxx | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/270.0/560.0000/560.0000/355.0000/1/327.5000/327.5000/0/90.0/0/270.0/1.0000/560.0000/355.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/355.00/355.00/0/50.00/50.00/560.00/100.00/90.00/270.00/0/560.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 560x355 | 560 | 355 | 560 | 0.000 | 0 | 1.490 m2 | IT.02.30013 | A2 | 6774Obj0000018145 | Objekt | 525.000/327.500/300.000/0.000/-197.500/-300.000/0.000/0.000/0.000/1.000 | 1.49 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.7; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355
20105355355050505601x9056xxxx | Půdorys 1.PP | Kus | 0.45 | 20105355355050505601x9056xxxx | T-STCK. GERADE | 20 | 1016 | 3/0/0/0/180.0/0/0/560.0000/560.0000/400.0000/1/450.0000/0/0/0/0/0/1.0000/560.0000/400.0000/1/225.0000/380.0000/0/90.0/0/0/250.0000/250.0000/400.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/250.00/250.00/0/0/0/0/400.00/0/0/0/450.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30014 | A2 | 6774Obj0000018193 | Objekt | 450.000/380.000/220.000/0.000/-300.000/-220.000/0.000/0.000/0.000/1.000 | 1 | 450 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.35; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
7010456056025025xx04xx45x1x1x90 | Půdorys 1.PP | Kus | 0.178 | 7010456056025025xx04xx45x1x1x90 | UEBERGANG ASYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/560.0000/560.0000/400.0000/1/177.9000/0/22.5000/0/0/0/0/560.0000/355.0000/1/ | 41/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/50.00/50.00/400.00/355.00/0/177.90/0/0/0/-45.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 355 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30015 | A2 | 6774Obj0000018215 | Objekt | 177.900/300.000/220.000/0.000/-300.000/-220.000/0.000/0.000/0.000/1.000 | 1 | 178 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.36; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
4110456056050504x3550178x0-453xx | Půdorys 1.PP | Kus | 0.287 | 4110456056050504x3550178x0-453xx | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/250.0000/250.0000/400.0000/1/287.4000/0/0/0/0/0/0/224.0000/224.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/224.00/35.00/100.00/400.00/224.00/224.00/287.40/-13.00/-13.00/-88.00/-88.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x400 | 224 | 224 | 250 | 0.000 | 0 | 1.000 m2 | IT.02.30016 | A2 | 6774Obj0000018237 | Objekt | 287.400/125.000/200.000/0.000/-125.000/-200.000/0.000/0.000/0.000/1.000 | 1 | 287 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
201051x01xx50502251x45225xxx0 | Půdorys 1.PP | Kus | 0.15 | 201051x01xx50502251x45225xxx0 | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/250.0000/400.0000/1/150.0000/0/0/0/0/0/0/224.0000/224.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/224.00/35.00/100.00/400.00/224.00/224.00/150.00/-13.00/-13.00/-88.00/-88.00/80.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x400 | 224 | 224 | 250 | 0.000 | 0 | 1.000 m2 | IT.02.30017 | A2 | 6774Obj0000018519 | Objekt | 150.000/125.000/200.000/0.000/-125.000/-200.000/0.000/0.000/0.000/1.000 | 1 | 150 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
50105250224351x4x224224150-13-13 | Půdorys 1.PP | Kus | 0 | 50105250224351x4x224224150-13-13 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/224.0000/224.0000/224.0000/2/224.0000/224.0000/0/90.0/0/90.0/224.0000/224.0000/224.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/224.00/90.00/0/224.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN224 | 224 | 224 | 224 | 0.000 | 0 | 1.0 | IT.02.30018 | A2 | 6774Obj0000018522 | Objekt | 336.000/224.000/112.000/0.000/-112.000/-112.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x224022419xxxxxx | Půdorys 1.PP | Kus | 0 | 252x224022419xxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/224.0000/224.0000/224.0000/2/224.0000/224.0000/0/90.0/0/90.0/224.0000/224.0000/224.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/224.00/0/0/224.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN224 | 224 | 224 | 224 | 0.000 | 0 | 1.0 | IT.02.30019 | A2 | 6774Obj0000018525 | Objekt | 336.000/224.000/112.000/0.000/-112.000/-112.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
101055604x266xxxxxx0 | Půdorys 1.PP | Kus | 0 | 101055604x266xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/0/125.0000/125.0000/125.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30020 | A2 | 6774Obj0000018624 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125145xxxxx0 | Půdorys 1.PP | Kus | 0.177 | 252x1250125145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/177.4175/125.0000/125.0000/2/177.4175/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/177.42/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.177 m | IT.02.30021 | A2 | 6774Obj0000018627 | Objekt | 177.417/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.177 | 177 | __ISO | 0.04 | 0,041 W/m.K
15206125125177xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15206125125177xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/0/125.0000/125.0000/125.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30022 | A2 | 6774Obj0000018630 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125145xxxxx0 | Půdorys 1.PP | Kus | 0.2 | 252x1250125145xxxxx0 | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/200.0000/0/0/0/0/0/0/200.0000/100.0000/1/ | 50/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/125.00/200.00/35.00/100.00/125.00/100.00/125.00/200.00/37.50/37.50/-12.50/-12.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 200 | 100 | 125 | 0.000 | 0 | 1.000 m2 | IT.02.30023 | A2 | 6774Obj0000018652 | Objekt | 200.000/100.000/62.500/0.000/-100.000/-62.500/0.000/0.000/0.000/1.000 | 1 | 200 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.10; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)
502161252x351x1251x1252x3838-13- | Půdorys 1.PP | Kus | 0 | 502161252x351x1251x1252x3838-13- | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/0/125.0000/125.0000/125.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30024 | A2 | 6774Obj0000018655 | Objekt | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
1x01062x1x4xxxxxxx | Půdorys 1.PP | Kus | 0.092 | 1x01062x1x4xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/91.6117/125.0000/125.0000/2/91.6117/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/91.61/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.092 m | IT.02.30025 | A2 | 6774Obj0000018672 | Objekt | 91.612/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.092 | 92 | __ISO | 0.04 | 0,041 W/m.K
1x01062x1x4xxxxxxx | Půdorys 1.PP | Kus | 0 | 1x01062x1x4xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30026 | A2 | 6774Obj0000018711 | Objekt | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012519xxxxxx | Půdorys 1.PP | Kus | 0.03 | 252x125012519xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.030 m | IT.02.30027 | A2 | 6774Obj0000018714 | Objekt | 30.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K
152041251253xxxxxxx | Půdorys 1.PP | Kus | 0 | 152041251253xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/0/125.0000/125.0000/125.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30028 | A2 | 6774Obj0000018717 | Objekt | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012519xxxxxx | Půdorys 1.PP | Kus | 0.64 | 252x125012519xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/639.8000/125.0000/125.0000/2/639.8000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/639.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.640 m | IT.02.30029 | A2 | 6774Obj0000018720 | Objekt | 639.800/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.64 | 640 | __ISO | 0.04 | 0,041 W/m.K
1520412512564xxxxxxx | Půdorys 1.PP | Kus | 0.078 | 1520412512564xxxxxxx | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/78.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 30/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/160.00/0/0/125.00/160.00/0/78.00/17.50/17.50/17.50/17.50/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 160 | 160 | 125 | 0.000 | 0 | 1.0 | IT.02.30030 | A2 | 6774Obj0000018723 | Objekt | 78.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 78 | __ISO | 0.04 | 0,041 W/m.K
3020612516x012516x78181818183xx | Půdorys 1.PP | Kus | 0.078 | 3020612516x012516x78181818183xx | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/78.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 30/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/160.00/0/0/125.00/160.00/0/78.00/17.50/17.50/17.50/17.50/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 160 | 160 | 125 | 0.000 | 0 | 1.0 | IT.02.30031 | A2 | 6774Obj0000018726 | Objekt | 78.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 78 | __ISO | 0.04 | 0,041 W/m.K
502161252x351x1251x1252x3838-13- | Půdorys 1.PP | Kus | 0 | 502161252x351x1251x1252x3838-13- | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30032 | A2 | 6774Obj0000018751 | Objekt | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012519xxxxxx | Půdorys 1.PP | Kus | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30033 | A2 | 6774Obj0000018754 | Objekt | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012519xxxxxx | Půdorys 1.PP | Kus | 0.078 | 252x125012519xxxxxx | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/78.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 30/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/160.00/0/0/125.00/160.00/0/78.00/17.50/17.50/17.50/17.50/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 160 | 160 | 125 | 0.000 | 0 | 1.0 | IT.02.30034 | A2 | 6774Obj0000018757 | Objekt | 78.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 78 | __ISO | 0.04 | 0,041 W/m.K
3020512516x012516x78181818183xx | Půdorys 1.PP | Kus | 0.26 | 3020512516x012516x78181818183xx | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/260.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/130.0000/130.0000/0/90.0/0/0/160.0000/160.0000/160.0000/2/ | 75/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/160.00/0/0/260.00/0/130.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.02.30035 | A2 | 6774Obj0000018761 | Objekt | 260.000/130.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 260 | __ISO | 0.04 | 0,041 W/m.K
7520516016016x26x13x9xxxx | Půdorys 1.PP | Kus | 0.078 | 7520516016016x26x13x9xxxx | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/78.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 30/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/0/0/160.00/125.00/0/78.00/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 125 | 125 | 160 | 0.000 | 0 | 1.0 | IT.02.30036 | A2 | 6774Obj0000018764 | Objekt | 78.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 78 | __ISO | 0.04 | 0,041 W/m.K
30205160125x160125078-18-18-18-1 | Půdorys 1.PP | Kus | 0 | 30205160125x160125078-18-18-18-1 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/224.0000/224.0000/224.0000/2/224.0000/224.0000/0/90.0/0/90.0/224.0000/224.0000/224.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/224.00/90.00/0/224.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN224 | 224 | 224 | 224 | 0.000 | 0 | 1.0 | IT.02.30037 | A2 | 6774Obj0000018767 | Objekt | 336.000/224.000/112.000/0.000/-112.000/-112.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x224022419xxxxxx | Půdorys 1.PP | Kus | 0 | 252x224022419xxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30038 | A2 | 6774Obj0000018770 | Objekt | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012519xxxxxx | Půdorys 1.PP | Kus | 0.355 | 252x125012519xxxxxx | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/270.0/224.0000/224.0000/224.0000/2/180.0000/-177.5000/0/270.0/0/270.0/125.0000/224.0000/224.0000/2/180.0000/177.5000/0/90.0/0/270.0/224.0000/224.0000/224.0000/2/ | 75/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/224.00/224.00/224.00/0/270.00/355.00/0/180.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN224 | 224 | 224 | 224 | 0.000 | 0 | 1.0 | IT.02.30039 | A2 | 6774Obj0000018774 | Objekt | 292.000/177.500/112.000/0.000/-177.500/-112.000/0.000/0.000/0.000/1.000 | 1 | 355 | __ISO | 0.04 | 0,041 W/m.K
752062242242240355018x9xxxx | Půdorys 1.PP | Kus | 0.118 | 752062242242240355018x9xxxx | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/224.0000/224.0000/224.0000/2/118.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 30/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/224.00/160.00/0/0/224.00/160.00/0/118.00/-32.00/-32.00/-32.00/-32.00/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN224 | 160 | 160 | 224 | 0.000 | 0 | 1.0 | IT.02.30040 | A2 | 6774Obj0000018777 | Objekt | 118.000/112.000/112.000/0.000/-112.000/-112.000/0.000/0.000/0.000/1.000 | 1 | 118 | __ISO | 0.04 | 0,041 W/m.K
3020622416x022416x118-32-32-32-3 | Půdorys 1.PP | Kus | 0.118 | 3020622416x022416x118-32-32-32-3 | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/224.0000/224.0000/224.0000/2/118.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 30/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/224.00/160.00/0/0/224.00/160.00/0/118.00/-32.00/-32.00/-32.00/-32.00/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN224 | 160 | 160 | 224 | 0.000 | 0 | 1.0 | IT.02.30041 | A2 | 6774Obj0000018780 | Objekt | 118.000/112.000/112.000/0.000/-112.000/-112.000/0.000/0.000/0.000/1.000 | 1 | 118 | __ISO | 0.04 | 0,041 W/m.K
3020622416x022416x118-32-32-32-3 | Půdorys 1.PP | Kus | 0 | 3020622416x022416x118-32-32-32-3 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.02.30042 | A2 | 6774Obj0000018783 | Objekt | 169.706/103.431/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x160145xxxxx0 | Půdorys 1.PP | Kus | 0.181 | 252x16x160145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/180.7000/160.0000/160.0000/2/180.7000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/180.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.181 m | IT.02.30043 | A2 | 6774Obj0000018786 | Objekt | 180.700/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.181 | 181 | __ISO | 0.04 | 0,041 W/m.K
15206160160181xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15206160160181xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/270.0/160.0000/160.0000/160.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.02.30044 | A2 | 6774Obj0000018789 | Objekt | 169.706/103.431/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x160145xxxxx0 | Půdorys 1.PP | Kus | 0.117 | 252x16x160145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/116.5000/160.0000/160.0000/2/116.5000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/116.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.117 m | IT.02.30045 | A2 | 6774Obj0000018792 | Objekt | 116.500/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.117 | 117 | __ISO | 0.04 | 0,041 W/m.K
15206160160117xxxxxx0 | Půdorys 1.PP | Kus | 0.18 | 15206160160117xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/179.5000/224.0000/224.0000/2/179.5000/0/0/0/0/0/224.0000/224.0000/224.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/224.00/224.00/179.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN224 | 224 | 224 | 224 | 0.000 | 0 | 0.179 m | IT.02.30046 | A2 | 6774Obj0000018795 | Objekt | 179.500/112.000/112.000/0.000/-112.000/-112.000/0.000/0.000/0.000/1.000 | 0.179 | 180 | __ISO | 0.04 | 0,041 W/m.K
1520622422418xxxxxxx | Půdorys 1.PP | Kus | 0.097 | 1520622422418xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/96.6000/224.0000/224.0000/2/96.6000/0/0/0/0/0/224.0000/224.0000/224.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/224.00/224.00/96.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN224 | 224 | 224 | 224 | 0.000 | 0 | 0.097 m | IT.02.30047 | A2 | 6774Obj0000018798 | Objekt | 96.600/112.000/112.000/0.000/-112.000/-112.000/0.000/0.000/0.000/1.000 | 0.097 | 97 | __ISO | 0.04 | 0,041 W/m.K
1520622422497xxxxxx0 | Půdorys 1.PP | Kus | 0.26 | 1520622422497xxxxxx0 | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/45.0/160.0000/160.0000/160.0000/2/260.0000/0/0/0/0/45.0/1.0000/160.0000/160.0000/2/130.0000/130.0000/0/90.0/0/45.0/160.0000/160.0000/160.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/160.00/0/45.00/260.00/0/130.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.02.30048 | A2 | 6774Obj0000018802 | Objekt | 260.000/130.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 260 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
7520416016016x26x13x9xxxx | Půdorys 1.PP | Kus | 0.03 | 7520416016016x26x13x9xxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/160.0000/160.0000/2/30.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.030 m | IT.02.30049 | A2 | 6774Obj0000018805 | Objekt | 30.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K
152041601603xxxxxxx | Půdorys 1.PP | Kus | 0 | 152041601603xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/270.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.02.30050 | A2 | 6774Obj0000018808 | Objekt | 169.706/103.431/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x160145xxxxx0 | Půdorys 1.PP | Kus | 0.5 | 252x16x160145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/500.0000/125.0000/125.0000/2/500.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.500 m | IT.02.30051 | A2 | 6774Obj0000018811 | Objekt | 500.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.5 | 500 | __ISO | 0.04 | 0,041 W/m.K
152051251255xxxxxxx0 | Půdorys 1.PP | Kus | 0.116 | 152051251255xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/116.1883/125.0000/125.0000/2/116.1883/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/116.19/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.116 m | IT.02.30052 | A2 | 6774Obj0000018814 | Objekt | 116.188/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.116 | 116 | __ISO | 0.04 | 0,041 W/m.K
15205125125116xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15205125125116xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30053 | A2 | 6774Obj0000018817 | Objekt | 93.750/70.873/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012513xxxxxx | Půdorys 1.PP | Kus | 0.133 | 252x125012513xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/132.9697/125.0000/125.0000/2/132.9697/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/132.97/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.133 m | IT.02.30054 | A2 | 6774Obj0000018820 | Objekt | 132.970/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.133 | 133 | __ISO | 0.04 | 0,041 W/m.K
15205125125133xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15205125125133xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30055 | A2 | 6774Obj0000018823 | Objekt | 93.750/70.873/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012513xxxxxx | Půdorys 1.PP | Kus | 0.116 | 252x125012513xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/116.1768/125.0000/125.0000/2/116.1768/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/116.18/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.116 m | IT.02.30056 | A2 | 6774Obj0000018826 | Objekt | 116.177/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.116 | 116 | __ISO | 0.04 | 0,041 W/m.K
15205125125116xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15205125125116xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30057 | A2 | 6774Obj0000018829 | Objekt | 93.750/70.873/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012513xxxxxx | Půdorys 1.PP | Kus | 0.133 | 252x125012513xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/132.9697/125.0000/125.0000/2/132.9697/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/132.97/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.133 m | IT.02.30058 | A2 | 6774Obj0000018832 | Objekt | 132.970/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.133 | 133 | __ISO | 0.04 | 0,041 W/m.K
15205125125133xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15205125125133xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30059 | A2 | 6774Obj0000018835 | Objekt | 93.750/70.873/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012513xxxxxx | Půdorys 1.PP | Kus | 0.13 | 252x125012513xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/130.2944/160.0000/160.0000/2/130.2944/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/130.29/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.130 m | IT.02.30060 | A2 | 6774Obj0000018838 | Objekt | 130.294/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.13 | 130 | __ISO | 0.04 | 0,041 W/m.K
1520516016013xxxxxxx | Půdorys 1.PP | Kus | 0 | 1520516016013xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/0/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/0/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.02.30061 | A2 | 6774Obj0000018841 | Objekt | 169.706/103.431/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x160145xxxxx0 | Půdorys 1.PP | Kus | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/0/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/0/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.02.30062 | A2 | 6774Obj0000018844 | Objekt | 169.706/103.431/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x160145xxxxx0 | Půdorys 1.PP | Kus | 1.767 | 252x16x160145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1767.2000/160.0000/160.0000/2/1767.2000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/1767.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.767 m | IT.02.30063 | A2 | 6774Obj0000018847 | Objekt | 1767.200/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1.767 | 1767 | __ISO | 0.04 | 0,041 W/m.K
 | Půdorys 1.PP | Kus | 0.26 |  | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/0/224.0000/224.0000/224.0000/2/260.0000/0/0/0/0/0/224.0000/224.0000/224.0000/2/130.0000/165.0000/0/90.0/0/0/160.0000/160.0000/160.0000/2/ | 75/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/224.00/224.00/160.00/0/0/260.00/0/165.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN224 | 224 | 224 | 224 | 0.000 | 0 | 1.0 | IT.02.30064 | A2 | 6774Obj0000018851 | Objekt | 260.000/165.000/112.000/0.000/-112.000/-112.000/0.000/0.000/0.000/1.000 | 1 | 260 | __ISO | 0.04 | 0,041 W/m.K
7520522422416x26x16509xxxx | Půdorys 1.PP | Kus | 0.118 | 7520522422416x26x16509xxxx | UE RUND AS | 20 | 1016 | 2/0/0/0/180.0/0/0/224.0000/224.0000/224.0000/2/118.0000/0/32.0000/0/0/0/160.0000/160.0000/160.0000/2/ | 31/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/224.00/160.00/0/0/224.00/160.00/0/118.00/-32.00/-32.00/0/-64.00/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN224 | 160 | 160 | 224 | 0.000 | 0 | 1.0 | IT.02.30065 | A2 | 6774Obj0000018854 | Objekt | 118.000/112.000/112.000/0.000/-112.000/-112.000/0.000/0.000/0.000/1.000 | 1 | 118 | __ISO | 0.04 | 0,041 W/m.K
3120522416x022416x118-32-320-643 | Půdorys 1.PP | Kus | 0.941 | 3120522416x022416x118-32-320-643 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/940.6000/224.0000/224.0000/2/940.6000/0/0/0/0/0/224.0000/224.0000/224.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/224.00/224.00/940.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN224 | 224 | 224 | 224 | 0.000 | 0 | 0.941 m | IT.02.30066 | A2 | 6774Obj0000018857 | Objekt | 940.600/112.000/112.000/0.000/-112.000/-112.000/0.000/0.000/0.000/1.000 | 0.941 | 941 | __ISO | 0.04 | 0,041 W/m.K
252x16x16019xxxxxx | Půdorys 1.PP | Kus | 0 | 252x16x16019xxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/180.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/180.00/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.02.30067 | A2 | 6774Obj0000018872 | Objekt | 240.000/160.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
 | Půdorys 1.PP | Kus | 4.035 |  | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/4035.0000/125.0000/125.0000/2/4035.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/4035.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 4.035 m | IT.02.30068 | A2 | 6774Obj0000018878 | Objekt | 4035.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 4.035 | 4035 | __ISO | 0.04 | 0,041 W/m.K
 | Půdorys 1.PP | Kus | 0.287 |  | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/286.8005/125.0000/125.0000/2/286.8005/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/286.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.287 m | IT.02.30069 | A2 | 6774Obj0000018884 | Objekt | 286.800/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.287 | 287 | __ISO | 0.04 | 0,041 W/m.K
15205125125287xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15205125125287xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30070 | A2 | 6774Obj0000018887 | Objekt | 93.750/70.873/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012513xxxxxx | Půdorys 1.PP | Kus | 0.131 | 252x125012513xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/131.0128/125.0000/125.0000/2/131.0128/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/131.01/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.131 m | IT.02.30071 | A2 | 6774Obj0000018890 | Objekt | 131.013/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.131 | 131 | __ISO | 0.04 | 0,041 W/m.K
15205125125131xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15205125125131xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30072 | A2 | 6774Obj0000018893 | Objekt | 93.750/70.873/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012513xxxxxx | Půdorys 1.PP | Kus | 0.287 | 252x125012513xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/286.7392/125.0000/125.0000/2/286.7392/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/286.74/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.287 m | IT.02.30073 | A2 | 6774Obj0000018896 | Objekt | 286.739/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.287 | 287 | __ISO | 0.04 | 0,041 W/m.K
15205125125287xxxxxx0 | Půdorys 1.PP | Kus | 2.889 | 15205125125287xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/2888.5000/160.0000/160.0000/2/2888.5000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/2888.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 2.889 m | IT.02.30074 | A2 | 6774Obj0000018899 | Objekt | 2888.500/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 2.889 | 2889 | __ISO | 0.04 | 0,041 W/m.K
 | Půdorys 1.PP | Kus | 4.047 |  | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/4047.4000/125.0000/125.0000/2/4047.4000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/4047.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 4.047 m | IT.02.30075 | A2 | 6774Obj0000018902 | Objekt | 4047.400/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 4.047 | 4047 | __ISO | 0.04 | 0,041 W/m.K
 | Půdorys 1.PP | Kus | 0.173 |  | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/355.0000/1/173.2000/0/0/0/0/0/1.0000/560.0000/355.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/355.00/173.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x355 | 560 | 355 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30076 | A2 | 6774Obj0000018916 | Objekt | 173.200/300.000/197.500/0.000/-300.000/-197.500/0.000/0.000/0.000/1.000 | 1 | 173 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.26; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355
10105560355173xxxxxx0 | Půdorys 1.PP | Kus | 0.038 | 10105560355173xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/38.0000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/38.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30077 | A2 | 6774Obj0000018930 | Objekt | 38.000/300.000/220.000/0.000/-300.000/-220.000/0.000/0.000/0.000/1.000 | 1 | 38 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
101045604x38xxxxxx0 | Půdorys 1.PP | Kus | 0 | 101045604x38xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/90.0/400.0000/400.0000/560.0000/1/430.0000/430.0000/0/90.0/0/90.0/1.0000/400.0000/560.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/0/50.00/50.00/400.00/100.00/90.00/90.00/1.00/400.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x560 | 400 | 560 | 400 | 0.000 | 0 | 2.180 m2 | IT.02.30078 | A2 | 6774Obj0000019012 | Objekt | 730.000/430.000/220.000/0.000/-300.000/-220.000/0.000/0.000/0.000/1.000 | 2.18 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.30; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 560
2010456056x50504x1x904xxxx0 | Půdorys 1.PP | Kus | 0 | 2010456056x50504x1x904xxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/180.0/400.0000/400.0000/560.0000/1/350.0000/350.0000/0/90.0/0/90.0/1.0000/560.0000/400.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/400.00/0/50.00/50.00/560.00/100.00/90.00/180.00/0/560.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x560 | 560 | 400 | 400 | 0.000 | 0 | 1.700 m2 | IT.02.30079 | A2 | 6774Obj0000019094 | Objekt | 570.000/350.000/300.000/0.000/-220.000/-300.000/0.000/0.000/0.000/1.000 | 1.7 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.32; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 560
201044x4x050505601x9056xxxx | Půdorys 1.PP | Kus | 0.322 | 201044x4x050505601x9056xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/400.0000/560.0000/1/321.5000/0/0/0/0/0/1.0000/400.0000/560.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/560.00/321.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x560 | 400 | 560 | 400 | 0.000 | 0 | 1.000 m2 | IT.02.30080 | A2 | 6774Obj0000019108 | Objekt | 321.500/220.000/300.000/0.000/-220.000/-300.000/0.000/0.000/0.000/1.000 | 1 | 322 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.27; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 560
101054x560322xxxxxx0 | Půdorys 1.PP | Kus | 0 | 101054x560322xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/180.0/560.0000/560.0000/400.0000/1/430.0000/430.0000/0/90.0/0/180.0/125.0000/560.0000/400.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/0/50.00/50.00/400.00/100.00/90.00/180.00/1.00/400.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 2.180 m2 | IT.02.30081 | A2 | 6774Obj0000019190 | Objekt | 730.000/430.000/220.000/0.000/-300.000/-220.000/0.000/0.000/0.000/1.000 | 2.18 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.24; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
macro | Půdorys 1.PP | Kus | 1.5 | macro | Schalldämpfer | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/-1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/560.00/400.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 1 | 1 | 1 | 0.000 | 0 |  | IT.02.30082 | A2 | 6774Obj0000019218 | Objekt | 54511.977/4203.635/-841.500/53011.977/3643.635/-1241.500/0.000/0.000/0.000/1.000 | 0 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1; K_DWGNAME: ${PROD}l\einbauteile\schalldaempfer\; K_DP_EBT: 0.00; K_DATE: 2023/01/13; N_FREI_68: Blech ST37 verzinkt
macro | Půdorys 1.PP | Kus | 1.5 | macro | Schalldämpfer | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/-1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/400.00/560.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 |  | 400x560 | 1 | 1 | 1 | 0.000 | 0 |  | IT.02.30083 | A2 | 6774Obj0000019232 | Objekt | 54511.977/3497.635/-2326.500/53011.977/3097.635/-2886.500/0.000/0.000/0.000/1.000 | 0 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.6; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1; K_DWGNAME: ${PROD}l\einbauteile\schalldaempfer\; K_DP_EBT: 0.00; K_DATE: 2023/01/13; N_FREI_68: Blech ST37 verzinkt
101045604x2xxxxxxx0 | Půdorys 1.PP | Kus | 0.25 | 101045604x2xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/250.0000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/250.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30084 | A2 | 6774Obj0000019260 | Objekt | 250.000/300.000/220.000/0.000/-300.000/-220.000/0.000/0.000/0.000/1.000 | 1 | 250 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
macro | Půdorys 1.PP | Kus | 1.25 | macro | Schalldämpfer | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/-1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/560.00/400.00/1250.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 |  | 560x400 | 1 | 1 | 1 | 0.000 | 0 |  | IT.02.30085 | A2 | 6774Obj0000019274 | Objekt | 55260.000/5803.600/-841.500/54700.000/4553.600/-1241.500/0.000/0.000/0.000/1.000 | 0 | 1250 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1; K_DWGNAME: ${PROD}l\einbauteile\schalldaempfer\; K_DP_EBT: 0.00; K_DATE: 2023/01/13; N_FREI_68: Blech ST37 verzinkt
201054x4x050505601x4556xxxx | Půdorys 1.PP | Kus | 0.1 | 201054x4x050505601x4556xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/860.0000/760.0000/1/100.0000/0/0/0/0/0/1.0000/860.0000/760.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/860.00/760.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 30/SB 30/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 860x760 | 860 | 760 | 860 | 0.000 | 0 | 1.000 m2 | IT.02.30086 | A2 | 6774Obj0000020074 | Objekt | 100.000/450.000/400.000/0.000/-450.000/-400.000/0.000/0.000/0.000/1.000 | 1 | 100 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 760
101058607601xxxxxxx0 | Půdorys 1.PP | Kus | 0.498 | 101058607601xxxxxxx0 | UEBERGANG ASYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/860.0000/860.0000/760.0000/1/498.4000/0/-100.0000/0/0/0/0/400.0000/560.0000/1/ | 41/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/860.00/400.00/50.00/50.00/760.00/560.00/0/498.40/-230.00/-230.00/-200.00/0/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 30/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 860x760 | 400 | 560 | 860 | 0.000 | 0 | 1.780 m2 | IT.02.30087 | A2 | 6774Obj0000020096 | Objekt | 498.400/450.000/400.000/0.000/-450.000/-400.000/0.000/0.000/0.000/1.000 | 1.78 | 498 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 760
411058604x505076056x498-230-230- | Půdorys 1.PP | Kus | 1.14 | 411058604x505076056x498-230-230- | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/400.0000/560.0000/1/1140.0000/0/0/0/0/0/1.0000/400.0000/560.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/560.00/1140.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x560 | 400 | 560 | 400 | 0.000 | 0 | 2.190 m2 | IT.02.30088 | A2 | 6774Obj0000020110 | Objekt | 1140.000/220.000/300.000/0.000/-220.000/-300.000/0.000/0.000/0.000/1.000 | 2.19 | 1140 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 560
101054x560114xxxxxxx | Půdorys 1.PP | Kus | 0 | 101054x560114xxxxxxx | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/560.0000/560.0000/400.0000/1/380.0000/380.0000/0/90.0/0/0/1.0000/560.0000/400.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/0/50.00/50.00/400.00/50.00/90.00/0/1.00/400.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 2.030 m2 | IT.02.30089 | A2 | 6774Obj0000020192 | Objekt | 680.000/380.000/220.000/0.000/-300.000/-220.000/0.000/0.000/0.000/1.000 | 2.03 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
