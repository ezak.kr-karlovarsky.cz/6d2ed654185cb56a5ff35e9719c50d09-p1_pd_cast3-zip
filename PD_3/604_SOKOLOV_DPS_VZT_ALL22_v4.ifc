Properties of the parts of a building model (IFC2X3), part 48 of 51

# IfcFlowSegment (1090)
Name | In | Jednotka | Délka (m) | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_LAENGE | L_BES_DIM | L_BES_DIM_A2 = L_BES_DIM_A | L_BES_DIM_B2 | K_VOLSTROM | K_LISTVALUE | Kód prvku | Podlaží | Průměr | Teplonosná látka | Allright_Stavebni_dil_ID | Název_objektu | Označení | K_LISTVALUE_ISO
101042802x531xxxxxx0 | Půdorys 1.NP | m2 | 0.531 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/280.0000/200.0000/1/530.9000/0/0/0/0/0/1.0000/280.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/200.00/530.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 531 | 280x200 | 280 | 200 | 0.000 | 1.000 m2 | PO.03.30220 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798485932 | Objekt | 101042802x531xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.28 m; Výška: 0.2 m
101042802x1492xxxxxx0 | Půdorys 1.NP | m2 | 1.492 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/280.0000/200.0000/1/1491.7000/0/0/0/0/0/1.0000/280.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/200.00/1491.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1492 | 280x200 | 280 | 200 | 0.000 | 1.430 m2 | PO.03.30221 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798485962 | Objekt | 101042802x1492xxxxxx0 | 1.910 m2 | NEMSOK - K_POSITION: L.5; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.28 m; Výška: 0.2 m
101042802x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/280.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/280.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 280x200 | 280 | 200 | 0.000 | 1.440 m2 | PO.03.30222 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798485977 | Objekt | 101042802x15xxxxxxx0 | 1.920 m2 | NEMSOK - K_POSITION: L.6; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.28 m; Výška: 0.2 m
101042802x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/280.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/280.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 280x200 | 280 | 200 | 0.000 | 1.440 m2 | PO.03.30223 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798485992 | Objekt | 101042802x15xxxxxxx0 | 1.920 m2 | NEMSOK - K_POSITION: L.7; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.28 m; Výška: 0.2 m
101042802x505xxxxxx0 | Půdorys 1.NP | m2 | 0.505 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/280.0000/200.0000/1/505.0000/0/0/0/0/0/1.0000/280.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/200.00/505.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 505 | 280x200 | 280 | 200 | 0.000 | 1.000 m2 | PO.03.30224 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798486007 | Objekt | 101042802x505xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.8; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.28 m; Výška: 0.2 m
15204125125559xxxxxx0 | Půdorys 1.NP | m | 0.559 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/558.8000/125.0000/125.0000/2/558.8000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/558.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 559 | DN125 | 125 | 125 | 0.000 | 0.559 m | PO.03.30225 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798486012 | Objekt | 15204125125559xxxxxx0 | 0.360 m2
101044502x1xxxxxxx0 | Půdorys 1.NP | m2 | 0.1 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/100.0000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 100 | 450x200 | 450 | 200 | 0.000 | 1.000 m2 | PO.03.30226 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798486123 | Objekt | 101044502x1xxxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.14; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.45 m; Výška: 0.2 m
15204160160385xxxxxx0 | Půdorys 1.NP | m | 0.385 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/385.3000/160.0000/160.0000/2/385.3000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/385.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 385 | DN160 | 160 | 160 | 0.000 | 0.385 m | PO.03.30227 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798486160 | Objekt | 15204160160385xxxxxx0 | 0.291 m2
15204125125161xxxxxx0 | Půdorys 1.NP | m | 0.161 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/161.1000/125.0000/125.0000/2/161.1000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/161.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 161 | DN125 | 125 | 125 | 0.000 | 0.161 m | PO.03.30228 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798486162 | Objekt | 15204125125161xxxxxx0 | 0.104 m2
15204125125266xxxxxx0 | Půdorys 1.NP | m | 0.266 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/265.5000/125.0000/125.0000/2/265.5000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/265.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 266 | DN125 | 125 | 125 | 0.000 | 0.266 m | PO.03.30229 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798486166 | Objekt | 15204125125266xxxxxx0 | 0.171 m2
101045x2x103xxxxxx0 | Půdorys 1.NP | m2 | 0.103 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/500.0000/200.0000/1/102.8204/0/0/0/0/0/1.0000/500.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/200.00/102.82/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 103 | 500x200 | 500 | 200 | 0.000 | 1.000 m2 | PO.03.30230 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798486466 | Objekt | 101045x2x103xxxxxx0 | 1.000 m2 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.5 m; Výška: 0.2 m
101045x2x1151xxxxxx0 | Půdorys 1.NP | m2 | 1.151 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/500.0000/200.0000/1/1150.8000/0/0/0/0/0/1.0000/500.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/200.00/1150.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1151 | 500x200 | 500 | 200 | 0.000 | 1.610 m2 | PO.03.30231 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798486511 | Objekt | 101045x2x1151xxxxxx0 | 1.980 m2 | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.5 m; Výška: 0.2 m
101043152x95xxxxxx0 | Půdorys 1.NP | m2 | 0.095 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/200.0000/1/95.0000/0/0/0/0/0/1.0000/315.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/200.00/95.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 95 | 315x200 | 315 | 200 | 0.000 | 1.000 m2 | PO.03.30232 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798486538 | Objekt | 101043152x95xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.315 m; Výška: 0.2 m
15205125125338xxxxxx0 | Půdorys 1.NP | m | 0.338 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/337.6812/125.0000/125.0000/2/337.6812/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/337.68/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 338 | DN125 | 125 | 125 | 0.000 | 0.338 m | PO.03.30234 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798486594 | Objekt | 15205125125338xxxxxx0 | 0.217 m2
 | Půdorys 1.NP | m | 1.429 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1429.4000/125.0000/125.0000/2/1429.4000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/1429.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1429 | DN125 | 125 | 125 | 0.000 | 1.429 m | PO.03.30235 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798486614 | Objekt |  | 0.921 m2
152051251253xxxxxx0 | Půdorys 1.NP | m | 0.003 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/3.1227/125.0000/125.0000/2/3.1227/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/3.12/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 3 | DN125 | 125 | 125 | 0.000 | 0.003 m | PO.03.30236 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798486746 | Objekt | 152051251253xxxxxx0 | 0.002 m2
101052802x234xxxxxx0 | Půdorys 1.NP | m2 | 0.234 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/280.0000/200.0000/1/233.5000/0/0/0/0/0/1.0000/280.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/200.00/233.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 234 | 280x200 | 280 | 200 | 0.000 | 1.000 m2 | PO.03.30237 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798486848 | Objekt | 101052802x234xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.6; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.28 m; Výška: 0.2 m
101052x315334xxxxxx0 | Půdorys 1.NP | m2 | 0.334 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/200.0000/315.0000/1/333.7000/0/0/0/0/0/1.0000/200.0000/315.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/315.00/333.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 334 | 200x315 | 200 | 315 | 0.000 | 1.000 m2 | PO.03.30238 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798486863 | Objekt | 101052x315334xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.7; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 315; Šířka: 0.2 m; Výška: 0.315 m
101055x2x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/500.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/500.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 500x200 | 500 | 200 | 0.000 | 2.100 m2 | PO.03.30239 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798486878 | Objekt | 101055x2x15xxxxxxx0 | 2.580 m2 | NEMSOK - K_POSITION: L.8; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.5 m; Výška: 0.2 m
101055x2x1357xxxxxx0 | Půdorys 1.NP | m2 | 1.357 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/500.0000/200.0000/1/1356.5000/0/0/0/0/0/1.0000/500.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/200.00/1356.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1357 | 500x200 | 500 | 200 | 0.000 | 1.900 m2 | PO.03.30240 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798486893 | Objekt | 101055x2x1357xxxxxx0 | 2.330 m2 | NEMSOK - K_POSITION: L.9; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.5 m; Výška: 0.2 m
15205125125367xxxxxx0 | Půdorys 1.NP | m | 0.367 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/366.6726/125.0000/125.0000/2/366.6726/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/366.67/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 367 | DN125 | 125 | 125 | 0.000 | 0.367 m | PO.03.30241 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798487019 | Objekt | 15205125125367xxxxxx0 | 0.236 m2
15205125125961xxxxxx0 | Půdorys 1.NP | m | 0.961 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/961.3000/125.0000/125.0000/2/961.3000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/961.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 961 | DN125 | 125 | 125 | 0.000 | 0.961 m | PO.03.30242 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798487034 | Objekt | 15205125125961xxxxxx0 | 0.619 m2
152041x1x5xxxxxxx | Půdorys 1.NP | m | 0.05 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/50.0000/100.0000/100.0000/2/50.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | 50 | DN100 | 100 | 100 | 120.000 | 0.050 m | PO.03.30243 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798487083 | Objekt | 152041x1x5xxxxxxx | 0.028 m2
152051x1x172xxxxxx0 | Půdorys 1.NP | m | 0.172 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/171.9000/100.0000/100.0000/2/171.9000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/171.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 172 | DN100 | 100 | 100 | 0.000 | 0.172 m | PO.03.30244 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798487094 | Objekt | 152051x1x172xxxxxx0 | 0.097 m2
152051x1x125xxxxxx0 | Půdorys 1.NP | m | 0.125 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/124.9000/100.0000/100.0000/2/124.9000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/124.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 125 | DN100 | 100 | 100 | 0.000 | 0.125 m | PO.03.30245 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798487099 | Objekt | 152051x1x125xxxxxx0 | 0.071 m2
1520516016098xxxxxx0 | Půdorys 1.NP | m | 0.098 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/97.5807/160.0000/160.0000/2/97.5807/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/97.58/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 98 | DN160 | 160 | 160 | 0.000 | 0.098 m | PO.03.30246 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798487104 | Objekt | 1520516016098xxxxxx0 | 0.074 m2
15205160160219xxxxxx0 | Půdorys 1.NP | m | 0.219 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/218.7258/160.0000/160.0000/2/218.7258/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/218.73/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 219 | DN160 | 160 | 160 | 0.000 | 0.219 m | PO.03.30247 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798487114 | Objekt | 15205160160219xxxxxx0 | 0.165 m2
15205160160382xxxxxx0 | Půdorys 1.NP | m | 0.382 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/382.2254/160.0000/160.0000/2/382.2254/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/382.23/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 382 | DN160 | 160 | 160 | 0.000 | 0.382 m | PO.03.30248 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798487129 | Objekt | 15205160160382xxxxxx0 | 0.288 m2
1520516016077xxxxxxx | Půdorys 1.NP | m | 0.77 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/770.2000/160.0000/160.0000/2/770.2000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/770.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 770 | DN160 | 160 | 160 | 0.000 | 0.770 m | PO.03.30249 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798487189 | Objekt | 1520516016077xxxxxxx | 0.581 m2
152051x1x1633xxxxxx0 | Půdorys 1.NP | m | 1.633 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1633.0000/100.0000/100.0000/2/1633.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/1633.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1633 | DN100 | 100 | 100 | 0.000 | 1.633 m | PO.03.30250 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798487231 | Objekt | 152051x1x1633xxxxxx0 | 0.923 m2
152051x1x1531xxxxxx0 | Půdorys 1.NP | m | 1.531 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1530.9000/100.0000/100.0000/2/1530.9000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/1530.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1531 | DN100 | 100 | 100 | 0.000 | 1.531 m | PO.03.30251 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798487252 | Objekt | 152051x1x1531xxxxxx0 | 0.866 m2
 | Půdorys 1.NP | m | 2.885 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/2885.0000/160.0000/160.0000/2/2885.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/2885.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 2885 | DN160 | 160 | 160 | 0.000 | 2.885 m | PO.03.30252 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798487257 | Objekt |  | 2.175 m2
152041x1x5xxxxxxx | Půdorys 1.NP | m | 0.05 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/50.0000/100.0000/100.0000/2/50.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | 50 | DN100 | 100 | 100 | 120.000 | 0.050 m | PO.03.30253 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798487259 | Objekt | 152041x1x5xxxxxxx | 0.028 m2
152052x2x78xxxxxx0 | Půdorys 1.NP | m | 0.078 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/78.2768/200.0000/200.0000/2/78.2768/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/78.28/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 78 | DN200 | 200 | 200 | 0.000 | 0.078 m | PO.03.30254 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798487292 | Objekt | 152052x2x78xxxxxx0 | 0.069 m2
152052x2x202xxxxxx0 | Půdorys 1.NP | m | 0.202 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/202.0102/200.0000/200.0000/2/202.0102/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/202.01/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 202 | DN200 | 200 | 200 | 0.000 | 0.202 m | PO.03.30255 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798487302 | Objekt | 152052x2x202xxxxxx0 | 0.178 m2
152052x2x51xxxxxx0 | Půdorys 1.NP | m | 0.051 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/50.8000/200.0000/200.0000/2/50.8000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/50.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 51 | DN200 | 200 | 200 | 0.000 | 0.051 m | PO.03.30256 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798487317 | Objekt | 152052x2x51xxxxxx0 | 0.045 m2
152052x2x174xxxxxx0 | Půdorys 1.NP | m | 0.174 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/174.3000/200.0000/200.0000/2/174.3000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/174.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 174 | DN200 | 200 | 200 | 0.000 | 0.174 m | PO.03.30257 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798487340 | Objekt | 152052x2x174xxxxxx0 | 0.153 m2
152052x2x306xxxxxx0 | Půdorys 1.NP | m | 0.306 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/305.7000/200.0000/200.0000/2/305.7000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/305.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 306 | DN200 | 200 | 200 | 0.000 | 0.306 m | PO.03.30258 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798487360 | Objekt | 152052x2x306xxxxxx0 | 0.269 m2
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/160.0000/160.0000/2/30.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN160 | 160 | 160 | 0.000 | 0.030 m | PO.03.30259 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798487373 | Objekt | 152041251253xxxxxxx | 0.023 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 30.000|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
15205160160285xxxxxx0 | Půdorys 1.NP | m | 0.285 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/284.6448/160.0000/160.0000/2/284.6448/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/284.64/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 285 | DN160 | 160 | 160 | 0.000 | 0.285 m | PO.03.30260 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798487389 | Objekt | 15205160160285xxxxxx0 | 0.215 m2
1520516016031xxxxxx0 | Půdorys 1.NP | m | 0.031 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/31.1000/160.0000/160.0000/2/31.1000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/31.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 31 | DN160 | 160 | 160 | 0.000 | 0.031 m | PO.03.30261 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798487427 | Objekt | 1520516016031xxxxxx0 | 0.023 m2
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/160.0000/160.0000/2/30.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN160 | 160 | 160 | 0.000 | 0.030 m | PO.03.30262 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798487439 | Objekt | 152041251253xxxxxxx | 0.023 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 30.000|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
15205160160285xxxxxx0 | Půdorys 1.NP | m | 0.285 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/284.6448/160.0000/160.0000/2/284.6448/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/284.64/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 285 | DN160 | 160 | 160 | 0.000 | 0.285 m | PO.03.30263 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798487455 | Objekt | 15205160160285xxxxxx0 | 0.215 m2
15205160160396xxxxxx0 | Půdorys 1.NP | m | 0.396 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/396.1000/160.0000/160.0000/2/396.1000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/396.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 396 | DN160 | 160 | 160 | 0.000 | 0.396 m | PO.03.30264 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798487470 | Objekt | 15205160160396xxxxxx0 | 0.299 m2
15205160160298xxxxxxx | Půdorys 1.NP | m | 2.98 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/2980.0000/160.0000/160.0000/2/2980.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/2980.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 2980 | DN160 | 160 | 160 | 0.000 | 2.980 m | PO.03.30265 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798487477 | Objekt | 15205160160298xxxxxxx | 2.247 m2
101044x2x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/400.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/400.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 400x200 | 400 | 200 | 0.000 | 1.800 m2 | PO.03.30266 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798487631 | Objekt | 101044x2x15xxxxxxx0 | 2.280 m2 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.4 m; Výška: 0.2 m
101044x2x114xxxxxx0 | Půdorys 1.NP | m2 | 0.114 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/400.0000/200.0000/1/114.0993/0/0/0/0/0/1.0000/400.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/200.00/114.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 114 | 400x200 | 400 | 200 | 0.000 | 1.000 m2 | PO.03.30267 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798487646 | Objekt | 101044x2x114xxxxxx0 | 1.000 m2 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.4 m; Výška: 0.2 m
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/160.0000/160.0000/2/30.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN160 | 160 | 160 | 0.000 | 0.030 m | PO.03.30268 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798487864 | Objekt | 152041251253xxxxxxx | 0.023 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 30.000|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
15204160160384xxxxxx0 | Půdorys 1.NP | m | 0.384 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/73.6000/160.0000/160.0000/2/73.6000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/73.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 74 | DN160 | 160 | 160 | 0.000 | 0.074 m | PO.03.30269 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798487888 | Objekt | 15204160160384xxxxxx0 | 0.055 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 383.569|80.000|80.000|0.000|-80.000|-80.000|0.000|0.000|0.000|1.000
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/160.0000/160.0000/2/30.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN160 | 160 | 160 | 0.000 | 0.030 m | PO.03.30270 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798487893 | Objekt | 152041251253xxxxxxx | 0.023 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 30.000|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.03.30271 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798487935 | Objekt | 152041251253xxxxxxx | 0.019 m2
15205125125555xxxxxx0 | Půdorys 1.NP | m | 0.555 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/554.8940/125.0000/125.0000/2/554.8940/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/554.89/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 555 | DN125 | 125 | 125 | 0.000 | 0.555 m | PO.03.30272 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798487951 | Objekt | 15205125125555xxxxxx0 | 0.357 m2
15205125125294xxxxxx0 | Půdorys 1.NP | m | 0.294 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/294.2722/125.0000/125.0000/2/294.2722/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/294.27/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 294 | DN125 | 125 | 125 | 0.000 | 0.294 m | PO.03.30273 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798487961 | Objekt | 15205125125294xxxxxx0 | 0.190 m2
101052802x847xxxxxx0 | Půdorys 1.NP | m2 | 0.847 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/280.0000/200.0000/1/847.0000/0/0/0/0/0/1.0000/280.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/200.00/847.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 847 | 280x200 | 280 | 200 | 0.000 | 1.000 m2 | PO.03.30274 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798487986 | Objekt | 101052802x847xxxxxx0 | 1.080 m2 | NEMSOK - K_POSITION: L.5; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.28 m; Výška: 0.2 m
101052x355873xxxxxx0 | Půdorys 1.NP | m2 | 0.873 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/200.0000/355.0000/1/873.0000/0/0/0/0/0/1.0000/200.0000/355.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/355.00/873.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 873 | 200x355 | 200 | 355 | 0.000 | 1.000 m2 | PO.03.30275 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798488001 | Objekt | 101052x355873xxxxxx0 | 1.250 m2 | NEMSOK - K_POSITION: L.6; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355; Šířka: 0.2 m; Výška: 0.355 m
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/200.0000/200.0000/2/30.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN200 | 200 | 200 | 0.000 | 0.030 m | PO.03.30276 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798488003 | Objekt | 152041251253xxxxxxx | 0.026 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 30.000|80.000|80.000|0.000|-80.000|-80.000|0.000|0.000|0.000|1.000
101052502x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/250.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/250.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 250x200 | 250 | 200 | 0.000 | 1.350 m2 | PO.03.30277 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798488009 | Objekt | 101052502x15xxxxxxx0 | 1.830 m2 | NEMSOK - K_POSITION: L.9; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.25 m; Výška: 0.2 m
101052502x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/250.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/250.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 250x200 | 250 | 200 | 0.000 | 1.350 m2 | PO.03.30278 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798488011 | Objekt | 101052502x15xxxxxxx0 | 1.830 m2 | NEMSOK - K_POSITION: L.10; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.25 m; Výška: 0.2 m
101052502x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/250.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/250.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 250x200 | 250 | 200 | 0.000 | 1.350 m2 | PO.03.30279 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798488013 | Objekt | 101052502x15xxxxxxx0 | 1.830 m2 | NEMSOK - K_POSITION: L.11; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.25 m; Výška: 0.2 m
101052502x1315xxxxxx0 | Půdorys 1.NP | m2 | 1.315 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/250.0000/200.0000/1/1315.0000/0/0/0/0/0/1.0000/250.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/200.00/1315.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1315 | 250x200 | 250 | 200 | 0.000 | 1.180 m2 | PO.03.30280 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798488015 | Objekt | 101052502x1315xxxxxx0 | 1.600 m2 | NEMSOK - K_POSITION: L.12; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.25 m; Výška: 0.2 m
10104450355753xxxxxx0 | Půdorys 1.NP | m2 | 0.753 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/450.0000/355.0000/1/753.0000/0/0/0/0/0/1.0000/450.0000/355.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/355.00/753.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 753 | 450x355 | 450 | 355 | 0.000 | 1.210 m2 | PO.03.30281 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798488069 | Objekt | 10104450355753xxxxxx0 | 1.450 m2 | NEMSOK - K_POSITION: L.48; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355; Šířka: 0.45 m; Výška: 0.355 m
101043552x981xxxxxx0 | Půdorys 1.NP | m2 | 0.981 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/355.0000/200.0000/1/980.7000/0/0/0/0/0/1.0000/355.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/355.00/200.00/980.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 981 | 355x200 | 355 | 200 | 0.000 | 1.090 m2 | PO.03.30282 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798488084 | Objekt | 101043552x981xxxxxx0 | 1.400 m2 | NEMSOK - K_POSITION: L.49; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.355 m; Výška: 0.2 m
101044502x1xxxxxxx | Půdorys 1.NP | m2 | 0.01 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/10.0000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/10.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 10 | 450x200 | 450 | 200 | 0.000 | 1.000 m2 | PO.03.30283 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798488114 | Objekt | 101044502x1xxxxxxx | 1.000 m2 | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.45 m; Výška: 0.2 m
101052502x113xxxxxx0 | Půdorys 1.NP | m2 | 0.113 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/250.0000/200.0000/1/112.8204/0/0/0/0/0/1.0000/250.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/200.00/112.82/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 113 | 250x200 | 250 | 200 | 0.000 | 1.000 m2 | PO.03.30284 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798489071 | Objekt | 101052502x113xxxxxx0 | 1.000 m2 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.25 m; Výška: 0.2 m
101052502x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/250.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/250.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 250x200 | 250 | 200 | 0.000 | 1.350 m2 | PO.03.30285 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798489116 | Objekt | 101052502x15xxxxxxx0 | 1.830 m2 | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.25 m; Výška: 0.2 m
101052502x39xxxxxxx | Půdorys 1.NP | m2 | 0.39 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/250.0000/200.0000/1/389.6000/0/0/0/0/0/1.0000/250.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/200.00/389.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 390 | 250x200 | 250 | 200 | 0.000 | 1.000 m2 | PO.03.30286 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798489131 | Objekt | 101052502x39xxxxxxx | 1.000 m2 | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.25 m; Výška: 0.2 m
101052502x1294xxxxxx0 | Půdorys 1.NP | m2 | 1.294 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/250.0000/200.0000/1/1294.3000/0/0/0/0/0/1.0000/250.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/200.00/1294.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1294 | 250x200 | 250 | 200 | 0.000 | 1.160 m2 | PO.03.30287 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798489146 | Objekt | 101052502x1294xxxxxx0 | 1.580 m2 | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.25 m; Výška: 0.2 m
152052x2x163xxxxxx0 | Půdorys 1.NP | m | 0.163 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/162.8204/200.0000/200.0000/2/162.8204/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/162.82/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 163 | DN200 | 200 | 200 | 0.000 | 0.163 m | PO.03.30288 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798489178 | Objekt | 152052x2x163xxxxxx0 | 0.143 m2
152052x2x6xxxxxxxx | Půdorys 1.NP | m | 6 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/5690.0000/200.0000/200.0000/2/5690.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/5690.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 5690 | DN200 | 200 | 200 | 0.000 | 5.690 m | PO.03.30289 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798489196 | Objekt | 152052x2x6xxxxxxxx | 5.005 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 6000.000|100.000|100.000|0.000|-100.000|-100.000|0.000|0.000|0.000|1.000
15205160160225xxxxxx0 | Půdorys 1.NP | m | 0.225 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/225.1000/160.0000/160.0000/2/225.1000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/225.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 225 | DN160 | 160 | 160 | 0.000 | 0.225 m | PO.03.30290 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798489218 | Objekt | 15205160160225xxxxxx0 | 0.170 m2
101044502x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 450x200 | 450 | 200 | 0.000 | 1.950 m2 | PO.03.30291 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798489263 | Objekt | 101044502x15xxxxxxx0 | 2.430 m2 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.45 m; Výška: 0.2 m
101044502x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 450x200 | 450 | 200 | 0.000 | 1.950 m2 | PO.03.30292 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798489278 | Objekt | 101044502x15xxxxxxx0 | 2.430 m2 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.45 m; Výška: 0.2 m
101044502x1291xxxxxx0 | Půdorys 1.NP | m2 | 1.291 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/1290.9098/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/1290.91/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1291 | 450x200 | 450 | 200 | 0.000 | 1.680 m2 | PO.03.30293 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798489293 | Objekt | 101044502x1291xxxxxx0 | 2.090 m2 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.45 m; Výška: 0.2 m
101044502x965xxxxxx0 | Půdorys 1.NP | m2 | 0.965 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/965.4000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/965.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 965 | 450x200 | 450 | 200 | 0.000 | 1.260 m2 | PO.03.30294 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798489338 | Objekt | 101044502x965xxxxxx0 | 1.560 m2 | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.45 m; Výška: 0.2 m
101044502x348xxxxxx0 | Půdorys 1.NP | m2 | 0.348 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/348.0000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/348.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 348 | 450x200 | 450 | 200 | 0.000 | 1.000 m2 | PO.03.30295 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798489353 | Objekt | 101044502x348xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.5; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.45 m; Výška: 0.2 m
101044502x192xxxxxx0 | Půdorys 1.NP | m2 | 0.192 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/192.1398/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/192.14/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 192 | 450x200 | 450 | 200 | 0.000 | 1.000 m2 | PO.03.30296 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798489392 | Objekt | 101044502x192xxxxxx0 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.45 m; Výška: 0.2 m
101045x2x118xxxxxx0 | Půdorys 1.NP | m2 | 0.118 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/500.0000/200.0000/1/117.7982/0/0/0/0/0/1.0000/500.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/200.00/117.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 118 | 500x200 | 500 | 200 | 0.000 | 1.000 m2 | PO.03.30297 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798489400 | Objekt | 101045x2x118xxxxxx0 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.5 m; Výška: 0.2 m
101045x2x25xxxxxxx | Půdorys 1.NP | m2 | 0.25 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/500.0000/200.0000/1/250.0000/0/0/0/0/0/1.0000/500.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/200.00/250.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250 | 500x200 | 500 | 200 | 0.000 | 1.000 m2 | PO.03.30298 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798489404 | Objekt | 101045x2x25xxxxxxx | NEMSOK - K_POSITION: L.18; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.5 m; Výška: 0.2 m
101045x2x3xxxxxx0 | Půdorys 1.NP | m2 | 0.003 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/500.0000/200.0000/1/3.0151/0/0/0/0/0/1.0000/500.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/200.00/3.02/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 3 | 500x200 | 500 | 200 | 0.000 | 1.000 m2 | PO.03.30299 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798489408 | Objekt | 101045x2x3xxxxxx0 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.5 m; Výška: 0.2 m
101044502x474xxxxxx0 | Půdorys 1.NP | m2 | 0.474 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/474.2613/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/474.26/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 474 | 450x200 | 450 | 200 | 0.000 | 1.000 m2 | PO.03.30300 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798489440 | Objekt | 101044502x474xxxxxx0 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.45 m; Výška: 0.2 m
101044502x13xxxxxx0 | Půdorys 1.NP | m2 | 0.013 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/12.8205/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/12.82/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 13 | 450x200 | 450 | 200 | 0.000 | 1.000 m2 | PO.03.30301 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798489470 | Objekt | 101044502x13xxxxxx0 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.45 m; Výška: 0.2 m
101044502x474xxxxxx0 | Půdorys 1.NP | m2 | 0.474 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/474.3353/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/474.34/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 474 | 450x200 | 450 | 200 | 0.000 | 1.000 m2 | PO.03.30302 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798489500 | Objekt | 101044502x474xxxxxx0 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.45 m; Výška: 0.2 m
15204160160222xxxxxx0 | Půdorys 1.NP | m | 0.222 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/222.3905/160.0000/160.0000/2/222.3905/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/222.39/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 222 | DN160 | 160 | 160 | 0.000 | 0.222 m | PO.03.30303 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798489525 | Objekt | 15204160160222xxxxxx0
101045x2x598xxxxxx0 | Půdorys 1.NP | m2 | 0.598 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/500.0000/200.0000/1/597.5000/0/0/0/0/0/1.0000/500.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/200.00/597.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 598 | 500x200 | 500 | 200 | 0.000 | 1.000 m2 | PO.03.30304 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798489575 | Objekt | 101045x2x598xxxxxx0 | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.5 m; Výška: 0.2 m
152041x1x907xxxxxx0 | Půdorys 1.NP | m | 0.907 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/906.9000/100.0000/100.0000/2/906.9000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/906.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 907 | DN100 | 100 | 100 | 0.000 | 0.907 m | PO.03.30305 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798489610 | Objekt | 152041x1x907xxxxxx0
152062x2x185xxxxxx0 | Půdorys 1.NP | m | 0.185 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/184.8204/200.0000/200.0000/2/184.8204/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/184.82/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 185 | DN200 | 200 | 200 | 0.000 | 0.185 m | PO.03.30306 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798489625 | Objekt | 152062x2x185xxxxxx0
152062x2x957xxxxxx0 | Půdorys 1.NP | m | 0.957 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/957.3000/200.0000/200.0000/2/957.3000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/957.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 957 | DN200 | 200 | 200 | 0.000 | 0.957 m | PO.03.30307 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798489640 | Objekt | 152062x2x957xxxxxx0
152041x1x732xxxxxx0 | Půdorys 1.NP | m | 0.732 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/731.6000/100.0000/100.0000/2/731.6000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/731.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 732 | DN100 | 100 | 100 | 0.000 | 0.732 m | PO.03.30308 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798489681 | Objekt | 152041x1x732xxxxxx0
152041x1x926xxxxxx0 | Půdorys 1.NP | m | 0.926 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/926.0000/100.0000/100.0000/2/926.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/926.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | 926 | DN100 | 100 | 100 | 0.000 | 0.926 m | PO.03.30309 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798489691 | Objekt | 152041x1x926xxxxxx0
15204160160341xxxxxx0 | Půdorys 1.NP | m | 0.341 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/341.0000/160.0000/160.0000/2/341.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/341.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 341 | DN160 | 160 | 160 | 0.000 | 0.341 m | PO.03.30310 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798489696 | Objekt | 15204160160341xxxxxx0
152041x1x755xxxxxx0 | Půdorys 1.NP | m | 0.755 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/755.3000/100.0000/100.0000/2/755.3000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/755.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | 755 | DN100 | 100 | 100 | 0.000 | 0.755 m | PO.03.30311 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798489721 | Objekt | 152041x1x755xxxxxx0
101044502x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 450x200 | 450 | 200 | 0.000 | 1.950 m2 | PO.03.30312 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798489736 | Objekt | 101044502x15xxxxxxx0 | NEMSOK - K_POSITION: L.17; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.45 m; Výška: 0.2 m
101044502x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 450x200 | 450 | 200 | 0.000 | 1.950 m2 | PO.03.30313 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798489751 | Objekt | 101044502x15xxxxxxx0 | NEMSOK - K_POSITION: L.18; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.45 m; Výška: 0.2 m
