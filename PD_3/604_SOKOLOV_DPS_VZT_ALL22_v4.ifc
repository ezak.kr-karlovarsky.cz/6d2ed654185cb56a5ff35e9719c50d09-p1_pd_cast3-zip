Properties of the parts of a building model (IFC2X3), part 23 of 51

# IfcFlowFitting (2887)
Name | In | Jednotka | Délka (m) | Označení | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_DIM | L_BES_DIM_A2 | L_BES_DIM_B2 | L_BES_DIM_A | K_VOLSTROM | K_MLH_GOST = K_MLD_GOST | K_LISTVALUE | Kód prvku | Třída reakce na oheň | Allright_Stavebni_dil_ID | Název_objektu | K_EBT_BOX_WC | Plocha | L_BES_LAENGE | K_INTERNAL_ISO | Tloušťka (m) | Součinitel tepelné vodivost
701043554x125125036031502xx32501 | Půdorys 1.NP | m2 | 0.325 | 701043554x125125036031502xx32501 | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/0/355.0000/355.0000/200.0000/1/325.0000/22.5000/0/0/0/0/1.0000/400.0000/200.0000/1/162.5000/322.5000/0/90.0/0/0/125.0000/125.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/355.00/400.00/125.00/125.00/0/45.00/0/0/200.00/0/0/0/325.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 355x200 | 400 | 200 | 355 | 0.000 | 0 | 1.000 m2 | TA.03.30173 | A1 | 6782Obj0798485233 | Objekt | 325.000/637.500/120.000/0.000/-197.500/-120.000/0.000/0.000/0.000/1.000 |  | 325 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.355 m; Výška: 0.2 m
4110435535550503552x0281-x-16510 | Půdorys 1.NP | m2 | 0.281 | 4110435535550503552x0281-x-16510 | UEBERGANG ASYM. | 20 | 41 | 2/0/0/0/180.0/0/0/1.0000/355.0000/355.0000/1/280.0000/0/-77.5000/0/0/0/0/355.0000/200.0000/1/ | 41/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/355.00/355.00/50.00/50.00/355.00/200.00/0/280.00/0/0/-155.00/0/41.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 355x355 | 355 | 200 | 355 | 0.000 | 0 | 1.000 m2 | TA.03.30189 | A1 | 6782Obj0798486518 | Objekt | 230.000/197.500/197.500/0.000/-197.500/-197.500/0.000/0.000/0.000/1.000 |  | 280 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.355 m; Výška: 0.355 m
201044x4x050502x1x45xxxx | Půdorys 1.NP | m2 | 0 | 201044x4x050502x1x45xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/0/400.0000/400.0000/200.0000/1/297.4874/123.2233/0/45.0/0/0/1.0000/400.0000/200.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/400.00/0/50.00/50.00/200.00/100.00/45.00/0/1.00/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x200 | 400 | 200 | 400 | 0.000 | 0 | 1.000 m2 | TA.03.30224 | A1 | 6782Obj0798487616 | Objekt | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.4 m; Výška: 0.2 m
201044x4x050502x1x45xxxx | Půdorys 1.NP | m2 | 0 | 201044x4x050502x1x45xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/180.0/400.0000/400.0000/200.0000/1/297.4874/123.2233/0/45.0/0/180.0/1.0000/400.0000/200.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/400.00/0/50.00/50.00/200.00/100.00/45.00/180.00/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x200 | 400 | 200 | 400 | 0.000 | 0 | 1.000 m2 | TA.03.30225 | A1 | 6782Obj0798487661 | Objekt | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.4 m; Výška: 0.2 m
701044x45016016x5x02xx36x1x1x90 | Půdorys 1.NP | m2 | 0.36 | 701044x45016016x5x02xx36x1x1x90 | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/180.0/400.0000/400.0000/200.0000/1/360.0000/25.0000/0/0/0/180.0/160.0000/450.0000/200.0000/1/180.0000/350.0000/0/90.0/0/180.0/160.0000/160.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/450.00/160.00/160.00/0/50.00/0/0/200.00/0/0/180.00/360.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x200 | 450 | 200 | 400 | 0.000 | 0 | 1.000 m2 | TA.03.30013 | A1 | 6782Obj0798479255 | Objekt |  |  | 360 | NEMSOK - K_POSITION: L.28; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.4 m; Výška: 0.2 m
701044x4502x2x05x02xx4x01x1x90 | Půdorys 1.NP | m2 | 0.4 | 701044x4502x2x05x02xx4x01x1x90 | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/180.0/400.0000/400.0000/200.0000/1/400.0000/25.0000/0/0/0/180.0/1.0000/450.0000/200.0000/1/200.0000/350.0000/0/90.0/0/180.0/200.0000/200.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/450.00/200.00/200.00/0/50.00/0/0/200.00/0/0/180.00/400.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x200 | 450 | 200 | 400 | 0.000 | 0 | 1.000 m2 | TA.03.30092 | A1 | 6782Obj0798479579 | Objekt |  |  | 400 | NEMSOK - K_POSITION: L.44; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.4 m; Výška: 0.2 m
701044x45016016x5x02xx36x1x1x90 | Půdorys 1.NP | m2 | 0.36 | 701044x45016016x5x02xx36x1x1x90 | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/180.0/400.0000/400.0000/200.0000/1/360.0000/25.0000/0/0/0/180.0/160.0000/450.0000/200.0000/1/180.0000/350.0000/0/90.0/0/180.0/160.0000/160.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/450.00/160.00/160.00/0/50.00/0/0/200.00/0/0/180.00/360.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x200 | 450 | 200 | 400 | 0.000 | 0 | 1.000 m2 | TA.03.30110 | A1 | 6782Obj0798479649 | Objekt |  |  | 360 | NEMSOK - K_POSITION: L.105; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.4 m; Výška: 0.2 m
701044501254504505050375502xx75x | Půdorys 1.NP | m2 | 0.75 | 701044501254504505050375502xx75x | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/0/450.0000/450.0000/200.0000/1/750.0000/-162.5000/0/0/0/0/160.0000/125.0000/200.0000/1/375.0000/375.0000/0/90.0/0/0/450.0000/450.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/125.00/450.00/450.00/50.00/50.00/375.00/50.00/200.00/0/0/0/750.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 125 | 200 | 450 | 0.000 | 0 | 1.590 m2 | TA.03.30128 | A1 | 6782Obj0798479716 | Objekt |  |  | 750 | NEMSOK - K_POSITION: L.120; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.980 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.45 m; Výška: 0.2 m
701044504501x1xxx2xx3x01x1x90 | Půdorys 1.NP | m2 | 0.3 | 701044504501x1xxx2xx3x01x1x90 | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/180.0/450.0000/450.0000/200.0000/1/300.0000/0/0/0/0/180.0/125.0000/450.0000/200.0000/1/150.0000/325.0000/0/90.0/0/180.0/100.0000/100.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/450.00/100.00/100.00/0/0/0/0/200.00/0/0/180.00/300.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.000 m2 | TA.03.30094 | A1 | 6782Obj0798479600 | Objekt |  |  | 300 | NEMSOK - K_POSITION: L.63; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.45 m; Výška: 0.2 m
701044504501x1xxx2xx3x01x1x90 | Půdorys 1.NP | m2 | 0.3 | 701044504501x1xxx2xx3x01x1x90 | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/180.0/450.0000/450.0000/200.0000/1/300.0000/0/0/0/0/180.0/125.0000/450.0000/200.0000/1/150.0000/325.0000/0/90.0/0/180.0/100.0000/100.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/450.00/100.00/100.00/0/0/0/0/200.00/0/0/180.00/300.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.000 m2 | TA.03.30108 | A1 | 6782Obj0798479641 | Objekt |  |  | 300 | NEMSOK - K_POSITION: L.63; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.45 m; Výška: 0.2 m
201052x2x050504501x45xxxx | Půdorys 1.NP | m2 | 0 | 201052x2x050504501x45xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/270.0/450.0000/450.0000/200.0000/1/226.7767/93.9340/0/45.0/0/270.0/1.0000/450.0000/200.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/0/50.00/50.00/450.00/100.00/45.00/270.00/1.00/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.120 m2 | TA.03.30132 | A1 | 6782Obj0798479726 | Objekt | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.120 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.45 m; Výška: 0.2 m
201052x2x050504501x45xxxx | Půdorys 1.NP | m2 | 0 | 201052x2x050504501x45xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/270.0/450.0000/450.0000/200.0000/1/226.7767/93.9340/0/45.0/0/270.0/1.0000/450.0000/200.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/0/50.00/50.00/450.00/100.00/45.00/270.00/1.00/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.120 m2 | TA.03.30133 | A1 | 6782Obj0798479728 | Objekt | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.120 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.45 m; Výška: 0.2 m
7010445045015015xx02xx35x1x1x90 | Půdorys 1.NP | m2 | 0.35 | 7010445045015015xx02xx35x1x1x90 | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/0/450.0000/450.0000/200.0000/1/360.0000/0/0/0/0/180.0/1.0000/450.0000/200.0000/1/180.0000/325.0000/0/90.0/0/180.0/160.0000/160.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/450.00/160.00/160.00/0/0/0/0/200.00/0/0/0/360.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.000 m2 | TA.03.30226 | A1 | 6782Obj0798487833 | Objekt | 325.000/325.000/120.000/0.000/-245.000/-120.000/0.000/0.000/0.000/1.000 |  | 360 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.45 m; Výška: 0.2 m
2010445045x50502x1x902xxxx0 | Půdorys 1.NP | m2 | 0 | 2010445045x50502x1x902xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/0/450.0000/450.0000/200.0000/1/325.0000/325.0000/0/90.0/0/180.0/1.0000/450.0000/200.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/450.00/0/50.00/50.00/200.00/50.00/90.00/0/1.00/200.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.150 m2 | TA.03.30240 | A1 | 6782Obj0798488099 | Objekt | 620.000/375.000/120.000/0.000/-245.000/-120.000/0.000/0.000/0.000/1.000 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.540 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.45 m; Výška: 0.2 m
2010445045x50502x1x45xxxx | Půdorys 1.NP | m2 | 0 | 2010445045x50502x1x45xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/0/450.0000/450.0000/200.0000/1/315.1650/130.5456/0/45.0/0/0/1.0000/450.0000/200.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/450.00/0/50.00/50.00/200.00/100.00/45.00/0/1.00/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.000 m2 | TA.03.30245 | A1 | 6782Obj0798489248 | Objekt | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.45 m; Výška: 0.2 m
2010445045x50502x1x45xxxx | Půdorys 1.NP | m2 | 0 | 2010445045x50502x1x45xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/180.0/450.0000/450.0000/200.0000/1/315.1650/130.5456/0/45.0/0/180.0/1.0000/450.0000/200.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/450.00/0/50.00/50.00/200.00/100.00/45.00/180.00/1.00/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.000 m2 | TA.03.30246 | A1 | 6782Obj0798489308 | Objekt | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.45 m; Výška: 0.2 m
201042x2x050504501x47xxxx | Půdorys 1.NP | m2 | 0 | 201042x2x050504501x47xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/270.0/450.0000/450.0000/200.0000/1/230.1961/99.8534/0/46.9/0/270.0/1.0000/450.0000/200.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/0/50.00/50.00/450.00/100.00/46.90/270.00/1.00/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.120 m2 | TA.03.30247 | A1 | 6782Obj0798489390 | Objekt | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.45 m; Výška: 0.2 m
201042x2x050504501x47xxxx | Půdorys 1.NP | m2 | 0 | 201042x2x050504501x47xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/270.0/450.0000/450.0000/200.0000/1/230.1961/99.8534/0/46.9/0/270.0/1.0000/450.0000/200.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/0/50.00/50.00/450.00/100.00/46.90/270.00/1.00/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.120 m2 | TA.03.30248 | A1 | 6782Obj0798489394 | Objekt | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.45 m; Výška: 0.2 m
201042x2x050504501x3xxxx0 | Půdorys 1.NP | m2 | 0 | 201042x2x050504501x3xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/270.0/450.0000/450.0000/200.0000/1/193.3013/51.7949/0/30.0/0/270.0/1.0000/450.0000/200.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/0/50.00/50.00/450.00/100.00/30.00/270.00/1.00/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.090 m2 | TA.03.30253 | A1 | 6782Obj0798489455 | Objekt | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.45 m; Výška: 0.2 m
201042x2x050504501x3xxxx0 | Půdorys 1.NP | m2 | 0 | 201042x2x050504501x3xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/270.0/450.0000/450.0000/200.0000/1/193.3013/51.7949/0/30.0/0/270.0/1.0000/450.0000/200.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/0/50.00/50.00/450.00/100.00/30.00/270.00/1.00/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 450 | 200 | 450 | 0.000 | 0 | 1.090 m2 | TA.03.30254 | A1 | 6782Obj0798489485 | Objekt | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.45 m; Výška: 0.2 m
701044505x2x2x05x02xx4x01x1x90 | Půdorys 1.NP | m2 | 0.4 | 701044505x2x2x05x02xx4x01x1x90 | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/180.0/450.0000/450.0000/200.0000/1/400.0000/25.0000/0/0/0/180.0/1.0000/500.0000/200.0000/1/200.0000/375.0000/0/90.0/0/180.0/200.0000/200.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/500.00/200.00/200.00/0/50.00/0/0/200.00/0/0/180.00/400.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x200 | 500 | 200 | 450 | 0.000 | 0 | 1.000 m2 | TA.03.30093 | A1 | 6782Obj0798479583 | Objekt |  |  | 400 | NEMSOK - K_POSITION: L.51; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.45 m; Výška: 0.2 m
201045x5x050502x1x902xxxx0 | Půdorys 1.NP | m2 | 0 | 201045x5x050502x1x902xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/0/500.0000/500.0000/200.0000/1/400.0000/400.0000/0/90.0/0/0/200.0000/500.0000/200.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/500.00/0/50.00/50.00/200.00/100.00/90.00/0/1.00/200.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 500x200 | 500 | 200 | 500 | 0.000 | 0 | 1.460 m2 | TA.03.30120 | A1 | 6782Obj0798479681 | Objekt | NEMSOK - K_POSITION: L.54; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.900 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.5 m; Výška: 0.2 m
701045x5x125125xx2xx32501x1x90 | Půdorys 1.NP | m2 | 0.325 | 701045x5x125125xx2xx32501x1x90 | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/180.0/500.0000/500.0000/200.0000/1/325.0000/0/0/0/0/180.0/1.0000/500.0000/200.0000/1/162.5000/350.0000/0/90.0/0/180.0/125.0000/125.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/500.00/125.00/125.00/0/0/0/0/200.00/0/0/180.00/325.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 500x200 | 500 | 200 | 500 | 0.000 | 0 | 1.000 m2 | TA.03.30121 | A1 | 6782Obj0798479683 | Objekt |  |  | 325 | NEMSOK - K_POSITION: L.58; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.5 m; Výška: 0.2 m; K_DATANORM: """"""";"""""""
201042x2x050505x1x3xxxx0 | Půdorys 1.NP | m2 | 0 | 201042x2x050505x1x3xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/270.0/500.0000/500.0000/200.0000/1/193.3013/51.7949/0/30.0/0/270.0/1.0000/500.0000/200.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/0/50.00/50.00/500.00/100.00/30.00/270.00/1.00/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 500x200 | 500 | 200 | 500 | 0.000 | 0 | 1.100 m2 | TA.03.30187 | A1 | 6782Obj0798486451 | Objekt | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.100 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.5 m; Výška: 0.2 m
201042x2x050505x1x3xxxx0 | Půdorys 1.NP | m2 | 0 | 201042x2x050505x1x3xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/270.0/500.0000/500.0000/200.0000/1/193.3013/51.7949/0/30.0/0/270.0/1.0000/500.0000/200.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/0/50.00/50.00/500.00/100.00/30.00/270.00/1.00/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 500x200 | 500 | 200 | 500 | 0.000 | 0 | 1.100 m2 | TA.03.30188 | A1 | 6782Obj0798486481 | Objekt | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.100 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.5 m; Výška: 0.2 m
201042x2x050505x1x15xxxx | Půdorys 1.NP | m2 | 0 | 201042x2x050505x1x15xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/90.0/500.0000/500.0000/200.0000/1/150.0601/19.7558/0/15.0/0/90.0/1.0000/500.0000/200.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/0/50.00/50.00/500.00/100.00/15.00/90.00/1.00/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 500x200 | 500 | 200 | 500 | 0.000 | 0 | 1.080 m2 | TA.03.30249 | A1 | 6782Obj0798489398 | Objekt | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.5 m; Výška: 0.2 m
201042x2x050505x1x15xxxx | Půdorys 1.NP | m2 | 0 | 201042x2x050505x1x15xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/90.0/500.0000/500.0000/200.0000/1/150.0601/19.7558/0/15.0/0/90.0/1.0000/500.0000/200.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/0/50.00/50.00/500.00/100.00/15.00/90.00/1.00/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 500x200 | 500 | 200 | 500 | 0.000 | 0 | 1.080 m2 | TA.03.30250 | A1 | 6782Obj0798489402 | Objekt | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.5 m; Výška: 0.2 m
201042x2x050505x1x45xxxx | Půdorys 1.NP | m2 | 0 | 201042x2x050505x1x45xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/90.0/500.0000/500.0000/200.0000/1/226.7767/93.9340/0/45.0/0/90.0/1.0000/500.0000/200.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/0/50.00/50.00/500.00/100.00/45.00/90.00/1.00/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 500x200 | 500 | 200 | 500 | 0.000 | 0 | 1.130 m2 | TA.03.30251 | A1 | 6782Obj0798489406 | Objekt | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.5 m; Výška: 0.2 m
201042x2x050505x1x45xxxx | Půdorys 1.NP | m2 | 0 | 201042x2x050505x1x45xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/90.0/500.0000/500.0000/200.0000/1/226.7767/93.9340/0/45.0/0/90.0/1.0000/500.0000/200.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/0/50.00/50.00/500.00/100.00/45.00/90.00/1.00/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 500x200 | 500 | 200 | 500 | 0.000 | 0 | 1.130 m2 | TA.03.30252 | A1 | 6782Obj0798489410 | Objekt | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.5 m; Výška: 0.2 m
411045x5x50503552x0369x-15503xx | Půdorys 1.NP | m2 | 0.369 | 411045x5x50503552x0369x-15503xx | UEBERGANG ASYM. | 20 | 41 | 2/0/0/0/180.0/0/0/1.0000/500.0000/355.0000/1/300.0000/0/77.5000/0/0/0/0/500.0000/200.0000/1/ | 41/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/500.00/50.00/50.00/355.00/200.00/0/300.00/0/0/0/-155.00/38.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 500x355 | 500 | 200 | 500 | 0.000 | 0 | 1.000 m2 | TA.03.30186 | A1 | 6782Obj0798486421 | Objekt | 300.000/270.000/197.500/0.000/-270.000/-197.500/0.000/0.000/0.000/1.000 |  | 300 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.5 m; Výška: 0.355 m
7010635545056056x95x355x76x1x1x9 | Půdorys 1.NP | m2 | 0.76 | 7010635545056056x95x355x76x1x1x9 | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/0/560.0000/560.0000/355.0000/1/372.5000/-380.0000/0/270.0/0/0/1.0000/355.0000/355.0000/1/325.0000/380.0000/0/90.0/0/0/450.0000/450.0000/355.0000/1/ | 70/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/355.00/450.00/560.00/560.00/0/95.00/0/0/355.00/0/0/0/760.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x355 | 355 | 355 | 560 | 0.000 | 0 | 1.580 m2 | TA.03.30185 | A1 | 6782Obj0798486384 | Objekt |  |  | 760 | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355; K_LISTVALUE_ISO: 1.890 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.56 m; Výška: 0.355 m
4110456045050503552x0369-55-55-1 | Půdorys 1.NP | m2 | 0.369 | 4110456045050503552x0369-55-55-1 | UEBERGANG ASYM. | 20 | 41 | 2/0/0/0/180.0/0/0/1.0000/560.0000/355.0000/1/368.5000/0/77.5000/0/0/0/0/450.0000/200.0000/1/ | 41/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/450.00/50.00/50.00/355.00/200.00/0/368.50/-55.00/-55.00/0/-155.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x355 | 450 | 200 | 560 | 0.000 | 0 | 1.000 m2 | TA.03.30127 | A1 | 6782Obj0798479714 | Objekt | 368.500/300.000/197.500/0.000/-300.000/-197.500/0.000/0.000/0.000/1.000 |  | 369 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.56 m; Výška: 0.355 m
7010456056063063xx0355x83x1x1x90 | Půdorys 1.NP | m2 | 0.83 | 7010456056063063xx0355x83x1x1x90 | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/0/560.0000/560.0000/355.0000/1/830.0000/0/0/0/0/0/1.0000/560.0000/355.0000/1/415.0000/380.0000/0/90.0/0/0/630.0000/630.0000/355.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/630.00/630.00/0/0/0/0/355.00/0/0/0/830.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x355 | 560 | 355 | 560 | 0.000 | 0 | 1.720 m2 | TA.03.30126 | A1 | 6782Obj0798479713 | Objekt |  |  | 830 | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355; K_LISTVALUE_ISO: 2.010 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.56 m; Výška: 0.355 m
20104355355050505601x9056xxxx | Půdorys 1.NP | m2 | 0 | 20104355355050505601x9056xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/270.0/560.0000/560.0000/355.0000/1/327.5000/327.5000/0/90.0/0/90.0/1.0000/560.0000/355.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/355.00/355.00/0/50.00/50.00/560.00/100.00/90.00/270.00/0/560.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x355 | 560 | 355 | 560 | 0.000 | 0 | 1.490 m2 | TA.03.30136 | A1 | 6782Obj0798479765 | Objekt | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355; K_LISTVALUE_ISO: 1.890 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.56 m; Výška: 0.355 m
20104355355050505601x9056xxxx | Půdorys 1.NP | m2 | 0 | 20104355355050505601x9056xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/90.0/560.0000/560.0000/355.0000/1/327.5000/327.5000/0/90.0/0/90.0/1.0000/560.0000/355.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/355.00/355.00/0/50.00/50.00/560.00/100.00/90.00/90.00/0/560.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x355 | 560 | 355 | 560 | 0.000 | 0 | 1.490 m2 | TA.03.30137 | A1 | 6782Obj0798479766 | Objekt | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355; K_LISTVALUE_ISO: 1.890 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.56 m; Výška: 0.355 m
70104630630355355xx2xx55501x1x90 | Půdorys 1.NP | m2 | 0.555 | 70104630630355355xx2xx55501x1x90 | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/0/630.0000/630.0000/200.0000/1/555.0000/-90.0000/0/0/0/0/1.0000/450.0000/200.0000/1/277.5000/415.0000/0/90.0/0/0/355.0000/355.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/630.00/450.00/355.00/355.00/0/0/180.00/0/200.00/0/0/0/555.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 630x200 | 450 | 200 | 630 | 0.000 | 0 | 1.230 m2 | TA.03.30135 | A1 | 6782Obj0798479747 | Objekt | 555.000/415.000/120.000/0.000/-335.000/-120.000/0.000/0.000/0.000/1.000 |  | 555 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.500 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.63 m; Výška: 0.2 m
2010463063x50502x1x902xxxx0 | Půdorys 1.NP | m2 | 0 | 2010463063x50502x1x902xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/0/630.0000/630.0000/200.0000/1/465.0000/465.0000/0/90.0/0/0/1.0000/630.0000/200.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/630.00/630.00/0/50.00/50.00/200.00/100.00/90.00/0/1.00/200.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 630x200 | 630 | 200 | 630 | 0.000 | 0 | 2.070 m2 | TA.03.30134 | A1 | 6782Obj0798479743 | Objekt | NEMSOK - K_POSITION: L.6; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 2.590 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.63 m; Výška: 0.2 m
4110463063050503552x017xx-15566x | Půdorys 1.NP | m2 | 0.17 | 4110463063050503552x017xx-15566x | UEBERGANG ASYM. | 20 | 41 | 2/0/0/0/180.0/0/0/1.0000/630.0000/355.0000/1/170.0000/0/77.5000/0/0/0/0/630.0000/200.0000/1/ | 41/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/630.00/630.00/50.00/50.00/355.00/200.00/0/170.00/0/0/0/-155.00/66.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 630x355 | 630 | 200 | 630 | 0.000 | 0 | 1.000 m2 | TA.03.30239 | A1 | 6782Obj0798488054 | Objekt |  |  | 170 | NEMSOK - K_POSITION: L.56; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.63 m; Výška: 0.355 m
252x1x01x19xxxxxx | Půdorys 1.NP | Stk | 0 | 252x1x01x19xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/270.0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/270.00/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | TA.03.30019 | A1 | 6782Obj0798479282 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 100 mm
252x1x01x19xxxxxx | Půdorys 1.NP | Stk | 0 | 252x1x01x19xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/270.0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/270.00/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | TA.03.30074 | A1 | 6782Obj0798479524 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 100 mm
252x1x01x19xxxxxx | Půdorys 1.NP | Stk | 0 | 252x1x01x19xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/270.0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/270.00/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | TA.03.30075 | A1 | 6782Obj0798479525 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 100 mm
252x1x01x19xxxxxx | Půdorys 1.NP | Stk | 0 | 252x1x01x19xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/180.0/100.0000/100.0000/100.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/180.00/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | TA.03.30084 | A1 | 6782Obj0798479538 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 100 mm
252x1x01x19xxxxxx | Půdorys 1.NP | Stk | 0 | 252x1x01x19xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/270.0/100.0000/100.0000/100.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/270.00/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | TA.03.30096 | A1 | 6782Obj0798479603 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 100 mm
252x1x01x19xxxxxx | Půdorys 1.NP | Stk | 0 | 252x1x01x19xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/270.0/100.0000/100.0000/100.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/270.00/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | TA.03.30114 | A1 | 6782Obj0798479664 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 100 mm
252x1x01x145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1x01x145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/100.0000/100.0000/100.0000/2/70.7107/29.2893/0/45.0/0/90.0/100.0000/100.0000/100.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/90.00/0/100.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | TA.03.30115 | A1 | 6782Obj0798479666 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 100 mm
252x1x01x145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1x01x145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/100.0000/100.0000/100.0000/2/70.7107/29.2893/0/45.0/0/270.0/100.0000/100.0000/100.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/270.00/0/100.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | TA.03.30116 | A1 | 6782Obj0798479668 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 100 mm
252x1x01x19xxxxxx | Půdorys 1.NP | Stk | 0 | 252x1x01x19xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/270.0/100.0000/100.0000/100.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/270.00/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | TA.03.30117 | A1 | 6782Obj0798479675 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 100 mm
252x1x01x19xxxxxx | Půdorys 1.NP | Stk | 0 | 252x1x01x19xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/0/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | TA.03.30142 | A1 | 6782Obj0798479785 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 100 mm
252x1x01x19xxxxxx | Půdorys 1.NP | Stk | 0 | 252x1x01x19xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/0/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | TA.03.30143 | A1 | 6782Obj0798479786 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 100 mm
252x1x01x19xxxxxx | Půdorys 1.NP | Stk | 0 | 252x1x01x19xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/180.0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/180.00/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | TA.03.30144 | A1 | 6782Obj0798479789 | Objekt | 150.000/100.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | NEMSOK - K_POSITION: L.1; Podlaží: Nadzemní podlaží 1.NP; Průměr: 100 mm
252x1x01x19xxxxxx | Půdorys 1.NP | Stk | 0 | 252x1x01x19xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/270.0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/270.00/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | TA.03.30145 | A1 | 6782Obj0798479797 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 100 mm
252x1x01x19xxxxxx | Půdorys 1.NP | Stk | 0 | 252x1x01x19xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/180.0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/180.00/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | TA.03.30146 | A1 | 6782Obj0798479801 | Objekt | 150.000/100.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | NEMSOK - K_POSITION: L.1; Podlaží: Nadzemní podlaží 1.NP; Průměr: 100 mm
252x1x01x19xxxxxx | Půdorys 1.NP | Stk | 0 | 252x1x01x19xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/180.0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/180.00/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | TA.03.30153 | A1 | 6782Obj0798479841 | Objekt | 150.000/100.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | NEMSOK - K_POSITION: L.1; Podlaží: Nadzemní podlaží 1.NP; Průměr: 100 mm
752051x1x1x019x9509xxxx | Půdorys 1.NP | Stk | 0.19 | 752051x1x1x019x9509xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/180.0/100.0000/100.0000/100.0000/2/190.0000/0/0/0/0/180.0/125.0000/100.0000/100.0000/2/95.0000/95.0000/0/90.0/0/180.0/100.0000/100.0000/100.0000/2/ | 75/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/100.00/0/180.00/190.00/0/95.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | TA.03.30202 | A1 | 6782Obj0798487050 | Objekt |  |  | 190 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 100 mm
252x1x01x19xxxxxx | Půdorys 1.NP | Stk | 0 | 252x1x01x19xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/270.0/100.0000/100.0000/100.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/270.00/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | TA.03.30203 | A1 | 6782Obj0798487084 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 100 mm
252x1x01x19xxxxxx | Půdorys 1.NP | Stk | 0 | 252x1x01x19xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/0/100.0000/100.0000/100.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/0/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | TA.03.30210 | A1 | 6782Obj0798487236 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 100 mm
752051x1x1x019x9509xxxx | Půdorys 1.NP | Stk | 0.19 | 752051x1x1x019x9509xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/0/100.0000/100.0000/100.0000/2/190.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/95.0000/95.0000/0/90.0/0/0/100.0000/100.0000/100.0000/2/ | 75/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/100.00/0/0/190.00/0/95.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | TA.03.30211 | A1 | 6782Obj0798487247 | Objekt |  |  | 190 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 100 mm
252x1x01x19xxxxxx | Půdorys 1.NP | Stk | 0 | 252x1x01x19xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/270.0/100.0000/100.0000/100.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/270.00/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | TA.03.30212 | A1 | 6782Obj0798487260 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 100 mm
302041x16x01x16x1x303030303xx | Půdorys 1.NP | Stk | 0.1 | 302041x16x01x16x1x303030303xx | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/100.0000/100.0000/100.0000/2/100.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/160.00/0/0/100.00/160.00/0/100.00/30.00/30.00/30.00/30.00/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 160 | 160 | 100 | 0.000 | 0 | 1.0 | TA.03.30139 | A1 | 6782Obj0798479781 | Objekt |  |  | 100 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
752041251251x019x11x9xxxx | Půdorys 1.NP | Stk | 0.19 | 752041251251x019x11x9xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/190.0000/0/0/0/0/0/1.0000/125.0000/125.0000/2/95.0000/110.0000/0/90.0/0/0/100.0000/100.0000/100.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/100.00/0/0/190.00/0/110.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30018 | A1 | 6782Obj0798479280 | Objekt |  |  | 190 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x1250125145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30020 | A1 | 6782Obj0798479290 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x1250125145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30021 | A1 | 6782Obj0798479292 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x1250125145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30022 | A1 | 6782Obj0798479295 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x1250125145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30023 | A1 | 6782Obj0798479297 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x1250125145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30024 | A1 | 6782Obj0798479299 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x1250125145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30025 | A1 | 6782Obj0798479301 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x1250125145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30026 | A1 | 6782Obj0798479303 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x1250125145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30027 | A1 | 6782Obj0798479305 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x1250125145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30028 | A1 | 6782Obj0798479307 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x1250125145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30029 | A1 | 6782Obj0798479309 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x1250125145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30048 | A1 | 6782Obj0798479396 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x1250125145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30049 | A1 | 6782Obj0798479398 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x1250125115xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30050 | A1 | 6782Obj0798479404 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x1250125115xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30051 | A1 | 6782Obj0798479406 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x125012519xxxxxx | Půdorys 1.NP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/315.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/315.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/315.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30054 | A1 | 6782Obj0798479434 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x1250125145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30055 | A1 | 6782Obj0798479436 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x125012519xxxxxx | Půdorys 1.NP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/315.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/315.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/315.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30056 | A1 | 6782Obj0798479437 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x1250125145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30057 | A1 | 6782Obj0798479439 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x125012519xxxxxx | Půdorys 1.NP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/315.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/315.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/315.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30058 | A1 | 6782Obj0798479440 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x1250125145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30059 | A1 | 6782Obj0798479442 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x125012519xxxxxx | Půdorys 1.NP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/315.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/315.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/315.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30060 | A1 | 6782Obj0798479443 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x1250125145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30061 | A1 | 6782Obj0798479445 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x125012519xxxxxx | Půdorys 1.NP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/315.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/315.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/315.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30062 | A1 | 6782Obj0798479446 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
