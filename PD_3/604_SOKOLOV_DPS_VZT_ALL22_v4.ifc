Properties of the parts of a building model (IFC2X3), part 20 of 51

# IfcFlowFitting (2887)
Name | In | Jednotka | Délka (m) | Označení | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_DIM | L_BES_DIM_A2 | L_BES_DIM_B2 | L_BES_DIM_A | K_VOLSTROM | K_MLH_GOST = K_MLD_GOST | K_LISTVALUE | Kód prvku | Třída reakce na oheň | Allright_Stavebni_dil_ID | Název_objektu | K_EBT_BOX_WC | Plocha | L_BES_LAENGE | K_INTERNAL_ISO | Tloušťka (m) | Součinitel tepelné vodivost
1010586076065xxxxxx0 | Půdorys 1.PP | Kus | 0.1 | 1010586076065xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/860.0000/760.0000/1/100.0000/0/0/0/0/0/1.0000/860.0000/760.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/860.00/760.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 30/SB 30/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 860x760 | 860 | 760 | 860 | 0.000 | 0 | 1.000 m2 | IT.02.30204 | A2 | 6774Obj0000053168 | Objekt | 100.000/450.000/400.000/0.000/-450.000/-400.000/0.000/0.000/0.000/1.000 | 1 | 100 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 760
101058607601xxxxxxx0 | Půdorys 1.PP | Kus | 0.492 | 101058607601xxxxxxx0 | UEBERGANG ASYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/860.0000/760.0000/1/492.3000/0/-46.5000/0/0/0/0/560.0000/400.0000/1/ | 41/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/860.00/560.00/50.00/50.00/760.00/400.00/0/492.30/-150.00/-150.00/-226.50/-133.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 30/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 860x760 | 560 | 400 | 860 | 0.000 | 0 | 1.760 m2 | IT.02.30205 | A2 | 6774Obj0000053190 | Objekt | 492.300/450.000/400.000/0.000/-450.000/-400.000/0.000/0.000/0.000/1.000 | 1.76 | 492 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.7; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 760
4110586056050507604x0492-150-150 | Půdorys 1.PP | Kus | 0.06 | 4110586056050507604x0492-150-150 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/60.0000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30206 | A2 | 6774Obj0000053204 | Objekt | 60.000/300.000/220.000/0.000/-300.000/-220.000/0.000/0.000/0.000/1.000 | 1 | 60 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.18; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
101055604x6xxxxxxx | Půdorys 1.PP | Kus | 0 | 101055604x6xxxxxxx | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/90.0/560.0000/560.0000/400.0000/1/350.0000/350.0000/0/90.0/0/90.0/0/560.0000/400.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/400.00/0/50.00/50.00/560.00/100.00/90.00/90.00/0/560.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 1.700 m2 | IT.02.30207 | A2 | 6774Obj0000053286 | Objekt | 570.000/350.000/300.000/0.000/-220.000/-300.000/0.000/0.000/0.000/1.000 | 1.7 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
macro | Půdorys 1.PP | Kus | 1.55 | macro | Schalldämpfer | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/-1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/560.00/400.00/1550.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 |  | 560x400 | 1 | 1 | 1 | 0.000 | 0 |  | IT.02.30217 | A2 | 6774Obj0000053640 | Objekt | 55221.977/5447.635/-1305.000/54661.977/3897.635/-1705.000/0.000/0.000/0.000/1.000 | 0 | 1550 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1; K_LISTVALUE_ISO: 2.980 m2; K_DWGNAME: ${PROD}l\einbauteile\schalldaempfer\; K_DP_EBT: 0.00; K_DATE: 2023/01/18; N_FREI_68: Blech ST37 verzinkt
1x01045604x155xxxxxxx | Půdorys 1.PP | Kus | 1.142 | 1x01045604x155xxxxxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/1142.4000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/1142.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 2.190 m2 | IT.02.30218 | A2 | 6774Obj0000053654 | Objekt | 1142.400/300.000/220.000/0.000/-300.000/-220.000/0.000/0.000/0.000/1.000 | 2.19 | 1142 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
15204160160667xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15204160160667xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/0/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.02.30219 | A2 | 6774Obj0000053684 | Objekt | 240.000/160.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16019xxxxxx | Půdorys 1.PP | Kus | 3.989 | 252x16x16019xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/3989.0000/160.0000/160.0000/2/3989.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/3989.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 3.989 m | IT.02.30220 | A2 | 6774Obj0000053687 | Objekt | 3989.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 3.989 | 3989 | __ISO | 0.04 | 0,041 W/m.K
 | Půdorys 1.PP | Kus | 0.007 |  | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/7.0720/160.0000/160.0000/2/7.0720/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/7.07/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.007 m | IT.02.30221 | A2 | 6774Obj0000053690 | Objekt | 7.072/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.007 | 7 | __ISO | 0.04 | 0,041 W/m.K
152041601607xxxxxx0 | Půdorys 1.PP | Kus | 0 | 152041601607xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/270.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.02.30222 | A2 | 6774Obj0000053693 | Objekt | 169.706/103.431/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x160145xxxxx0 | Půdorys 1.PP | Kus | 0.235 | 252x16x160145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/235.1472/160.0000/160.0000/2/235.1472/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/235.15/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.235 m | IT.02.30223 | A2 | 6774Obj0000053696 | Objekt | 235.147/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.235 | 235 | __ISO | 0.04 | 0,041 W/m.K
15204160160235xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15204160160235xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.02.30224 | A2 | 6774Obj0000053699 | Objekt | 169.706/103.431/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x160145xxxxx0 | Půdorys 1.PP | Kus | 0.007 | 252x16x160145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/6.9986/160.0000/160.0000/2/6.9986/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/7.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.007 m | IT.02.30225 | A2 | 6774Obj0000053702 | Objekt | 6.999/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.007 | 7 | __ISO | 0.04 | 0,041 W/m.K
152041601607xxxxxx0 | Půdorys 1.PP | Kus | 0.667 | 152041601607xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/666.8068/160.0000/160.0000/2/666.8068/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/666.81/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.667 m | IT.02.30226 | A2 | 6774Obj0000053705 | Objekt | 666.807/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.667 | 667 | __ISO | 0.04 | 0,041 W/m.K
15204160160667xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15204160160667xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.02.30227 | A2 | 6774Obj0000053708 | Objekt | 169.706/103.431/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x160145xxxxx0 | Půdorys 1.PP | Kus | 0.096 | 252x16x160145xxxxx0 | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/2/96.0000/0/0.0439/0/0/0/160.0000/160.0000/160.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/0/160.00/160.00/0/96.00/0/0/0.04/-0.04/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.02.30228 | A2 | 6774Obj0000053711 | Objekt | 96.000/80.000/80.044/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 96 | __ISO | 0.04 | 0,041 W/m.K
3020416016x016016x96x0-03xx | Půdorys 1.PP | Kus | 0.14 | 3020416016x016016x96x0-03xx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/139.8104/160.0000/160.0000/2/139.8104/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/139.81/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.140 m | IT.02.30229 | A2 | 6774Obj0000053714 | Objekt | 139.810/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.14 | 140 | __ISO | 0.04 | 0,041 W/m.K
1520416016014xxxxxxx | Půdorys 1.PP | Kus | 0 | 1520416016014xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/270.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.02.30230 | A2 | 6774Obj0000053717 | Objekt | 169.706/103.431/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x160145xxxxx0 | Půdorys 1.PP | Kus | 0.667 | 252x16x160145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/666.8069/160.0000/160.0000/2/666.8069/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/666.81/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.667 m | IT.02.30231 | A2 | 6774Obj0000053720 | Objekt | 666.807/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.667 | 667 | __ISO | 0.04 | 0,041 W/m.K
 | Půdorys 1.PP | Kus | 4.288 |  | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/4288.4000/125.0000/125.0000/2/4288.4000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/4288.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 4.288 m | IT.02.30232 | A2 | 6774Obj0000053723 | Objekt | 4288.400/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 4.288 | 4288 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
macro | Půdorys 1.PP | Kus | 0.3 | macro | ZG Klappe | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/300.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.02.30233 | A2 | 6774Obj0000053737 | Objekt | 61516.604/7737.500/-637.500/61216.604/7612.500/-762.500/0.000/0.000/0.000/1.000 | 1 | 300 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\zentralgeräte\zg klappen\; K_DP_EBT: 0.00; K_DATE: 2023/01/19; N_FREI_68: SPIRO POTRUBÍ
 | Půdorys 1.PP | Kus | 0.168 |  | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/168.4000/125.0000/125.0000/2/168.4000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/168.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.168 m | IT.02.30234 | A2 | 6774Obj0000053740 | Objekt | 168.400/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.168 | 168 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
macro | Půdorys 1.PP | Kus | 0.3 | macro | ZG Klappe | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/300.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.02.30235 | A2 | 6774Obj0000053754 | Objekt | 56555.662/12465.684/-637.521/56430.662/12165.684/-762.521/0.000/0.000/0.000/1.000 | 1 | 300 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\zentralgeräte\zg klappen\; K_DP_EBT: 0.00; K_DATE: 2023/01/19; N_FREI_68: SPIRO POTRUBÍ
 | Půdorys 1.PP | Kus | 0.116 |  | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/116.4000/125.0000/125.0000/2/116.4000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/116.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.116 m | IT.02.30236 | A2 | 6774Obj0000053757 | Objekt | 116.400/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.116 | 116 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
macro | Půdorys 1.PP | Kus | 0.3 | macro | ZG Klappe | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/300.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.02.30237 | A2 | 6774Obj0000053771 | Objekt | 56857.349/12474.823/-637.500/56732.349/12174.823/-762.500/0.000/0.000/0.000/1.000 | 1 | 300 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\zentralgeräte\zg klappen\; K_DP_EBT: 0.00; K_DATE: 2023/01/19; N_FREI_68: SPIRO POTRUBÍ
 | Půdorys 1.PP | Kus | 0.397 |  | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/397.4000/125.0000/125.0000/2/397.4000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/397.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.397 m | IT.02.30238 | A2 | 6774Obj0000053774 | Objekt | 397.400/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.397 | 397 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
macro | Půdorys 1.PP | Kus | 0.3 | macro | ZG Klappe | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/300.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.02.30239 | A2 | 6774Obj0000053788 | Objekt | 56857.349/10625.023/-637.500/56732.349/10325.023/-762.500/0.000/0.000/0.000/1.000 | 1 | 300 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\zentralgeräte\zg klappen\; K_DP_EBT: 0.00; K_DATE: 2023/01/19; N_FREI_68: SPIRO POTRUBÍ
 | Půdorys 1.PP | Kus | 1.21 |  | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1209.5000/125.0000/125.0000/2/1209.5000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/1209.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.210 m | IT.02.30240 | A2 | 6774Obj0000053791 | Konstrukce v aktuální hladině | 1209.500/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1.21 | 1210 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
macro | Půdorys 1.PP | Kus | 0.3 | macro | ZG Klappe | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/-1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/300.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.02.30241 | A2 | 6774Obj0000053805 | Objekt | 52233.594/12890.500/-657.500/52108.594/12590.500/-782.500/0.000/0.000/0.000/1.000 | 1 | 300 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\zentralgeräte\zg klappen\; K_DP_EBT: 0.00; K_DATE: 2023/01/19; N_FREI_68: SPIRO POTRUBÍ
 | Půdorys 1.PP | Kus | 0.48 |  | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/479.7000/125.0000/125.0000/2/479.7000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/479.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.480 m | IT.02.30242 | A2 | 6774Obj0000053808 | Konstrukce v aktuální hladině | 479.700/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.48 | 480 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
macro | Půdorys 1.PP | Kus | 0.3 | macro | ZG Klappe | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/300.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.02.30243 | A2 | 6774Obj0000053822 | Objekt | 48168.768/13415.816/-637.500/48043.768/13115.816/-762.500/0.000/0.000/0.000/1.000 | 1 | 300 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\zentralgeräte\zg klappen\; K_DP_EBT: 0.00; K_DATE: 2023/01/19; N_FREI_68: SPIRO POTRUBÍ
3020431525x031525x116-33-33-33-3 | Půdorys 1.NP | Stk | 0.116 | 3020431525x031525x116-33-33-33-3 | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/1.0000/315.0000/315.0000/2/116.3000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/250.00/0/0/315.00/250.00/0/116.30/-32.50/-32.50/-32.50/-32.50/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/70.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN315 | 250 | 250 | 315 | 0.000 | 0 | 1.0 | TA.03.30282 | A | 6782Obj0798478895 | Potrubní tvarovka |  |  | 116 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN315
30204250315x2503150156333333333x | Půdorys 1.NP | Stk | 0.156 | 30204250315x2503150156333333333x | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/1.0000/250.0000/250.0000/2/156.3000/0/0/0/0/0/315.0000/315.0000/315.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/315.00/0/0/250.00/315.00/0/156.30/32.50/32.50/32.50/32.50/30.00/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN250 | 315 | 315 | 250 | 0.000 | 0 | 1.0 | TA.03.30283 | A | 6782Obj0798478896 | Potrubní tvarovka |  |  | 156 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN250
30204250315x2503150156333333333x | Půdorys 1.NP | Stk | 0.156 | 30204250315x2503150156333333333x | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/1.0000/250.0000/250.0000/2/156.3000/0/0/0/0/0/315.0000/315.0000/315.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/315.00/0/0/250.00/315.00/0/156.30/32.50/32.50/32.50/32.50/30.00/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN250 | 315 | 315 | 250 | 0.000 | 0 | 1.0 | TA.03.30284 | A | 6782Obj0798478897 | Potrubní tvarovka |  |  | 156 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN250
252x25x25019xxxxxx | Půdorys 1.NP | Stk | 0 | 252x25x25019xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/250.0000/250.0000/250.0000/2/250.0000/250.0000/0/90.0/0/0/250.0000/250.0000/250.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/0/0/250.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Mineralwolle/100.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | TA.03.30285 | A | 6782Obj0798478899 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN250
252x25x25019xxxxxx | Půdorys 1.NP | Stk | 0 | 252x25x25019xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/250.0000/250.0000/250.0000/2/250.0000/250.0000/0/90.0/0/180.0/250.0000/250.0000/250.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/180.00/0/250.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Mineralwolle/100.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | TA.03.30286 | A | 6782Obj0798478902 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN250
252x25x25019xxxxxx | Půdorys 1.NP | Stk | 0 | 252x25x25019xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/250.0000/250.0000/250.0000/2/250.0000/250.0000/0/90.0/0/0/250.0000/250.0000/250.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/0/0/250.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Mineralwolle/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | TA.03.30287 | A | 6782Obj0798478906 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN250
252x25x25019xxxxxx | Půdorys 1.NP | Stk | 0 | 252x25x25019xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/250.0000/250.0000/250.0000/2/250.0000/250.0000/0/90.0/0/0/250.0000/250.0000/250.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/0/0/250.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | TA.03.30288 | A | 6782Obj0798478909 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN250
252x25x25019xxxxxx | Půdorys 1.NP | Stk | 0 | 252x25x25019xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/250.0000/250.0000/250.0000/2/250.0000/250.0000/0/90.0/0/0/250.0000/250.0000/250.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/0/0/250.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | TA.03.30289 | A | 6782Obj0798478912 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN250
252x25x25019xxxxxx | Půdorys 1.NP | Stk | 0 | 252x25x25019xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/250.0000/250.0000/250.0000/2/250.0000/250.0000/0/90.0/0/90.0/250.0000/250.0000/250.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/90.00/0/250.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Alu kaschiert/50.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | TA.03.30290 | A | 6782Obj0798478915 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN250
252x25x250145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x25x250145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/250.0000/250.0000/250.0000/2/176.7767/73.2233/0/45.0/0/0/250.0000/250.0000/250.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/0/0/250.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | TA.03.30291 | A | 6782Obj0798478977 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN250
752042502501x019x17x9xxxx | Půdorys 1.NP | Stk | 0.19 | 752042502501x019x17x9xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/0/250.0000/250.0000/250.0000/2/190.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/95.0000/170.0000/0/90.0/0/0/100.0000/100.0000/100.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/190.00/0/170.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | TA.03.30292 | A | 6782Obj0798478979 | Potrubní tvarovka |  |  | 190 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN250
252x25x250145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x25x250145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/250.0000/250.0000/250.0000/2/176.7767/73.2233/0/45.0/0/180.0/250.0000/250.0000/250.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/180.00/0/250.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | TA.03.30293 | A | 6782Obj0798478981 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN250
25204125012519xxxxxx | Půdorys 1.NP | Kus | 0 | 25204125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 |  | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 125 | 125 | 125 | 120.000 |  | 1.0 | TA.03.30294 | A | 6782Obj0798479015 | Potrubní tvarovka | NEMSOK - K_POSITION: L.1; L_BES_DIM_B: 125; Podlaží: Nadzemní podlaží 1.NP; Průměr: DN100
25204125012519xxxxxx | Půdorys 1.NP | Kus | 0 | 25204125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 |  | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 125 | 125 | 125 | 120.000 |  | 1.0 | TA.03.30295 | A | 6782Obj0798479016 | Potrubní tvarovka | NEMSOK - K_POSITION: L.1; L_BES_DIM_B: 125; Podlaží: Nadzemní podlaží 1.NP; Průměr: DN100
25204125012519xxxxxx | Půdorys 1.NP | Kus | 0 | 25204125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 |  | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 125 | 125 | 125 | 120.000 |  | 1.0 | TA.03.30296 | A | 6782Obj0798479017 | Potrubní tvarovka | NEMSOK - K_POSITION: L.1; L_BES_DIM_B: 125; Podlaží: Nadzemní podlaží 1.NP; Průměr: DN100
25204125012519xxxxxx | Půdorys 1.NP | Kus | 0 | 25204125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 |  | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 125 | 125 | 125 | 120.000 |  | 1.0 | TA.03.30297 | A | 6782Obj0798479018 | Potrubní tvarovka | NEMSOK - K_POSITION: L.1; L_BES_DIM_B: 125; Podlaží: Nadzemní podlaží 1.NP; Průměr: DN100
752041601601250215012509xxxx | Půdorys 1.NP | Stk | 0.215 | 752041601601250215012509xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/215.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/107.5000/125.0000/0/90.0/0/0/125.0000/125.0000/125.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/125.00/0/0/215.00/0/125.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | TA.03.30298 | A | 6782Obj0798479030 | Potrubní tvarovka |  |  | 215 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
30204160125x160125078-18-18-18-1 | Půdorys 1.NP | Stk | 0.078 | 30204160125x160125078-18-18-18-1 | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/78.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/0/0/160.00/125.00/0/78.00/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 125 | 125 | 160 | 120.000 | 0 | 1.0 | TA.03.30299 | A | 6782Obj0798479031 | Potrubní tvarovka |  |  | 78 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
252x1250125145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | TA.03.30300 | A | 6782Obj0798479033 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN125
30204160125x160125078-18-18-18-1 | Půdorys 1.NP | Stk | 0.078 | 30204160125x160125078-18-18-18-1 | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/78.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/0/0/160.00/125.00/0/78.00/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 125 | 125 | 160 | 120.000 | 0 | 1.0 | TA.03.30301 | A | 6782Obj0798479038 | Potrubní tvarovka |  |  | 78 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
752041601601250215012509xxxx | Půdorys 1.NP | Stk | 0.215 | 752041601601250215012509xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/215.0000/0/0/0/0/180.0/1.0000/160.0000/160.0000/2/107.5000/125.0000/0/90.0/0/180.0/125.0000/125.0000/125.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/125.00/0/180.00/215.00/0/125.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | TA.03.30302 | A | 6782Obj0798479040 | Potrubní tvarovka | 215.000/125.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 |  | 215 | NEMSOK - K_POSITION: L.1; Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
252x1250125145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | TA.03.30303 | A | 6782Obj0798479042 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN125
752042502501250215017x9xxxx | Půdorys 1.NP | Stk | 0.215 | 752042502501250215017x9xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/0/250.0000/250.0000/250.0000/2/215.0000/0/0/0/0/0/125.0000/250.0000/250.0000/2/107.5000/170.0000/0/90.0/0/0/125.0000/125.0000/125.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/125.00/0/0/215.00/0/170.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | TA.03.30304 | A | 6782Obj0798479046 | Potrubní tvarovka |  |  | 215 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN250
752042502501250215017x9xxxx | Půdorys 1.NP | Stk | 0.215 | 752042502501250215017x9xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/180.0/250.0000/250.0000/250.0000/2/215.0000/0/0/0/0/180.0/125.0000/250.0000/250.0000/2/107.5000/170.0000/0/90.0/0/180.0/125.0000/125.0000/125.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/125.00/0/180.00/215.00/0/170.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | TA.03.30305 | A | 6782Obj0798479048 | Potrubní tvarovka |  |  | 215 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN250
7520425025025x38x19x9xxxx | Půdorys 1.NP | Stk | 0.38 | 7520425025025x38x19x9xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/0/250.0000/250.0000/250.0000/2/260.0000/0/0/0/0/0/1.0000/250.0000/250.0000/2/130.0000/175.0000/0/90.0/0/0/160.0000/160.0000/160.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/160.00/0/0/260.00/0/175.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | TA.03.30306 | A | 6782Obj0798479083 | Potrubní tvarovka | 380.000/190.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 260 | NEMSOK - K_POSITION: L.1; Podlaží: Nadzemní podlaží 1.NP; Průměr: DN250
7520416016016x26x13x9xxxx | Půdorys 1.NP | Stk | 0.26 | 7520416016016x26x13x9xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/260.0000/0/0/0/0/0/1.0000/160.0000/160.0000/2/130.0000/130.0000/0/90.0/0/0/160.0000/160.0000/160.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/160.00/0/0/260.00/0/130.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30307 | A | 6782Obj0798479085 | Potrubní tvarovka |  |  | 260 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
752042x2x2x033x16509xxxx | Půdorys 1.NP | Stk | 0.33 | 752042x2x2x033x16509xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/0/200.0000/200.0000/200.0000/2/150.0000/-130.0000/0/270.0/0/0/1.0000/200.0000/200.0000/2/150.0000/130.0000/0/90.0/0/0/200.0000/200.0000/200.0000/2/ | 75/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/200.00/0/0/260.00/0/150.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30308 | A | 6782Obj0798480525 | Potrubní tvarovka | 260.000/150.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 |  | 260 | NEMSOK - K_POSITION: L.1; Podlaží: Nadzemní podlaží 1.NP; Průměr: DN200
302042x1xx2x1x0150-50-50-50-503x | Půdorys 1.NP | Stk | 0.15 | 302042x1xx2x1x0150-50-50-50-503x | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/2/150.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/100.00/0/0/200.00/100.00/0/150.00/-50.00/-50.00/-50.00/-50.00/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 100 | 100 | 200 | 0.000 | 0 | 1.0 | TA.03.30309 | A | 6782Obj0798480531 | Potrubní tvarovka |  |  | 150 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN200
302042x16x02x16x85-20-20-20-203x | Půdorys 1.NP | Stk | 0.085 | 302042x16x02x16x85-20-20-20-203x | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/2/85.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/160.00/0/0/200.00/160.00/0/85.00/-20.00/-20.00/-20.00/-20.00/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 160 | 160 | 200 | 0.000 | 0 | 1.0 | TA.03.30310 | A | 6782Obj0798480566 | Potrubní tvarovka |  |  | 85 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN200
252x1x01x13xxxxxx | Půdorys 1.NP | Stk | 0 | 252x1x01x13xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/91.2/100.0000/100.0000/100.0000/2/50.0000/13.3975/0/30.0/0/91.2/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/91.20/0/100.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | TA.03.30311 | A | 6782Obj0798480875 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN100
252x1x01x13xxxxxx | Půdorys 1.NP | Stk | 0 | 252x1x01x13xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/271.4/100.0000/100.0000/100.0000/2/50.0000/13.3975/0/30.0/0/271.4/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/271.40/0/100.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | TA.03.30312 | A | 6782Obj0798480885 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN100
252x16x16013xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16013xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.8/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/270.8/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.80/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30313 | A | 6782Obj0798480900 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
252x16x16013xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16013xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.9/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/90.9/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.90/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30314 | A | 6782Obj0798480910 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
50216160315351x1601601602697878x | Půdorys 1.NP | m2 | 0.269 | 50216160315351x1601601602697878x | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/2/269.2000/0/0/0/0/0/0/160.0000/160.0000/1/ | 50/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/160.00/160.00/35.00/100.00/160.00/160.00/160.00/269.20/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | TA.03.30315 | A | 6782Obj0798480952 | Potrubní tvarovka | 269.200/157.500/80.000/0.000/-157.500/-80.000/0.000/0.000/0.000/1.000 |  | 269 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
701063153153153155050505016x0615 | Půdorys 1.NP | m2 | 0.615 | 701063153153153155050505016x0615 | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/0/315.0000/315.0000/160.0000/1/230.0000/-307.5000/0/270.0/0/0/1.0000/160.0000/160.0000/1/230.0000/307.5000/0/90.0/0/0/160.0000/160.0000/160.0000/1/ | 70/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/315.00/315.00/50.00/50.00/50.00/50.00/160.00/0/0/0/615.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 160 | 160 | 315 | 0.000 | 0 | 1.000 m2 | TA.03.30316 | A | 6782Obj0798480972 | Potrubní tvarovka | 485.000/307.500/100.000/0.000/-307.500/-100.000/0.000/0.000/0.000/1.000 |  | 615 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.315 m; Výška: 0.16 m
50216160315351x1601601601507878x | Půdorys 1.NP | m2 | 0.15 | 50216160315351x1601601601507878x | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/2/150.0000/0/0/0/0/0/0/160.0000/160.0000/1/ | 50/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/160.00/160.00/35.00/100.00/160.00/160.00/160.00/150.00/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | TA.03.30317 | A | 6782Obj0798480989 | Potrubní tvarovka | 150.000/157.500/80.000/0.000/-157.500/-80.000/0.000/0.000/0.000/1.000 |  | 150 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
252x16x16013xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16013xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/270.0/160.0000/160.0000/160.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.00/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30318 | A | 6782Obj0798481024 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
252x16x16013xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16013xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30319 | A | 6782Obj0798481034 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
252x16x16013xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16013xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/270.0/160.0000/160.0000/160.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.00/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30320 | A | 6782Obj0798481049 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
252x16x16013xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16013xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30321 | A | 6782Obj0798481059 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
701043153151251255050505016x0425 | Půdorys 1.NP | m2 | 0.425 | 701043153151251255050505016x0425 | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/180.0/315.0000/315.0000/160.0000/1/425.0000/0/0/0/0/180.0/160.0000/315.0000/160.0000/1/212.5000/307.5000/0/90.0/0/180.0/125.0000/125.0000/160.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/125.00/125.00/50.00/50.00/50.00/50.00/160.00/0/0/180.00/425.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | TA.03.30322 | A | 6782Obj0798481085 | Potrubní tvarovka |  |  | 425 | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.315 m; Výška: 0.16 m
50105125125351x160125125165x-18- | Půdorys 1.NP | m2 | 0.165 | 50105125125351x160125125165x-18- | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/1.0000/125.0000/160.0000/1/187.0000/0/0/0/0/0/0/100.0000/100.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/100.00/35.00/100.00/160.00/100.00/100.00/187.00/-12.50/-12.50/-30.00/-30.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 125x160 | 100 | 100 | 125 | 0.000 | 0 | 1.000 m2 | TA.03.30323 | A | 6782Obj0798481202 | Potrubní tvarovka | 165.300/62.500/80.000/0.000/-62.500/-80.000/0.000/0.000/0.000/1.000 |  | 187 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.125 m; Výška: 0.16 m
302042x16x02x16x85-20-20-20-203x | Půdorys 1.NP | Stk | 0.085 | 302042x16x02x16x85-20-20-20-203x | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/2/85.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/160.00/0/0/200.00/160.00/0/85.00/-20.00/-20.00/-20.00/-20.00/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 160 | 160 | 200 | 0.000 | 0 | 1.0 | TA.03.30324 | A | 6782Obj0798481236 | Potrubní tvarovka |  |  | 85 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN200
7520525025025x38x19x9xxxx | Půdorys 1.NP | Stk | 0.38 | 7520525025025x38x19x9xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/0/250.0000/250.0000/250.0000/2/190.0000/-190.0000/0/270.0/0/0/1.0000/250.0000/250.0000/2/190.0000/190.0000/0/90.0/0/0/250.0000/250.0000/250.0000/2/ | 75/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/250.00/0/0/380.00/0/190.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | TA.03.30325 | A | 6782Obj0798481244 | Potrubní tvarovka | 380.000/190.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 380 | NEMSOK - K_POSITION: L.1; Podlaží: Nadzemní podlaží 1.NP; Průměr: DN250
3020425016x025016x154-45-45-45-4 | Půdorys 1.NP | Stk | 0.154 | 3020425016x025016x154-45-45-45-4 | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/250.0000/250.0000/250.0000/2/154.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/160.00/0/0/250.00/160.00/0/154.00/-45.00/-45.00/-45.00/-45.00/30.00/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 160 | 160 | 250 | 0.000 | 0 | 1.0 | TA.03.30326 | A | 6782Obj0798481270 | Potrubní tvarovka |  |  | 154 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN250
752042x2x2x033x16509xxxx | Půdorys 1.NP | Stk | 0.33 | 752042x2x2x033x16509xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/180.0/200.0000/200.0000/200.0000/2/190.0000/0/0/0/0/180.0/1.0000/200.0000/200.0000/2/95.0000/145.0000/0/90.0/0/180.0/100.0000/100.0000/100.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/100.00/0/180.00/190.00/0/145.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30327 | A | 6782Obj0798481306 | Potrubní tvarovka | 250.000/130.000/100.000/0.000/-130.000/-100.000/0.000/0.000/0.000/1.000 |  | 190 | NEMSOK - K_POSITION: L.1; Podlaží: Nadzemní podlaží 1.NP; Průměr: DN200
302062502xx2502x099-25-25-25-253 | Půdorys 1.NP | Stk | 0.099 | 302062502xx2502x099-25-25-25-253 | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/250.0000/250.0000/250.0000/2/99.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 30/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/200.00/0/0/250.00/200.00/0/99.00/-25.00/-25.00/-25.00/-25.00/30.00/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 200 | 200 | 250 | 0.000 | 0 | 1.0 | TA.03.30328 | A | 6782Obj0798481316 | Potrubní tvarovka |  |  | 99 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN250
51105315250505016025x216-33-3309 | Půdorys 1.NP | m2 | 0.216 | 51105315250505016025x216-33-3309 | UEBERGANG ECK/RU AS | 20 | 51 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/215.9000/0/-45.0000/0/0/0/0/250.0000/250.0000/2/ | 51/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/250.00/50.00/50.00/160.00/250.00/0/215.90/-32.50/-32.50/0/90.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 315x160 | 250 | 250 | 315 | 0.000 | 0 | 1.000 m2 | TA.03.30329 | A | 6782Obj0798481363 | Potrubní tvarovka |  |  | 216 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.315 m; Výška: 0.16 m
252x25x25013xxxxxx | Půdorys 1.NP | Stk | 0 | 252x25x25013xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/250.0000/250.0000/250.0000/2/125.0000/33.4936/0/30.0/0/0/250.0000/250.0000/250.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/0/0/250.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | TA.03.30330 | A | 6782Obj0798481519 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN250
252x25x25013xxxxxx | Půdorys 1.NP | Stk | 0 | 252x25x25013xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/250.0000/250.0000/250.0000/2/125.0000/33.4936/0/30.0/0/180.0/250.0000/250.0000/250.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/180.00/0/250.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | TA.03.30331 | A | 6782Obj0798481529 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN250
252x2x02x19xxxxxx | Půdorys 1.NP | Stk | 0 | 252x2x02x19xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/200.0000/200.0000/200.0000/2/200.0000/200.0000/0/90.0/0/0/200.0000/200.0000/200.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/0/0/200.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30332 | A | 6782Obj0798481672 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN200
252x16x16016xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16016xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/138.5641/80.0000/0/60.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | TA.03.30333 | A | 6782Obj0798482049 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
252x16x16016xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16016xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/138.5641/80.0000/0/60.0/0/270.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.00/0/160.00/1.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | TA.03.30334 | A | 6782Obj0798482059 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
252x16x16016xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16016xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/138.5641/80.0000/0/60.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | TA.03.30335 | A | 6782Obj0798482074 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
252x16x16016xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16016xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/138.5641/80.0000/0/60.0/0/270.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.00/0/160.00/1.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | TA.03.30336 | A | 6782Obj0798482084 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
252x16x16019xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16019xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/180.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/180.00/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30337 | A | 6782Obj0798482119 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
252x16x16013xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16013xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30338 | A | 6782Obj0798482129 | Potrubní tvarovka | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: DN160
