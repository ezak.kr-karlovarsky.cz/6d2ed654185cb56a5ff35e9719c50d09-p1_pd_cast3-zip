Properties of the parts of a building model (IFC2X3), part 15 of 51

# IfcFlowFitting (2887)
Name | In | Jednotka | Délka (m) | Označení | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_DIM | L_BES_DIM_A2 | L_BES_DIM_B2 | L_BES_DIM_A | K_VOLSTROM | K_MLH_GOST = K_MLD_GOST | K_LISTVALUE | Kód prvku | Třída reakce na oheň | Allright_Stavebni_dil_ID | Název_objektu | K_EBT_BOX_WC | Plocha | L_BES_LAENGE | K_INTERNAL_ISO | Tloušťka (m) | Součinitel tepelné vodivost
152041251253xxxxxxx | Půdorys 1.PP | Kus | 0.03 | 152041251253xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.030 m | IT.02.30500 | A1 | 6774Obj0000047099 | Objekt | 30.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.019 m2
152041251253xxxxxxx | Půdorys 1.PP | Kus | 0.03 | 152041251253xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.030 m | IT.02.30501 | A1 | 6774Obj0000047102 | Objekt | 30.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.019 m2
152041251253xxxxxxx | Půdorys 1.PP | Kus | 0.03 | 152041251253xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.030 m | IT.02.30502 | A1 | 6774Obj0000047105 | Objekt | 30.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.019 m2
152041251253xxxxxxx | Půdorys 1.PP | Kus | 0.03 | 152041251253xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.030 m | IT.02.30503 | A1 | 6774Obj0000047108 | Objekt | 30.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.019 m2
152041251253xxxxxxx | Půdorys 1.PP | Kus | 0.03 | 152041251253xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.030 m | IT.02.30504 | A1 | 6774Obj0000047111 | Objekt | 30.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.019 m2
macro | Půdorys 1.PP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.02.30505 | A1 | 6774Obj0000047125 | Objekt | 19277.053/6659.980/-460.500/19152.041/6349.974/-585.500/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2022/11/04; N_FREI_68: SPIRO POTRUBÍ
 | Půdorys 1.PP | Kus | 0.03 |  | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.030 m | IT.02.30506 | A1 | 6774Obj0000047128 | Objekt | 30.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.019 m2
macro | Půdorys 1.PP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.02.30507 | A1 | 6774Obj0000047142 | Objekt | 15799.767/7083.985/-460.500/15674.754/6773.980/-585.500/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2022/11/04; N_FREI_68: SPIRO POTRUBÍ
 | Půdorys 1.PP | Kus | 0.03 |  | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.030 m | IT.02.30508 | A1 | 6774Obj0000047145 | Objekt | 30.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.019 m2
152041251253xxxxxxx | Půdorys 1.PP | Kus | 0.024 | 152041251253xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/24.3519/125.0000/125.0000/2/24.3519/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/24.35/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.024 m | IT.02.30509 | A1 | 6774Obj0000047148 | Objekt | 24.352/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.024 | 24 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.016 m2
1520512512524xxxxxx0 | Půdorys 1.PP | Kus | 0.03 | 1520512512524xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.030 m | IT.02.30510 | A1 | 6774Obj0000047151 | Objekt | 30.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.019 m2
152041251253xxxxxxx | Půdorys 1.PP | Kus | 0 | 152041251253xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/0/125.0000/125.0000/125.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30511 | A1 | 6774Obj0000047154 | Objekt | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012519xxxxxx | Půdorys 1.PP | Kus | 0.211 | 252x125012519xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/210.7292/125.0000/125.0000/2/210.7292/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/210.73/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.211 m | IT.02.30512 | A1 | 6774Obj0000047157 | Objekt | 210.729/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.211 | 211 | __ISO | 0.04 | 0,041 W/m.K
15204125125211xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15204125125211xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30513 | A1 | 6774Obj0000047160 | Objekt | 48.529/64.630/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125115xxxxx0 | Půdorys 1.PP | Kus | 0.16 | 252x1250125115xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/160.2719/125.0000/125.0000/2/160.2719/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/160.27/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.160 m | IT.02.30514 | A1 | 6774Obj0000047163 | Objekt | 160.272/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.16 | 160 | __ISO | 0.04 | 0,041 W/m.K
1520412512516xxxxxxx | Půdorys 1.PP | Kus | 0 | 1520412512516xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30515 | A1 | 6774Obj0000047166 | Objekt | 48.529/64.630/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125115xxxxx0 | Půdorys 1.PP | Kus | 0.211 | 252x1250125115xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/210.6216/125.0000/125.0000/2/210.6216/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/210.62/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.211 m | IT.02.30516 | A1 | 6774Obj0000047169 | Objekt | 210.622/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.211 | 211 | __ISO | 0.04 | 0,041 W/m.K
15204125125211xxxxxx0 | Půdorys 1.PP | Kus | 0.162 | 15204125125211xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/162.2181/125.0000/125.0000/2/162.2181/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/162.22/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.162 m | IT.02.30517 | A1 | 6774Obj0000047172 | Objekt | 162.218/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.162 | 162 | __ISO | 0.04 | 0,041 W/m.K
15205125125162xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15205125125162xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30518 | A1 | 6774Obj0000047175 | Objekt | 48.529/64.630/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125115xxxxx0 | Půdorys 1.PP | Kus | 0.092 | 252x1250125115xxxxx0 | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/125.0000/125.0000/2/92.0000/0.0040/0.0275/0/0/0/125.0000/125.0000/125.0000/2/ | 30/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/0/0/125.00/125.00/0/92.00/-0.00/0.00/0.03/-0.03/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30519 | A1 | 6774Obj0000047178 | Objekt | 92.000/62.504/62.528/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 | 92 | __ISO | 0.04 | 0,041 W/m.K
30205125125x125125092-x0-03xx | Půdorys 1.PP | Kus | 0.068 | 30205125125x125125092-x0-03xx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/68.1693/125.0000/125.0000/2/68.1693/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/68.17/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.068 m | IT.02.30520 | A1 | 6774Obj0000047181 | Objekt | 68.169/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.068 | 68 | __ISO | 0.04 | 0,041 W/m.K
1520512512568xxxxxx0 | Půdorys 1.PP | Kus | 0 | 1520512512568xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30521 | A1 | 6774Obj0000047184 | Objekt | 48.529/64.630/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125115xxxxx0 | Půdorys 1.PP | Kus | 0.162 | 252x1250125115xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/162.2180/125.0000/125.0000/2/162.2180/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/162.22/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.162 m | IT.02.30522 | A1 | 6774Obj0000047187 | Objekt | 162.218/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.162 | 162 | __ISO | 0.04 | 0,041 W/m.K
15205125125162xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15205125125162xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/351.9/125.0000/125.0000/125.0000/2/85.0901/33.4321/0/42.9/0/351.9/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/351.90/0/125.00/1.00/42.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30523 | A1 | 6774Obj0000047190 | Objekt | 127.635/79.216/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125143xxxxx0 | Půdorys 1.PP | Kus | 0.092 | 252x1250125143xxxxx0 | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/125.0000/125.0000/2/92.0000/0.3685/0.1858/0/0/0/125.0000/125.0000/125.0000/2/ | 30/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/0/0/125.00/125.00/0/92.00/-0.37/0.37/0.19/-0.19/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30524 | A1 | 6774Obj0000047193 | Objekt | 92.000/62.869/62.686/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 | 92 | __ISO | 0.04 | 0,041 W/m.K
30205125125x125125092-x0-03xx | Půdorys 1.PP | Kus | 0.333 | 30205125125x125125092-x0-03xx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/333.0006/125.0000/125.0000/2/333.0006/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/333.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.333 m | IT.02.30525 | A1 | 6774Obj0000047196 | Objekt | 333.001/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.333 | 333 | __ISO | 0.04 | 0,041 W/m.K
15205125125333xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15205125125333xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/174.0/125.0000/125.0000/125.0000/2/85.0901/33.4321/0/42.9/0/174.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/174.00/0/125.00/1.00/42.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30526 | A1 | 6774Obj0000047199 | Objekt | 127.635/79.216/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125143xxxxx0 | Půdorys 1.PP | Kus | 0.032 | 252x1250125143xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/32.2663/125.0000/125.0000/2/32.2663/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/32.27/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.032 m | IT.02.30527 | A1 | 6774Obj0000047202 | Objekt | 32.266/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.032 | 32 | __ISO | 0.04 | 0,041 W/m.K
1520412512532xxxxxx0 | Půdorys 1.PP | Kus | 0 | 1520412512532xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/348.9/125.0000/125.0000/125.0000/2/108.2532/62.5000/0/60.0/0/348.9/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/348.90/0/125.00/1.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30528 | A1 | 6774Obj0000047205 | Objekt | 162.380/93.750/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012516xxxxxx | Půdorys 1.PP | Kus | 0.157 | 252x125012516xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/156.7099/125.0000/125.0000/2/156.7099/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/156.71/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.157 m | IT.02.30529 | A1 | 6774Obj0000047208 | Objekt | 156.710/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.157 | 157 | __ISO | 0.04 | 0,041 W/m.K
15204125125157xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15204125125157xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/174.4/125.0000/125.0000/125.0000/2/108.2532/62.5000/0/60.0/0/174.4/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/174.40/0/125.00/1.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30530 | A1 | 6774Obj0000047211 | Objekt | 162.380/93.750/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012516xxxxxx | Půdorys 1.PP | Kus | 0.032 | 252x125012516xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/32.2910/125.0000/125.0000/2/32.2910/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/32.29/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.032 m | IT.02.30531 | A1 | 6774Obj0000047214 | Objekt | 32.291/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.032 | 32 | __ISO | 0.04 | 0,041 W/m.K
1520412512532xxxxxx0 | Půdorys 1.PP | Kus | 0.042 | 1520412512532xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/41.9594/125.0000/125.0000/2/41.9594/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/41.96/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.042 m | IT.02.30532 | A1 | 6774Obj0000047217 | Objekt | 41.959/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.042 | 42 | __ISO | 0.04 | 0,041 W/m.K
1520412512542xxxxxx0 | Půdorys 1.PP | Kus | 0 | 1520412512542xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30533 | A1 | 6774Obj0000047220 | Objekt | 48.529/64.630/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125115xxxxx0 | Půdorys 1.PP | Kus | 0.092 | 252x1250125115xxxxx0 | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/125.0000/125.0000/2/92.0000/0/0.0278/0/0/0/125.0000/125.0000/125.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/0/0/125.00/125.00/0/92.00/0/0/0.03/-0.03/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30534 | A1 | 6774Obj0000047223 | Objekt | 92.000/62.500/62.528/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 | 92 | __ISO | 0.04 | 0,041 W/m.K
30204125125x125125092x0-03xx | Půdorys 1.PP | Kus | 0.068 | 30204125125x125125092x0-03xx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/68.1682/125.0000/125.0000/2/68.1682/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/68.17/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.068 m | IT.02.30535 | A1 | 6774Obj0000047226 | Objekt | 68.168/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.068 | 68 | __ISO | 0.04 | 0,041 W/m.K
1520412512568xxxxxx0 | Půdorys 1.PP | Kus | 0 | 1520412512568xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30536 | A1 | 6774Obj0000047229 | Objekt | 48.529/64.630/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125115xxxxx0 | Půdorys 1.PP | Kus | 0.042 | 252x1250125115xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/41.9593/125.0000/125.0000/2/41.9593/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/41.96/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.042 m | IT.02.30537 | A1 | 6774Obj0000047232 | Objekt | 41.959/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.042 | 42 | __ISO | 0.04 | 0,041 W/m.K
1520412512542xxxxxx0 | Půdorys 1.PP | Kus | 0.703 | 1520412512542xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/703.2960/125.0000/125.0000/2/703.2960/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/703.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.703 m | IT.02.30538 | A1 | 6774Obj0000047235 | Objekt | 703.296/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.703 | 703 | __ISO | 0.04 | 0,041 W/m.K
15205125125703xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15205125125703xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30539 | A1 | 6774Obj0000047238 | Objekt | 48.529/64.630/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125115xxxxx0 | Půdorys 1.PP | Kus | 0.16 | 252x1250125115xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/160.2719/125.0000/125.0000/2/160.2719/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/160.27/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.160 m | IT.02.30540 | A1 | 6774Obj0000047241 | Objekt | 160.272/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.16 | 160 | __ISO | 0.04 | 0,041 W/m.K
1520512512516xxxxxxx | Půdorys 1.PP | Kus | 0 | 1520512512516xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30541 | A1 | 6774Obj0000047244 | Objekt | 48.529/64.630/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125115xxxxx0 | Půdorys 1.PP | Kus | 0.703 | 252x1250125115xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/703.1884/125.0000/125.0000/2/703.1884/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/703.19/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.703 m | IT.02.30542 | A1 | 6774Obj0000047247 | Objekt | 703.188/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.703 | 703 | __ISO | 0.04 | 0,041 W/m.K
15205125125703xxxxxx0 | Půdorys 1.PP | Kus | 1.018 | 15205125125703xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1017.9327/125.0000/125.0000/2/1017.9327/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/1017.93/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.018 m | IT.02.30543 | A1 | 6774Obj0000047250 | Objekt | 1017.933/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1.018 | 1018 | __ISO | 0.04 | 0,041 W/m.K
 | Půdorys 1.PP | Kus | 0 |  | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/289.7/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/289.7/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/289.70/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30544 | A1 | 6774Obj0000047253 | Objekt | 48.529/64.630/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125115xxxxx0 | Půdorys 1.PP | Kus | 0.172 | 252x1250125115xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/172.1198/125.0000/125.0000/2/172.1198/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/172.12/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.172 m | IT.02.30545 | A1 | 6774Obj0000047256 | Objekt | 172.120/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.172 | 172 | __ISO | 0.04 | 0,041 W/m.K
15205125125172xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15205125125172xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/110.3/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/110.3/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/110.30/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30546 | A1 | 6774Obj0000047259 | Objekt | 48.529/64.630/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125115xxxxx0 | Půdorys 1.PP | Kus | 1.018 | 252x1250125115xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1017.9248/125.0000/125.0000/2/1017.9248/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/1017.92/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.018 m | IT.02.30547 | A1 | 6774Obj0000047262 | Objekt | 1017.925/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1.018 | 1018 | __ISO | 0.04 | 0,041 W/m.K
 | Půdorys 1.PP | Kus | 0.146 |  | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/146.3460/125.0000/125.0000/2/146.3460/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/146.35/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.146 m | IT.02.30548 | A1 | 6774Obj0000047265 | Objekt | 146.346/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.146 | 146 | __ISO | 0.04 | 0,041 W/m.K
15204125125146xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15204125125146xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30549 | A1 | 6774Obj0000047268 | Objekt | 48.529/64.630/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125115xxxxx0 | Půdorys 1.PP | Kus | 0.092 | 252x1250125115xxxxx0 | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/125.0000/125.0000/2/92.0000/0/0.0278/0/0/0/125.0000/125.0000/125.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/0/0/125.00/125.00/0/92.00/0/0/0.03/-0.03/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30550 | A1 | 6774Obj0000047271 | Objekt | 92.000/62.500/62.528/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 | 92 | __ISO | 0.04 | 0,041 W/m.K
30204125125x125125092x0-03xx | Půdorys 1.PP | Kus | 0.068 | 30204125125x125125092x0-03xx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/68.1682/125.0000/125.0000/2/68.1682/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/68.17/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.068 m | IT.02.30551 | A1 | 6774Obj0000047274 | Objekt | 68.168/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.068 | 68 | __ISO | 0.04 | 0,041 W/m.K
1520412512568xxxxxx0 | Půdorys 1.PP | Kus | 0 | 1520412512568xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30552 | A1 | 6774Obj0000047277 | Objekt | 48.529/64.630/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125115xxxxx0 | Půdorys 1.PP | Kus | 0.146 | 252x1250125115xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/146.3459/125.0000/125.0000/2/146.3459/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/146.35/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.146 m | IT.02.30553 | A1 | 6774Obj0000047280 | Objekt | 146.346/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.146 | 146 | __ISO | 0.04 | 0,041 W/m.K
15204125125146xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15204125125146xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/90.0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/0/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 |  | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 100 | 100 | 100 | 120.000 |  | 1.0 | IT.02.30554 | A1 | 6774Obj0000047283 | Objekt | 150.000/100.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; L_BES_DIM_B: 100
252x1x01x19xxxxxx | Půdorys 1.PP | Kus | 0 | 252x1x01x19xxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 |  | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 125 | 125 | 125 | 120.000 |  | 1.0 | IT.02.30555 | A1 | 6774Obj0000047286 | Objekt | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; L_BES_DIM_B: 125
252x125012519xxxxxx | Půdorys 1.PP | Kus | 1.5 | 252x125012519xxxxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/450.0000/160.0000/1/1500.0000/0/0/0/0/0/1.0000/450.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/160.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x160 | 450 | 160 | 450 | 0.000 | 0 | 1.830 m2 | IT.02.30556 | A1 | 6774Obj0000047300 | Objekt | 1500.000/245.000/100.000/0.000/-245.000/-100.000/0.000/0.000/0.000/1.000 | 1.83 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.26; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 2.310 m2
1010445016015xxxxxxx0 | Půdorys 1.PP | Kus | 0.48 | 1010445016015xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/450.0000/160.0000/1/480.0000/0/0/0/0/0/1.0000/450.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/160.00/480.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x160 | 450 | 160 | 450 | 0.000 | 0 | 1.000 m2 | IT.02.30557 | A1 | 6774Obj0000047314 | Objekt | 480.000/245.000/100.000/0.000/-245.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 480 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.27; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
1010445016048xxxxxxx | Půdorys 1.PP | Kus | 0.46 | 1010445016048xxxxxxx | T-STCK. SCHRÄG | 20 | 1016 | 3/0/0/0/180.0/0/180.0/450.0000/450.0000/160.0000/1/460.0000/-25.0000/0/0/0/180.0/1.0000/500.0000/160.0000/1/230.0000/375.0000/0/90.0/0/180.0/160.0000/160.0000/160.0000/1/ | 71/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/500.00/160.00/160.00/50.00/50.00/50.00/50.00/160.00/0/0/180.00/460.00/-50.00/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x160 | 500 | 160 | 450 | 0.000 | 0 | 1.000 m2 | IT.02.30558 | A1 | 6774Obj0000047370 | Objekt | 460.000/375.000/100.000/0.000/-295.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 460 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.28; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
711044505x1601605050505016x0460- | Půdorys 1.PP | Kus | 0.06 | 711044505x1601605050505016x0460- | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/59.5884/100.0000/100.0000/2/59.5884/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/59.59/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 0.060 m | IT.02.30559 | A1 | 6774Obj0000047373 | Objekt | 59.588/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.06 | 60 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.034 m2
152041x1x6xxxxxxx | Půdorys 1.PP | Kus | 0 | 152041x1x6xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/321.5/100.0000/100.0000/100.0000/2/94.1471/66.2905/0/70.3/0/321.5/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/321.50/0/100.00/1.00/70.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 1.0 | IT.02.30560 | A1 | 6774Obj0000047376 | Objekt | 141.221/83.145/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1x01x17xxxxxx | Půdorys 1.PP | Kus | 0.02 | 252x1x01x17xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/20.1703/100.0000/100.0000/2/20.1703/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/20.17/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 0.020 m | IT.02.30561 | A1 | 6774Obj0000047379 | Objekt | 20.170/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.02 | 20 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.011 m2
152041x1x2xxxxxxx | Půdorys 1.PP | Kus | 0 | 152041x1x2xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/52.0/100.0000/100.0000/100.0000/2/67.5590/26.2723/0/42.5/0/52.0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/52.00/0/100.00/1.00/42.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 1.0 | IT.02.30562 | A1 | 6774Obj0000047382 | Objekt | 101.339/63.136/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1x01x143xxxxx0 | Půdorys 1.PP | Kus | 0.091 | 252x1x01x143xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/91.1020/100.0000/100.0000/2/91.1020/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/91.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 0.091 m | IT.02.30563 | A1 | 6774Obj0000047385 | Objekt | 91.102/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.091 | 91 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.052 m2
152041x1x91xxxxxx0 | Půdorys 1.PP | Kus | 0.135 | 152041x1x91xxxxxx0 | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/135.0000/0/0/0/0/0/0/160.0000/120.0000/1/ | 50/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/160.00/160.00/35.00/100.00/160.00/120.00/160.00/135.00/0/0/-20.00/-20.00/53.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 120 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30564 | A1 | 6774Obj0000047407 | Objekt | 135.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 135 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.23; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); K_LISTVALUE_ISO: 1.000 m2
50216160160351x160120160135x-20- | Půdorys 1.PP | Kus | 0.19 | 50216160160351x160120160135x-20- | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/190.0000/0/0/0/0/180.0/1.0000/160.0000/160.0000/2/95.0000/125.0000/0/90.0/0/180.0/100.0000/100.0000/100.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/100.00/0/180.00/190.00/0/125.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | IT.02.30565 | A1 | 6774Obj0000047411 | Objekt | 190.000/125.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 190 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
752041601601x019x12509xxxx | Půdorys 1.PP | Kus | 0.012 | 752041601601x019x12509xxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/12.0000/160.0000/160.0000/2/12.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/12.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 0.012 m | IT.02.30566 | A1 | 6774Obj0000047414 | Objekt | 12.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.012 | 12 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.009 m2
1520616016012xxxxxx0 | Půdorys 1.PP | Kus | 0.078 | 1520616016012xxxxxx0 | UE RUND AS | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/78.0000/0/17.5000/0/0/0/125.0000/125.0000/125.0000/2/ | 31/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/0/0/160.00/125.00/0/78.00/-17.50/-17.50/0/-35.00/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 125 | 125 | 160 | 120.000 | 0 | 1.0 | IT.02.30567 | A1 | 6774Obj0000047417 | Objekt | 78.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 78 | __ISO | 0.04 | 0,041 W/m.K
31206160125x160125078-18-180-353 | Půdorys 1.PP | Kus | 0.145 | 31206160125x160125078-18-180-353 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/144.5306/125.0000/125.0000/2/144.5306/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/144.53/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 0.144 m | IT.02.30568 | A1 | 6774Obj0000047420 | Objekt | 144.531/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.144 | 145 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.093 m2
15206125125145xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15206125125145xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/352.0/125.0000/125.0000/125.0000/2/77.4724/26.9030/0/38.3/0/352.0/125.0000/125.0000/125.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/352.00/0/125.00/1.00/38.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | IT.02.30569 | A1 | 6774Obj0000047423 | Objekt | 116.209/75.951/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125138xxxxx0 | Půdorys 1.PP | Kus | 0.693 | 252x1250125138xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/693.3145/125.0000/125.0000/2/693.3145/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/693.31/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 0.693 m | IT.02.30570 | A1 | 6774Obj0000047426 | Objekt | 693.315/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.693 | 693 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.447 m2
15206125125693xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15206125125693xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/3.9/125.0000/125.0000/125.0000/2/98.6355/48.2143/0/52.1/0/3.9/125.0000/125.0000/125.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/3.90/0/125.00/1.00/52.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | IT.02.30571 | A1 | 6774Obj0000047429 | Objekt | 147.953/86.607/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125152xxxxx0 | Půdorys 1.PP | Kus | 0.127 | 252x1250125152xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/127.0062/125.0000/125.0000/2/127.0062/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/127.01/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 0.127 m | IT.02.30572 | A1 | 6774Obj0000047432 | Objekt | 127.006/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.127 | 127 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.082 m2
15206125125127xxxxxx0 | Půdorys 1.PP | Kus | 0.412 | 15206125125127xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/411.9229/160.0000/160.0000/2/411.9229/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/411.92/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.412 m | IT.02.30573 | A1 | 6774Obj0000047435 | Objekt | 411.923/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.412 | 412 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.311 m2
15206160160412xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15206160160412xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/181.2/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/181.2/160.0000/160.0000/160.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/181.20/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.02.30574 | A1 | 6774Obj0000047438 | Objekt | 169.706/103.431/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x160145xxxxx0 | Půdorys 1.PP | Kus | 0.096 | 252x16x160145xxxxx0 | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/2/96.0000/0.0798/-0.0322/0/0/0/160.0000/160.0000/160.0000/2/ | 30/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/0/160.00/160.00/0/96.00/-0.08/0.08/-0.03/0.03/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.02.30575 | A1 | 6774Obj0000047441 | Objekt | 96.000/80.080/80.000/0.000/-80.000/-80.032/0.000/0.000/0.000/1.000 | 1 | 96 | __ISO | 0.04 | 0,041 W/m.K
3020616016x016016x96-x-x3xx | Půdorys 1.PP | Kus | 0.242 | 3020616016x016016x96-x-x3xx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/241.9755/160.0000/160.0000/2/241.9755/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/241.98/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.242 m | IT.02.30576 | A1 | 6774Obj0000047444 | Objekt | 241.976/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.242 | 242 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.182 m2
15206160160242xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15206160160242xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0.8/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/0.8/160.0000/160.0000/160.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/0.80/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.02.30577 | A1 | 6774Obj0000047447 | Objekt | 169.706/103.431/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
macro | Půdorys 1.PP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/160.00/160.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 |  | DN160 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.02.30578 | A1 | 6774Obj0000047461 | Objekt | 21511.325/6629.039/-400.101/21351.321/6318.941/-560.287/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2022/11/04; N_FREI_68: SPIRO POTRUBÍ
 | Půdorys 1.PP | Kus | 0.102 |  | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/101.9000/160.0000/160.0000/2/101.9000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/101.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.102 m | IT.02.30579 | A1 | 6774Obj0000047464 | Objekt | 101.900/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.102 | 102 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.077 m2
15206160160102xxxxxx0 | Půdorys 1.PP | Kus | 0.135 | 15206160160102xxxxxx0 | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/135.0000/0/0/0/0/0/0/160.0000/120.0000/1/ | 50/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/160.00/160.00/35.00/100.00/160.00/120.00/160.00/135.00/0/0/-20.00/-20.00/53.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 120 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30580 | A1 | 6774Obj0000047486 | Objekt | 135.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 135 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.23; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); K_LISTVALUE_ISO: 1.000 m2
50216160160351x160120160135x-20- | Půdorys 1.PP | Kus | 0.05 | 50216160160351x160120160135x-20- | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/300.0000/400.0000/1/50.0000/0/0/0/0/0/1.0000/300.0000/400.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/300.00/400.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 300x400 | 300 | 400 | 300 | 0.000 | 0 | 1.000 m2 | IT.02.30581 | A1 | 6774Obj0000047500 | Objekt | 50.000/170.000/220.000/0.000/-170.000/-220.000/0.000/0.000/0.000/1.000 | 1 | 50 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; K_LISTVALUE_ISO: 1.000 m2
101043x4x5xxxxxxx | Půdorys 1.PP | Kus | 0 | 101043x4x5xxxxxxx | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/180.0/500.0000/500.0000/160.0000/1/400.0000/400.0000/0/90.0/0/180.0/1.0000/500.0000/160.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/500.00/0/50.00/50.00/160.00/100.00/90.00/180.00/1.00/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 500x160 | 500 | 160 | 500 | 0.000 | 0 | 1.380 m2 | IT.02.30582 | A1 | 6774Obj0000047582 | Objekt | 670.000/400.000/100.000/0.000/-270.000/-100.000/0.000/0.000/0.000/1.000 | 1.38 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.22; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.810 m2
201055x5x050501601x9016xxxx | Půdorys 1.PP | Kus | 0 | 201055x5x050501601x9016xxxx | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/180.0/500.0000/500.0000/160.0000/1/400.0000/400.0000/0/90.0/0/180.0/1.0000/500.0000/160.0000/1/ | 20/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/500.00/0/50.00/50.00/160.00/100.00/90.00/180.00/1.00/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 500x160 | 500 | 160 | 500 | 0.000 | 0 | 1.380 m2 | IT.02.30583 | A1 | 6774Obj0000047664 | Objekt | 670.000/400.000/100.000/0.000/-270.000/-100.000/0.000/0.000/0.000/1.000 | 1.38 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.15; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.810 m2
201065x5x050501601x9016xxxx | Půdorys 1.PP | Kus | 1.175 | 201065x5x050501601x9016xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/500.0000/160.0000/1/1175.0000/0/0/0/0/0/1.0000/500.0000/160.0000/1/ | 10/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/160.00/1175.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 500x160 | 500 | 160 | 500 | 0.000 | 0 | 1.550 m2 | IT.02.30584 | A1 | 6774Obj0000047678 | Objekt | 1175.000/270.000/100.000/0.000/-270.000/-100.000/0.000/0.000/0.000/1.000 | 1.55 | 1175 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.5; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.930 m2
101065x1601175xxxxxx0 | Půdorys 1.PP | Kus | 0.731 | 101065x1601175xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/500.0000/160.0000/1/731.1000/0/0/0/0/0/1.0000/500.0000/160.0000/1/ | 10/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/160.00/731.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 500x160 | 500 | 160 | 500 | 0.000 | 0 | 1.000 m2 | IT.02.30585 | A1 | 6774Obj0000047692 | Objekt | 731.100/270.000/100.000/0.000/-270.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 731 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.8; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.200 m2
101065x160731xxxxxx0 | Půdorys 1.PP | Kus | 0.551 | 101065x160731xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/500.0000/160.0000/1/551.1000/0/0/0/0/0/1.0000/500.0000/160.0000/1/ | 10/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/160.00/551.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 500x160 | 500 | 160 | 500 | 0.000 | 0 | 1.000 m2 | IT.02.30586 | A1 | 6774Obj0000047706 | Objekt | 551.100/270.000/100.000/0.000/-270.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 551 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.10; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
