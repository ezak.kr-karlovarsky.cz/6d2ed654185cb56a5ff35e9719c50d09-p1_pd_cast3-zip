Properties of the parts of a building model (IFC2X3), part 1 of 51

# File
Description: no view
File name: 604-SOKOLOV_VZT_3D_e.ifc
Time: 2023-04-05T14:22:55
Author: Černoch Radim
Organization: TECHNICO Opava s.r.o., Hradecká 51
Written by: EDMsix Version 2.0.209.92 Dec 12 2020
Made in: Allplan 2022.1 01.07.2022 - 13:53:11

# IfcSite, 6.04 VZT
RefLatitude: 48, 0, 0, 0; RefLongitude: 0, 0, 0, 0

# IfcBuildingStorey (4)
In: Pavilon C
Elevation: 0 m
Name
Půdorys 1.PP
Půdorys 1.NP
Půdorys 2.NP
Půdorys střechy

# IfcAnnotation (31)
Name | In
28 x  | Půdorys 1.PP
 | Půdorys 1.NP | NEMSOK - Allright_Stavebni_dil_ID: 6782ExE0798482803; Jednotka: m; Název_objektu: Rozšířený element
 | Půdorys střechy | NEMSOK - Allright_Stavebni_dil_ID: 6882ExE0000000002; Jednotka: m; Název_objektu: Rozšířený element
 | Půdorys střechy | NEMSOK - Allright_Stavebni_dil_ID: 6882ExE0000000003; Jednotka: m; Název_objektu: Rozšířený element

# IfcBuildingElementProxy (417)
Name | In | Allright_Stavebni_dil_ID | Jednotka | Název_objektu | V6 (m) = V7 (m) = V8 (m) = V9 | Označení | Kód prvku | Podlaží | Délka (m) | Třída reakce na oheň
151 x  | Půdorys 1.PP
 | Půdorys 1.PP | 6772ExE0000161509 | m2 | Rozšířený element
QMODEL_c1402c89_5795_47f4_9d0e_0 | Půdorys 1.PP | 6772Obj0000000784 | Kus | Výřivý anemostat | 0 | QMODEL_c1402c89_5795_47f4_9d0e_0 | VV.02.30023 | Podzemní podlaží 1.PP | 0.588 | A1 | NEMSOK - Číslo místnosti: 1.01; Šířka: 0.388 m; Výška: 0.25 m; Průměr: 160 mm; Jmenovitá velikost vstupu: 160 mm; Průtok: 200 m3/hod; Rychlost: 1,3 m/s
QMODEL_c1402c89_5795_47f4_9d0e_0 | Půdorys 1.PP | 6772Obj0000000785 | Kus | Výřivý anemostat | 0 | QMODEL_c1402c89_5795_47f4_9d0e_0 | VV.02.30024 | Podzemní podlaží 1.PP | 0.588 | A1 | NEMSOK - Číslo místnosti: 1.01; Šířka: 0.388 m; Výška: 0.25 m; Průměr: 160 mm; Jmenovitá velikost vstupu: 160 mm; Průtok: 200 m3/hod; Rychlost: 1,3 m/s
QMODEL_c1402c89_5795_47f4_9d0e_0 | Půdorys 1.PP | 6772Obj0000000786 | Kus | Výřivý anemostat | 0 | QMODEL_c1402c89_5795_47f4_9d0e_0 | VV.02.30025 | Podzemní podlaží 1.PP | 0.588 | A1 | NEMSOK - Číslo místnosti: 1.01; Šířka: 0.388 m; Výška: 0.25 m; Průměr: 160 mm; Jmenovitá velikost vstupu: 160 mm; Průtok: 200 m3/hod; Rychlost: 1,3 m/s
QMODEL_c1402c89_5795_47f4_9d0e_0 | Půdorys 1.PP | 6772Obj0000000787 | Kus | Výřivý anemostat | 0 | QMODEL_c1402c89_5795_47f4_9d0e_0 | VV.02.30026 | Podzemní podlaží 1.PP | 0.588 | A1 | NEMSOK - Číslo místnosti: 1.01; Šířka: 0.388 m; Výška: 0.25 m; Průměr: 160 mm; Jmenovitá velikost vstupu: 160 mm; Průtok: 200 m3/hod; Rychlost: 1,3 m/s
QMODEL_c1402c89_5795_47f4_9d0e_0 | Půdorys 1.PP | 6772Obj0000000790 | Kus | Výřivý anemostat | 0 | QMODEL_c1402c89_5795_47f4_9d0e_0 | VV.02.30027 | Podzemní podlaží 1.PP | 0.588 | A1 | NEMSOK - Číslo místnosti: 1.01; Šířka: 0.388 m; Výška: 0.25 m; Průměr: 160 mm; Jmenovitá velikost vstupu: 160 mm; Průtok: 200 m3/hod; Rychlost: 1,3 m/s
QMODEL_c1402c89_5795_47f4_9d0e_0 | Půdorys 1.PP | 6772Obj0000000794 | Kus | Výřivý anemostat | 0 | QMODEL_c1402c89_5795_47f4_9d0e_0 | VV.02.30028 | Podzemní podlaží 1.PP | 0.588 | A1 | NEMSOK - Číslo místnosti: 1.01; Šířka: 0.388 m; Výška: 0.25 m; Průměr: 160 mm; Jmenovitá velikost vstupu: 160 mm; Průtok: 200 m3/hod; Rychlost: 1,3 m/s
QMODEL_c1402c89_5795_47f4_9d0e_0 | Půdorys 1.PP | 6772Obj0000000796 | Kus | Výřivý anemostat | 0 | QMODEL_c1402c89_5795_47f4_9d0e_0 | VV.02.30029 | Podzemní podlaží 1.PP | 0.588 | A1 | NEMSOK - Číslo místnosti: 1.01; Šířka: 0.388 m; Výška: 0.25 m; Průměr: 160 mm; Jmenovitá velikost vstupu: 160 mm; Průtok: 200 m3/hod; Rychlost: 1,3 m/s
QMODEL_c1402c89_5795_47f4_9d0e_0 | Půdorys 1.PP | 6772Obj0000000797 | Kus | Výřivý anemostat | 0 | QMODEL_c1402c89_5795_47f4_9d0e_0 | VV.02.30030 | Podzemní podlaží 1.PP | 0.588 | A1 | NEMSOK - Číslo místnosti: 1.01; Šířka: 0.388 m; Výška: 0.25 m; Průměr: 160 mm; Jmenovitá velikost vstupu: 160 mm; Průtok: 200 m3/hod; Rychlost: 1,3 m/s
QMODEL_c1402c89_5795_47f4_9d0e_0 | Půdorys 1.PP | 6772Obj0000000800 | Kus | Výřivý anemostat | 0 | QMODEL_c1402c89_5795_47f4_9d0e_0 | VV.02.30031 | Podzemní podlaží 1.PP | 0.588 | A1 | NEMSOK - Číslo místnosti: 1.01; Šířka: 0.388 m; Výška: 0.25 m; Průměr: 160 mm; Jmenovitá velikost vstupu: 160 mm; Průtok: 200 m3/hod; Rychlost: 1,3 m/s
QMODEL_c1402c89_5795_47f4_9d0e_0 | Půdorys 1.PP | 6772Obj0000000802 | Kus | Výřivý anemostat | 0 | QMODEL_c1402c89_5795_47f4_9d0e_0 | VV.02.30032 | Podzemní podlaží 1.PP | 0.588 | A1 | NEMSOK - Číslo místnosti: 1.01; Šířka: 0.388 m; Výška: 0.25 m; Průměr: 160 mm; Jmenovitá velikost vstupu: 160 mm; Průtok: 200 m3/hod; Rychlost: 1,3 m/s
QMODEL_c1402c89_5795_47f4_9d0e_0 | Půdorys 1.PP | 6772Obj0000000804 | Kus | Výřivý anemostat | 0 | QMODEL_c1402c89_5795_47f4_9d0e_0 | VV.02.30033 | Podzemní podlaží 1.PP | 0.588 | A1 | NEMSOK - Číslo místnosti: 1.01; Šířka: 0.388 m; Výška: 0.25 m; Průměr: 160 mm; Jmenovitá velikost vstupu: 160 mm; Průtok: 200 m3/hod; Rychlost: 1,3 m/s
QMODEL_c1402c89_5795_47f4_9d0e_0 | Půdorys 1.PP | 6772Obj0000000808 | Kus | Výřivý anemostat | 0 | QMODEL_c1402c89_5795_47f4_9d0e_0 | VV.02.30034 | Podzemní podlaží 1.PP | 0.588 | A1 | NEMSOK - Číslo místnosti: 1.01; Šířka: 0.388 m; Výška: 0.25 m; Průměr: 160 mm; Jmenovitá velikost vstupu: 160 mm; Průtok: 200 m3/hod; Rychlost: 1,3 m/s
QMODEL_c1402c89_5795_47f4_9d0e_0 | Půdorys 1.PP | 6772Obj0000000810 | Kus | Výřivý anemostat | 0 | QMODEL_c1402c89_5795_47f4_9d0e_0 | VV.02.30035 | Podzemní podlaží 1.PP | 0.588 | A1 | NEMSOK - Číslo místnosti: 1.01; Šířka: 0.388 m; Výška: 0.25 m; Průměr: 160 mm; Jmenovitá velikost vstupu: 160 mm; Průtok: 200 m3/hod; Rychlost: 1,3 m/s
QMODEL_c1402c89_5795_47f4_9d0e_0 | Půdorys 1.PP | 6772Obj0000000812 | Kus | Výřivý anemostat | 0 | QMODEL_c1402c89_5795_47f4_9d0e_0 | VV.02.30036 | Podzemní podlaží 1.PP | 0.588 | A1 | NEMSOK - Číslo místnosti: 1.01; Šířka: 0.388 m; Výška: 0.25 m; Průměr: 160 mm; Jmenovitá velikost vstupu: 160 mm; Průtok: 200 m3/hod; Rychlost: 1,3 m/s
QMODEL_c1402c89_5795_47f4_9d0e_0 | Půdorys 1.PP | 6772Obj0000000814 | Kus | Výřivý anemostat | 0 | QMODEL_c1402c89_5795_47f4_9d0e_0 | VV.02.30037 | Podzemní podlaží 1.PP | 0.588 | A1 | NEMSOK - Číslo místnosti: 1.01; Šířka: 0.388 m; Výška: 0.25 m; Průměr: 160 mm; Jmenovitá velikost vstupu: 160 mm; Průtok: 200 m3/hod; Rychlost: 1,3 m/s
QMODEL_c1402c89_5795_47f4_9d0e_0 | Půdorys 1.PP | 6772Obj0000000820 | Kus | Výřivý anemostat | 0 | QMODEL_c1402c89_5795_47f4_9d0e_0 | VV.02.30038 | Podzemní podlaží 1.PP | 0.588 | A1 | NEMSOK - Číslo místnosti: 1.01; Šířka: 0.388 m; Výška: 0.25 m; Průměr: 160 mm; Jmenovitá velikost vstupu: 160 mm; Průtok: 200 m3/hod; Rychlost: 1,3 m/s
QMODEL_c1402c89_5795_47f4_9d0e_0 | Půdorys 1.PP | 6772Obj0000000869 | Kus | Výřivý anemostat | 0 | QMODEL_c1402c89_5795_47f4_9d0e_0 | VV.02.30039 | Podzemní podlaží 1.PP | 0.588 | A1 | NEMSOK - Číslo místnosti: 1.01; Šířka: 0.388 m; Výška: 0.25 m; Průměr: 160 mm; Jmenovitá velikost vstupu: 160 mm; Průtok: 200 m3/hod; Rychlost: 1,3 m/s
QMODEL_c1402c89_5795_47f4_9d0e_0 | Půdorys 1.PP | 6772Obj0000000928 | Kus | Výřivý anemostat | 0 | QMODEL_c1402c89_5795_47f4_9d0e_0 | VV.02.30040 | Podzemní podlaží 1.PP | 0.588 | A1 | NEMSOK - Číslo místnosti: 1.01; Šířka: 0.388 m; Výška: 0.25 m; Průměr: 160 mm; Jmenovitá velikost vstupu: 160 mm; Průtok: 200 m3/hod; Rychlost: 1,3 m/s
QMODEL_c1402c89_5795_47f4_9d0e_0 | Půdorys 1.PP | 6772Obj0000000947 | Kus | Výřivý anemostat | 0 | QMODEL_c1402c89_5795_47f4_9d0e_0 | VV.02.30041 | Podzemní podlaží 1.PP | 0.588 | A1 | NEMSOK - Číslo místnosti: 1.01; Šířka: 0.388 m; Výška: 0.25 m; Průměr: 160 mm; Jmenovitá velikost vstupu: 160 mm; Průtok: 200 m3/hod; Rychlost: 1,3 m/s
QMODEL_c1402c89_5795_47f4_9d0e_0 | Půdorys 1.PP | 6772Obj0000000949 | Kus | Výřivý anemostat | 0 | QMODEL_c1402c89_5795_47f4_9d0e_0 | VV.02.30042 | Podzemní podlaží 1.PP | 0.588 | A1 | NEMSOK - Číslo místnosti: 1.01; Šířka: 0.388 m; Výška: 0.25 m; Průměr: 160 mm; Jmenovitá velikost vstupu: 160 mm; Průtok: 200 m3/hod; Rychlost: 1,3 m/s
QMODEL_c1402c89_5795_47f4_9d0e_0 | Půdorys 1.PP | 6772Obj0000000951 | Kus | Výřivý anemostat | 0 | QMODEL_c1402c89_5795_47f4_9d0e_0 | VV.02.30043 | Podzemní podlaží 1.PP | 0.588 | A1 | NEMSOK - Číslo místnosti: 1.01; Šířka: 0.388 m; Výška: 0.25 m; Průměr: 160 mm; Jmenovitá velikost vstupu: 160 mm; Průtok: 200 m3/hod; Rychlost: 1,3 m/s
QMODEL_c1402c89_5795_47f4_9d0e_0 | Půdorys 1.PP | 6772Obj0000000953 | Kus | Výřivý anemostat | 0 | QMODEL_c1402c89_5795_47f4_9d0e_0 | VV.02.30044 | Podzemní podlaží 1.PP | 0.588 | A1 | NEMSOK - Číslo místnosti: 1.01; Šířka: 0.388 m; Výška: 0.25 m; Průměr: 160 mm; Jmenovitá velikost vstupu: 160 mm; Průtok: 200 m3/hod; Rychlost: 1,3 m/s
QMODEL_c1402c89_5795_47f4_9d0e_0 | Půdorys 1.PP | 6772Obj0000001212 | Kus | Výřivý anemostat | 0 | QMODEL_c1402c89_5795_47f4_9d0e_0 | VV.02.30045 | Podzemní podlaží 1.PP | 0.588 | A1 | NEMSOK - Číslo místnosti: 1.01; Šířka: 0.388 m; Výška: 0.25 m; Průměr: 160 mm; Jmenovitá velikost vstupu: 160 mm; Průtok: 200 m3/hod; Rychlost: 1,3 m/s
QMODEL_c1402c89_5795_47f4_9d0e_0 | Půdorys 1.PP | 6772Obj0000001400 | Kus | Výřivý anemostat | 0 | QMODEL_c1402c89_5795_47f4_9d0e_0 | VV.02.30047 | Podzemní podlaží 1.PP | 0.588 | A1 | NEMSOK - Číslo místnosti: 1.01; Šířka: 0.388 m; Výška: 0.25 m; Průměr: 160 mm; Jmenovitá velikost vstupu: 160 mm; Průtok: 200 m3/hod; Rychlost: 1,3 m/s
QMODEL_c1402c89_5795_47f4_9d0e_0 | Půdorys 1.PP | 6772Obj0000001466 | Kus | Výřivý anemostat | 0 | QMODEL_c1402c89_5795_47f4_9d0e_0 | VV.02.30048 | Podzemní podlaží 1.PP | 0.588 | A1 | NEMSOK - Číslo místnosti: 1.01; Šířka: 0.388 m; Výška: 0.25 m; Průměr: 160 mm; Jmenovitá velikost vstupu: 160 mm; Průtok: 200 m3/hod; Rychlost: 1,3 m/s
QMODEL_c1402c89_5795_47f4_9d0e_0 | Půdorys 1.PP | 6772Obj0000001493 | Kus | Výřivý anemostat | 0 | QMODEL_c1402c89_5795_47f4_9d0e_0 | VV.02.30049 | Podzemní podlaží 1.PP | 0.588 | A1 | NEMSOK - Číslo místnosti: 1.01; Šířka: 0.388 m; Výška: 0.25 m; Průměr: 160 mm; Jmenovitá velikost vstupu: 160 mm; Průtok: 200 m3/hod; Rychlost: 1,3 m/s
QMODEL_c1402c89_5795_47f4_9d0e_0 | Půdorys 1.PP | 6772Obj0000001634 | Kus | Výřivý anemostat | 0 | QMODEL_c1402c89_5795_47f4_9d0e_0 | VV.02.30050 | Podzemní podlaží 1.PP | 0.588 | A1 | NEMSOK - Číslo místnosti: 1.01; Šířka: 0.388 m; Výška: 0.25 m; Průměr: 160 mm; Jmenovitá velikost vstupu: 160 mm; Průtok: 200 m3/hod; Rychlost: 1,3 m/s
ZG Klappe | Půdorys 1.PP | 6772Obj0000160438 | Stk | Objekt | 0 | ZG Klappe | KA.02.30001 | Podzemní podlaží 1.PP | 0.3 | - | NEMSOK - Číslo místnosti: -1.63; Jmenovitá velikost vstupu: DN125; Průtok: 100 m3/h; Dolní_hrana: 0 m; Horní_hrana: 0 m; Plocha: 1; K_GEWERK: 1; K_BLOCKNAME: ZG Klappe; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|300.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\zentralgeräte\zg klappen\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 300; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/19; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
ABL Regler RN | Půdorys 1.PP | 6772Obj0000139763 | Stk | Objekt | 0 | ABL Regler RN | KA.02.30002 | Podzemní podlaží 1.PP | 0.31 | - | NEMSOK - Číslo místnosti: -1.63; Jmenovitá velikost vstupu: DN125; Průtok: 100 m3/h; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/13; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
ABL Regler RN | Půdorys 1.PP | 6772Obj0000139753 | Stk | Objekt | 0 | ABL Regler RN | KA.02.30003 | Podzemní podlaží 1.PP | 0.31 | - | NEMSOK - Číslo místnosti: -1.63; Jmenovitá velikost vstupu: DN125; Průtok: 225 m3/h; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/13; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
ZG Klappe | Půdorys 1.PP | 6772Obj0000160454 | Stk | Objekt | 0 | ZG Klappe | KA.02.30004 | Podzemní podlaží 1.PP | 0.3 | - | NEMSOK - Číslo místnosti: -1.63; Jmenovitá velikost vstupu: DN125; Průtok: 225 m3/h; Dolní_hrana: 0 m; Horní_hrana: 0 m; Plocha: 1; K_GEWERK: 1; K_BLOCKNAME: ZG Klappe; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|300.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\zentralgeräte\zg klappen\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 300; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/19; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
ZG Klappe | Půdorys 1.PP | 6772Obj0000160422 | Stk | Objekt | 0 | ZG Klappe | KA.02.30005 | Podzemní podlaží 1.PP | 0.3 | - | NEMSOK - Číslo místnosti: -1.63; Jmenovitá velikost vstupu: DN125; Průtok: 100 m3/h; Dolní_hrana: 0 m; Horní_hrana: 0 m; Plocha: 1; K_GEWERK: 1; K_BLOCKNAME: ZG Klappe; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|300.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\zentralgeräte\zg klappen\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 300; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/19; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
ABL Regler RN | Půdorys 1.PP | 6772Obj0000139743 | Stk | Objekt | 0 | ABL Regler RN | KA.02.30007 | Podzemní podlaží 1.PP | 0.31 | - | NEMSOK - Číslo místnosti: -1.63; Jmenovitá velikost vstupu: DN125; Průtok: 100 m3/h; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/13; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
ABL Regler RN | Půdorys 1.PP | 6772Obj0000139733 | Stk | Objekt | 0 | ABL Regler RN | KA.02.30008 | Podzemní podlaží 1.PP | 0.31 | - | NEMSOK - Číslo místnosti: -1.63; Jmenovitá velikost vstupu: DN125; Průtok: 225 m3/h; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/13; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
ZG Klappe | Půdorys 1.PP | 6772Obj0000160470 | Stk | Objekt | 0 | ZG Klappe | KA.02.30009 | Podzemní podlaží 1.PP | 0.3 | - | NEMSOK - Číslo místnosti: -1.63; Jmenovitá velikost vstupu: DN125; Průtok: 225 m3/h; Dolní_hrana: 0 m; Horní_hrana: 0 m; Plocha: 1; K_GEWERK: 1; K_BLOCKNAME: ZG Klappe; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|300.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\zentralgeräte\zg klappen\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 300; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/19; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
ABL Regler RN | Půdorys 1.PP | 6772Obj0000139672 | Stk | Objekt | 0 | ABL Regler RN | KA.02.30010 | Podzemní podlaží 1.PP | 0.31 | - | NEMSOK - Číslo místnosti: -1.63; Jmenovitá velikost vstupu: DN160; Průtok: 100 m3/h; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|160.00|160.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN160; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/13; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN160; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
ABL Regler RN | Půdorys 1.PP | 6772Obj0000139723 | Stk | Objekt | 0 | ABL Regler RN | KA.02.30011 | Podzemní podlaží 1.PP | 0.31 | - | NEMSOK - Číslo místnosti: -1.63; Jmenovitá velikost vstupu: DN125; Průtok: 100 m3/h; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/13; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
ZG Klappe | Půdorys 1.PP | 6772Obj0000160364 | Stk | Objekt | 0 | ZG Klappe | KA.02.30012 | Podzemní podlaží 1.PP | 0.3 | - | NEMSOK - Číslo místnosti: -1.63; Jmenovitá velikost vstupu: DN125; Průtok: 100 m3/h; Dolní_hrana: 0 m; Horní_hrana: 0 m; Plocha: 1; K_GEWERK: 1; K_BLOCKNAME: ZG Klappe; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|300.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\zentralgeräte\zg klappen\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 300; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/19; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
ABL Regler RN | Půdorys 1.PP | 6772Obj0000139709 | Stk | Objekt | 0 | ABL Regler RN | KA.02.30013 | Podzemní podlaží 1.PP | 0.31 | - | NEMSOK - Číslo místnosti: -1.64; Jmenovitá velikost vstupu: DN125; Průtok: 100 m3/h; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/13; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
ABL Regler RN | Půdorys 1.PP | 6772Obj0000139699 | Stk | Objekt | 0 | ABL Regler RN | KA.02.30014 | Podzemní podlaží 1.PP | 0.31 | - | NEMSOK - Číslo místnosti: -1.64; Jmenovitá velikost vstupu: DN160; Průtok: 100 m3/h; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|160.00|160.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN160; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/13; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN160; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
ZG Klappe | Půdorys 1.PP | 6772Obj0000160380 | Stk | Objekt | 0 | ZG Klappe | KA.02.30015 | Podzemní podlaží 1.PP | 0.3 | - | NEMSOK - Číslo místnosti: -1.64; Jmenovitá velikost vstupu: DN125; Průtok: 100 m3/h; Dolní_hrana: 0 m; Horní_hrana: 0 m; Plocha: 1; K_GEWERK: 1; K_BLOCKNAME: ZG Klappe; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|300.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\zentralgeräte\zg klappen\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 300; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/19; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
Bundkragen | Půdorys 1.PP | 6772Obj0000136127 | Stk | Objekt | 0 | Bundkragen | TA.02.30013 | Podzemní podlaží 1.PP | 0.05 | A1 | NEMSOK - Šířka: 1.6 m; Výška: 0.16 m; Průměr: 160; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: Bundkragen; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|160.00|160.00|50.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_DWGNAME: ${PROD}l\einbauteile rund\bundkragen\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 50; L_BES_DIM: DN160; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/13; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ
QMODEL_8f547253_65b4_4e98_96f4_2 | Půdorys 1.PP | 6772Obj0000135904 | Kus | Objekt | 0 | QMODEL_8f547253_65b4_4e98_96f4_2 | VV.02.30001 | Podzemní podlaží 1.PP | 0.38 | A1 | NEMSOK - Číslo místnosti: -1.58; Šířka: 0.38 m; Výška: 0.215 m; Průměr: 160 mm; Jmenovitá velikost vstupu: 125 mm; Průtok: 100 m3/hod; Rychlost: 1,3 m/s
QMODEL_8f547253_65b4_4e98_96f4_2 | Půdorys 1.PP | 6772Obj0000135902 | Kus | Objekt | 0 | QMODEL_8f547253_65b4_4e98_96f4_2 | VV.02.30002 | Podzemní podlaží 1.PP | 0.38 | A1 | NEMSOK - Číslo místnosti: -1.58; Šířka: 0.38 m; Výška: 0.215 m; Průměr: 160 mm; Jmenovitá velikost vstupu: 125 mm; Průtok: 100 m3/hod; Rychlost: 1,3 m/s
ABL Regler RN | Půdorys 1.PP | 6772Obj0000000905 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.02.30020 | Podzení podlaží 1.PP | 0.31 | A1 | NEMSOK - Číslo místnosti: -1.36; Jmenovitá velikost vstupu: DN125; Průtok: 1,002 m3/s; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Blech ummantelt|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/11/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
ABL Regler RN | Půdorys 1.PP | 6772Obj0000001468 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.02.30034 | Podzení podlaží 1.PP | 0.31 | A1 | NEMSOK - Číslo místnosti: -1.37; Jmenovitá velikost vstupu: DN125; Průtok: 1,002 m3/s; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Blech ummantelt|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/11/07; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
ABL Regler RN | Půdorys 1.PP | 6772Obj0000000946 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.02.30022 | Podzení podlaží 1.PP | 0.31 | A1 | NEMSOK - Číslo místnosti: -1.39; Jmenovitá velikost vstupu: DN125; Průtok: 1,002 m3/s; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Blech ummantelt|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/11/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
ABL Regler RN | Půdorys 1.PP | 6772Obj0000001218 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.02.30031 | Podzení podlaží 1.PP | 0.31 | A1 | NEMSOK - Číslo místnosti: -1.34; Jmenovitá velikost vstupu: DN125; Průtok: 1,002 m3/s; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Blech ummantelt|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/11/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
ABL Regler RN | Půdorys 1.PP | 6772Obj0000001202 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.02.30026 | Podzení podlaží 1.PP | 0.31 | A1 | NEMSOK - Číslo místnosti: -1.34; Jmenovitá velikost vstupu: DN125; Průtok: 1,002 m3/s; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Blech ummantelt|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/11/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
ABL Regler RN | Půdorys 1.PP | 6772Obj0000001201 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.02.30025 | Podzení podlaží 1.PP | 0.31 | A1 | NEMSOK - Číslo místnosti: -1.34; Jmenovitá velikost vstupu: DN125; Průtok: 1,002 m3/s; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Blech ummantelt|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/11/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
ABL Regler RN | Půdorys 1.PP | 6772Obj0000001200 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.02.30024 | Podzení podlaží 1.PP | 0.31 | A1 | NEMSOK - Číslo místnosti: -1.34; Jmenovitá velikost vstupu: DN125; Průtok: 1,002 m3/s; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Blech ummantelt|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/11/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
ABL Regler konst. EN mit Antrieb | Půdorys 1.PP | 6772Obj0000059758 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler konst. EN mit Antrieb | KA.02.30040 | Podzení podlaží 1.PP | 0.31 | A1 | NEMSOK - Číslo místnosti: -1.57; Jmenovitá velikost vstupu: DN160; Průtok: 1,002 m3/s; K_GEWERK: 1; K_BLOCKNAME: ABL Regler konst. EN mit Antrieb; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|160.00|160.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_DWGNAME: ${PROD}l\einbauteile\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Blech ummantelt|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN160; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/10; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN160; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
ABL Regler RN | Půdorys 1.PP | 6772Obj0000000906 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.02.30021 | Podzení podlaží 1.PP | 0.31 | A1 | NEMSOK - Číslo místnosti: -1.53; Jmenovitá velikost vstupu: DN125; Průtok: 1,002 m3/s; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Blech ummantelt|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/11/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
ABL Regler RN | Půdorys 1.PP | 6772Obj0000001402 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.02.30033 | Podzení podlaží 1.PP | 0.31 | A1 | NEMSOK - Číslo místnosti: -1.53; Jmenovitá velikost vstupu: DN125; Průtok: 1,002 m3/s; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Blech ummantelt|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/11/03; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
ABL Regler RN | Půdorys 1.PP | 6772Obj0000001208 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.02.30028 | Podzení podlaží 1.PP | 0.31 | A1 | NEMSOK - Číslo místnosti: -1.53; Jmenovitá velikost vstupu: DN125; Průtok: 1,002 m3/s; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Blech ummantelt|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/11/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
ABL Regler konst. EN mit Antrieb | Půdorys 1.PP | 6772Obj0000138366 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler konst. EN mit Antrieb | KA.02.30041 | Podzení podlaží 1.PP | 0.26 | A1 | NEMSOK - Číslo místnosti: -1.52; Jmenovitá velikost vstupu: DN125; Průtok: 1,002 m3/s; K_GEWERK: 1; K_BLOCKNAME: ABL Regler konst. EN mit Antrieb; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|260.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Blech ummantelt|40.00; L_BES_LAENGE: 260; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/13; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
ABL Regler RN | Půdorys 1.PP | 6772Obj0000000833 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.02.30016 | Podzení podlaží 1.PP | 0.31 | A1 | NEMSOK - Číslo místnosti: -1.51; Jmenovitá velikost vstupu: DN125; Průtok: 1,002 m3/s; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Blech ummantelt|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/11/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
ABL Regler RN | Půdorys 1.PP | 6772Obj0000000868 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.02.30017 | Podzení podlaží 1.PP | 0.31 | A1 | NEMSOK - Číslo místnosti: -1.51; Jmenovitá velikost vstupu: DN125; Průtok: 1,002 m3/s; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Blech ummantelt|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/11/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
ABL Regler RN | Půdorys 1.PP | 6772Obj0000000882 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.02.30019 | Podzení podlaží 1.PP | 0.31 | A1 | NEMSOK - Číslo místnosti: -1.50; Jmenovitá velikost vstupu: DN125; Průtok: 1,002 m3/s; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Blech ummantelt|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/11/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
ABL Regler RN | Půdorys 1.PP | 6772Obj0000001501 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.02.30035 | Podzení podlaží 1.PP | 0.31 | A1 | NEMSOK - Číslo místnosti: -1.50; Jmenovitá velikost vstupu: DN125; Průtok: 1,002 m3/s; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Blech ummantelt|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/11/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
ABL Regler RN | Půdorys 1.PP | 6772Obj0000001209 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.02.30029 | Podzení podlaží 1.PP | 0.31 | A1 | NEMSOK - Číslo místnosti: -1.50; Jmenovitá velikost vstupu: DN125; Průtok: 1,002 m3/s; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Blech ummantelt|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/11/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
ABL Regler RN | Půdorys 1.PP | 6772Obj0000000871 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.02.30018 | Podzení podlaží 1.PP | 0.31 | A1 | NEMSOK - Číslo místnosti: -1.49; Jmenovitá velikost vstupu: DN125; Průtok: 1,002 m3/s; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Blech ummantelt|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/11/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
ABL Regler RN | Půdorys 1.PP | 6772Obj0000001216 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.02.30030 | Podzení podlaží 1.PP | 0.31 | A1 | NEMSOK - Číslo místnosti: -1.49; Jmenovitá velikost vstupu: DN125; Průtok: 1,002 m3/s; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Blech ummantelt|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/11/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
ABL Regler RN | Půdorys 1.PP | 6772Obj0000001595 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.02.30036 | Podzení podlaží 1.PP | 0.31 | A1 | NEMSOK - Číslo místnosti: -1.46; Jmenovitá velikost vstupu: DN125; Průtok: 1,002 m3/s; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Blech ummantelt|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/11/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
ABL Regler RN | Půdorys 1.PP | 6772Obj0000001636 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.02.30037 | Podzení podlaží 1.PP | 0.31 | A1 | NEMSOK - Číslo místnosti: -1.47; Jmenovitá velikost vstupu: DN125; Průtok: 1,002 m3/s; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.1; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Blech ummantelt|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/11/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální; K_ETAGE: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)|Blech ST37 verzinkt|SPIRO POTRUBÍ|OVALROHR; K_EBT_BOX_WC: 300.252|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
ABL Regler RN | Půdorys 1.PP | 6772Obj0000001221 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.02.30032 | Podzení podlaží 1.PP | 0.31 | A1 | NEMSOK - Číslo místnosti: -1.47; Jmenovitá velikost vstupu: DN160; Průtok: 1,002 m3/s; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|160.00|160.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Blech ummantelt|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN160; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/11/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN160; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
1610814884832 | Půdorys 1.PP | 6772Obj0000139181 | Kus | Objekt | 0
1610814885024 | Půdorys 1.PP | 6772Obj0000139182 | Kus | Objekt | 0
1610814885072 | Půdorys 1.PP | 6772Obj0000139183 | Kus | Objekt | 0
1610814745616 | Půdorys 1.PP | 6772Obj0000139184 | Kus | Objekt | 0
1610814906128 | Půdorys 1.PP | 6772Obj0000139185 | Kus | Objekt | 0
1610814826912 | Půdorys 1.PP | 6772Obj0000139186 | Kus | Objekt | 0
1610814908016 | Půdorys 1.PP | 6772Obj0000139187 | Kus | Objekt | 0
1610814940016 | Půdorys 1.PP | 6772Obj0000139188 | Kus | Objekt | 0
1610814975952 | Půdorys 1.PP | 6772Obj0000139190 | Kus | Objekt | 0
1610815006080 | Půdorys 1.PP | 6772Obj0000139191 | Kus | Objekt | 0
1610815035808 | Půdorys 1.PP | 6772Obj0000139192 | Kus | Objekt | 0
1610815049632 | Půdorys 1.PP | 6772Obj0000139193 | Kus | Objekt | 0
1610815049680 | Půdorys 1.PP | 6772Obj0000139194 | Kus | Objekt | 0
1610815050224 | Půdorys 1.PP | 6772Obj0000139195 | Kus | Objekt | 0
1610815050272 | Půdorys 1.PP | 6772Obj0000139196 | Kus | Objekt | 0
1610815050560 | Půdorys 1.PP | 6772Obj0000139197 | Kus | Objekt | 0
1610814975136 | Půdorys 1.PP | 6772Obj0000139198 | Kus | Objekt | 0
1610815093824 | Půdorys 1.PP | 6772Obj0000139199 | Kus | Objekt | 0
1610815084960 | Půdorys 1.PP | 6772Obj0000139200 | Kus | Objekt | 0
1610815101632 | Půdorys 1.PP | 6772Obj0000139201 | Kus | Objekt | 0
1610815101680 | Půdorys 1.PP | 6772Obj0000139202 | Kus | Objekt | 0
1610829781696 | Půdorys 1.PP | 6772Obj0000139204 | Kus | Objekt | 0
1610829855856 | Půdorys 1.PP | 6772Obj0000139205 | Kus | Objekt | 0
1610831833312 | Půdorys 1.PP | 6772Obj0000139212 | Kus | Objekt | 0
1610831833456 | Půdorys 1.PP | 6772Obj0000139213 | Kus | Objekt | 0
1610831453440 | Půdorys 1.PP | 6772Obj0000139214 | Kus | Objekt | 0
1610831777744 | Půdorys 1.PP | 6772Obj0000139215 | Kus | Objekt | 0
1610831761024 | Půdorys 1.PP | 6772Obj0000139216 | Kus | Objekt | 0
1610832143888 | Půdorys 1.PP | 6772Obj0000139217 | Kus | Objekt | 0
1610832176368 | Půdorys 1.PP | 6772Obj0000139218 | Kus | Objekt | 0
1610832875088 | Půdorys 1.PP | 6772Obj0000139219 | Kus | Objekt | 0
1610830825696 | Půdorys 1.PP | 6772Obj0000139220 | Kus | Objekt | 0
1610814783936 | Půdorys 1.PP | 6772Obj0000139189 | Kus | Objekt | 0 | 1610814783936
QMODEL_5656f5c0_340b_44dc_9391_0 | Půdorys 1.NP | 6782Obj0798478922 | Kus | Objekt | 0 | QMODEL_5656f5c0_340b_44dc_9391_0 | VV.03.3071 | Nadzemní podlaží 1.NP | 0.588 | A1 | NEMSOK - Číslo místnosti: K1.16; Šířka: 0.388 m; Výška: 0.16 m; Průměr: 160 mm; Jmenovitá velikost vstupu: 160 mm; Průtok: 230 m3/hod; Rychlost: 2,9 m/s
QMODEL_5656f5c0_340b_44dc_9391_0 | Půdorys 1.NP | 6782Obj0798478927 | Kus | Objekt | 0 | QMODEL_5656f5c0_340b_44dc_9391_0 | VV.03.3072 | Nadzemní podlaží 1.NP | 0.588 | A1 | NEMSOK - Číslo místnosti: K1.09; Šířka: 0.388 m; Výška: 0.25 m; Průměr: 160 mm; Jmenovitá velikost vstupu: 160 mm; Průtok: 200 m3/hod; Rychlost: 2,5 m/s
QMODEL_5656f5c0_340b_44dc_9391_0 | Půdorys 1.NP | 6782Obj0798478929 | Kus | Objekt | 0 | QMODEL_5656f5c0_340b_44dc_9391_0 | VV.03.3073 | Nadzemní podlaží 1.NP | 0.588 | A1 | NEMSOK - Číslo místnosti: K1.09; Šířka: 0.388 m; Výška: 0.25 m; Průměr: 160 mm; Jmenovitá velikost vstupu: 160 mm; Průtok: 200 m3/hod; Rychlost: 2,9 m/s
QMODEL_816b41ac_f5c9_475b_87ff_3 | Půdorys 1.NP | 6782Obj0798478935 | Kus | Objekt | 0 | QMODEL_816b41ac_f5c9_475b_87ff_3 | VV.03.3074 | Nadzemní podlaží 1.NP | 0.388 | A1 | NEMSOK - Číslo místnosti: K1.08; Šířka: 0.26 m; Výška: 0.255 m; Průměr: 100 mm; Jmenovitá velikost vstupu: 100 mm; Průtok: 150 m3/hod; Rychlost: 1,9 m/s
QMODEL_5656f5c0_340b_44dc_9391_0 | Půdorys 1.NP | 6782Obj0798479108 | Kus | Objekt | 0 | QMODEL_5656f5c0_340b_44dc_9391_0 | VV.03.3076 | Nadzemní podlaží 1.NP | 0.58 | A1 | NEMSOK - Číslo místnosti: K1.07; Šířka: 0.38 m; Výška: 0.25 m; Průměr: 160 mm; Jmenovitá velikost vstupu: 160 mm; Průtok: 250 m3/hod; Rychlost: 3,2 m/s
QMODEL_5656f5c0_340b_44dc_9391_0 | Půdorys 1.NP | 6782Obj0798479134 | Kus | Objekt | 0 | QMODEL_5656f5c0_340b_44dc_9391_0 | VV.03.3078 | Nadzemní podlaží 1.NP | 0.58 | A1 | NEMSOK - Číslo místnosti: K1.07; Šířka: 0.38 m; Výška: 0.25 m; Průměr: 160 mm; Jmenovitá velikost vstupu: 160 mm; Průtok: 250 m3/hod; Rychlost: 3,2 m/s
QMODEL_5656f5c0_340b_44dc_9391_0 | Půdorys 1.NP | 6782Obj0798479136 | Kus | Objekt | 0 | QMODEL_5656f5c0_340b_44dc_9391_0 | VV.03.3079 | Nadzemní podlaží 1.NP | 0.58 | A1 | NEMSOK - Číslo místnosti: K1.07; Šířka: 0.38 m; Výška: 0.25 m; Průměr: 160 mm; Jmenovitá velikost vstupu: 160 mm; Průtok: 250 m3/hod; Rychlost: 3,2 m/s
QMODEL_816b41ac_f5c9_475b_87ff_3 | Půdorys 1.NP | 6782Obj0798478937 | Kus | Objekt | 0 | QMODEL_816b41ac_f5c9_475b_87ff_3 | VV.03.3075 | Nadzemní podlaží 1.NP | 0.388 | A1 | NEMSOK - Číslo místnosti: K1.11; Šířka: 0.26 m; Výška: 0.255 m; Průměr: 100 mm; Jmenovitá velikost vstupu: 100 mm; Průtok: 100 m3/hod; Rychlost: 1,3 m/s
Schalldämpfer | Půdorys 1.NP | 6782Obj0798478904 | Stk | Objekt | 0 | Schalldämpfer | KA.03.30100 | Nadzení podlaží 1.NP | 1.25 | B | NEMSOK - Číslo místnosti: K1.09; Jmenovitá velikost vstupu: DN250; Průtok: 1,002 m3/s; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: Schalldämpfer; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|250.00|250.00|1250.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.1; K_DWGNAME: ${PROD}l\einbauteile\schalldaempfer\; K_MATERIAL: POZINK|0.00; K_PROFIL: ||||; K_ISOLATION: Alu kaschiert|100.00; L_BES_LAENGE: 1250; L_BES_DIM: DN250; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/05/10; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: POZINK; Jmenovitá velikost výstupu: DN250; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální; K_EBT_BOX_WC: 18244.282|7733.164|3864.000|17944.282|6483.164|3564.000|0.000|0.000|0.000|1.000
Schalldämpfer | Půdorys 1.NP | 6782Obj0798478908 | Stk | Objekt | 0 | Schalldämpfer | KA.03.30101 | Nadzení podlaží 1.NP | 1.25 | B | NEMSOK - Číslo místnosti: K1.09; Jmenovitá velikost vstupu: DN250; Průtok: 1,002 m3/s; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: Schalldämpfer; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|250.00|250.00|1250.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.1; K_DWGNAME: ${PROD}l\einbauteile\schalldaempfer\; K_MATERIAL: POZINK|0.00; K_PROFIL: ||||; K_ISOLATION: Alu kaschiert|100.00; L_BES_LAENGE: 1250; L_BES_DIM: DN250; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/05/10; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: POZINK; Jmenovitá velikost výstupu: DN250; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální; K_EBT_BOX_WC: 18757.282|8983.164|3864.000|18457.282|7733.164|3564.000|0.000|0.000|0.000|1.000
Schalldämpfer | Půdorys 1.NP | 6782Obj0798478910 | Stk | Objekt | 0 | Schalldämpfer | KA.03.30102 | Nadzení podlaží 1.NP | 1.25 | B | NEMSOK - Číslo místnosti: K1.09; Jmenovitá velikost vstupu: DN250; Průtok: 1,002 m3/s; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: Schalldämpfer; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|250.00|250.00|1250.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.1; K_DWGNAME: ${PROD}l\einbauteile\schalldaempfer\; K_MATERIAL: POZINK|0.00; K_PROFIL: ||||; K_ISOLATION: Alu kaschiert|100.00; L_BES_LAENGE: 1250; L_BES_DIM: DN250; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/05/10; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: POZINK; Jmenovitá velikost výstupu: DN250; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální; K_EBT_BOX_WC: 18757.282|8983.164|3864.000|18457.282|7733.164|3564.000|0.000|0.000|0.000|1.000
Schalldämpfer | Půdorys 1.NP | 6782Obj0798478916 | Stk | Objekt | 0 | Schalldämpfer | KA.03.30103 | Nadzení podlaží 1.NP | 1.25 | B | NEMSOK - Číslo místnosti: K1.09; Jmenovitá velikost vstupu: DN250; Průtok: 1,002 m3/s; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: Schalldämpfer; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|250.00|250.00|1250.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_DWGNAME: ${PROD}l\einbauteile\schalldaempfer\; K_MATERIAL: POZINK|0.00; K_PROFIL: ||||; K_ISOLATION: Blech ummantelt|40.00; L_BES_LAENGE: 1250; L_BES_DIM: DN250; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/05/10; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: POZINK; Jmenovitá velikost výstupu: DN250; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
Schalldämpfer | Půdorys 1.NP | 6782Obj0798478917 | Stk | Objekt | 0 | Schalldämpfer | KA.03.30104 | Nadzení podlaží 1.NP | 1.25 | B | NEMSOK - Číslo místnosti: K1.09; Jmenovitá velikost vstupu: DN250; Průtok: 1,002 m3/s; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: Schalldämpfer; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|250.00|250.00|1250.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_DWGNAME: ${PROD}l\einbauteile\schalldaempfer\; K_MATERIAL: POZINK|0.00; K_PROFIL: ||||; K_ISOLATION: Blech ummantelt|40.00; L_BES_LAENGE: 1250; L_BES_DIM: DN250; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/05/10; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: POZINK; Jmenovitá velikost výstupu: DN250; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
Schalldämpfer | Půdorys 1.NP | 6782Obj0798478918 | Stk | Objekt | 0 | Schalldämpfer | KA.03.30105 | Nadzení podlaží 1.NP | 1.25 | B | NEMSOK - Číslo místnosti: K1.10; Jmenovitá velikost vstupu: DN250; Průtok: 1,002 m3/s; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: Schalldämpfer; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|250.00|250.00|1250.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_DWGNAME: ${PROD}l\einbauteile\schalldaempfer\; K_MATERIAL: POZINK|0.00; K_PROFIL: ||||; K_ISOLATION: Blech ummantelt|40.00; L_BES_LAENGE: 1250; L_BES_DIM: DN250; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2022/05/10; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: POZINK; Jmenovitá velikost výstupu: DN250; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
