Properties of the parts of a building model (IFC2X3), part 19 of 51

# IfcFlowFitting (2887)
Name | In | Jednotka | Délka (m) | Označení | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_DIM | L_BES_DIM_A2 | L_BES_DIM_B2 | L_BES_DIM_A | K_VOLSTROM | K_MLH_GOST = K_MLD_GOST | K_LISTVALUE | Kód prvku | Třída reakce na oheň | Allright_Stavebni_dil_ID | Název_objektu | K_EBT_BOX_WC | Plocha | L_BES_LAENGE | K_INTERNAL_ISO | Tloušťka (m) | Součinitel tepelné vodivost
2010456056x50504x50904xxxx0 | Půdorys 1.PP | Kus | 0 | 2010456056x50504x50904xxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/400.0000/400.0000/560.0000/1/300.0000/300.0000/0/90.0/0/90.0/1.0000/560.0000/400.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/400.00/0/50.00/50.00/560.00/50.00/90.00/0/0/560.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x560 | 560 | 400 | 400 | 0.000 | 0 | 1.550 m2 | IT.02.30090 | A2 | 6774Obj0000020274 | Objekt | 520.000/300.000/300.000/0.000/-220.000/-300.000/0.000/0.000/0.000/1.000 | 1.55 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 560
201044x4x05050560509056xxxx | Půdorys 1.PP | Kus | 0.059 | 201044x4x05050560509056xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/58.5000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/58.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30091 | A2 | 6774Obj0000020288 | Objekt | 58.500/300.000/220.000/0.000/-300.000/-220.000/0.000/0.000/0.000/1.000 | 1 | 59 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
101045604x59xxxxxx0 | Půdorys 1.PP | Kus | 0.05 | 101045604x59xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/50.0000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30092 | A2 | 6774Obj0000020302 | Objekt | 50.000/300.000/220.000/0.000/-300.000/-220.000/0.000/0.000/0.000/1.000 | 1 | 50 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
101045604x5xxxxxxx | Půdorys 1.PP | Kus | 0.1 | 101045604x5xxxxxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/860.0000/760.0000/1/100.0000/0/0/0/0/0/1.0000/860.0000/760.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/860.00/760.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 30/SB 30/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 860x760 | 860 | 760 | 860 | 0.000 | 0 | 1.000 m2 | IT.02.30093 | A2 | 6774Obj0000020316 | Objekt | 100.000/450.000/400.000/0.000/-450.000/-400.000/0.000/0.000/0.000/1.000 | 1 | 100 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 760
1x01055604x15xxxxxxx0 | Půdorys 1.PP | Kus | 0.45 | 1x01055604x15xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/355.0000/1/450.0000/0/0/0/0/0/1.0000/560.0000/355.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/355.00/450.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 560x355 | 560 | 355 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30094 | A2 | 6774Obj0000020888 | Objekt | 450.000/300.000/197.500/0.000/-300.000/-197.500/0.000/0.000/0.000/1.000 | 1 | 450 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355
1010556035545xxxxxxx | Půdorys 1.PP | Kus | 0.45 | 1010556035545xxxxxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/355.0000/1/450.0000/0/0/0/0/0/1.0000/560.0000/355.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/355.00/450.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 560x355 | 560 | 355 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30095 | A2 | 6774Obj0000020902 | Objekt | 450.000/300.000/197.500/0.000/-300.000/-197.500/0.000/0.000/0.000/1.000 | 1 | 450 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.5; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355
1010556035545xxxxxxx | Půdorys 1.PP | Kus | 0.61 | 1010556035545xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/610.0000/160.0000/160.0000/2/610.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/610.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.610 m | IT.02.30096 | A2 | 6774Obj0000020905 | Objekt | 610.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.61 | 610 | __ISO | 0.04 | 0,041 W/m.K
1520416016061xxxxxxx | Půdorys 1.PP | Kus | 0.26 | 1520416016061xxxxxxx | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/260.0000/0/0/0/0/0/1.0000/160.0000/160.0000/2/130.0000/130.0000/0/90.0/0/0/160.0000/160.0000/160.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/160.00/0/0/260.00/0/130.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.02.30097 | A2 | 6774Obj0000020909 | Objekt | 260.000/130.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 260 | __ISO | 0.04 | 0,041 W/m.K
7520416016016x26x13x9xxxx | Půdorys 1.PP | Kus | 0.078 | 7520416016016x26x13x9xxxx | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/78.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 30/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/160.00/0/0/125.00/160.00/0/78.00/17.50/17.50/17.50/17.50/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 160 | 160 | 125 | 0.000 | 0 | 1.0 | IT.02.30098 | A2 | 6774Obj0000020912 | Objekt | 78.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 78 | __ISO | 0.04 | 0,041 W/m.K
3020512516x012516x78181818183xx | Půdorys 1.PP | Kus | 0.05 | 3020512516x012516x78181818183xx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/50.0000/160.0000/160.0000/2/50.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.050 m | IT.02.30099 | A2 | 6774Obj0000020915 | Objekt | 50.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.05 | 50 | __ISO | 0.04 | 0,041 W/m.K
152041601605xxxxxxx | Půdorys 1.PP | Kus | 0 | 152041601605xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/180.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/180.00/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.02.30100 | A2 | 6774Obj0000020918 | Objekt | 240.000/160.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16019xxxxxx | Půdorys 1.PP | Kus | 0.81 | 252x16x16019xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/810.0000/160.0000/160.0000/2/810.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/810.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.810 m | IT.02.30101 | A2 | 6774Obj0000020921 | Objekt | 810.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.81 | 810 | __ISO | 0.04 | 0,041 W/m.K
macro | Půdorys 1.PP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/-1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/160.00/160.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN160 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.02.30102 | A2 | 6774Obj0000020935 | Objekt | 54401.577/7748.000/-841.500/54091.577/7588.000/-1001.500/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/13; N_FREI_68: SPIRO POTRUBÍ
1x01041x503xxxxxxx0 | Půdorys 1.PP | Kus | 0.936 | 1x01041x503xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/935.5000/125.0000/125.0000/2/935.5000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/935.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.935 m | IT.02.30103 | A2 | 6774Obj0000020952 | Objekt | 935.500/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.935 | 936 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
 | Půdorys 1.PP | Kus | 2.259 |  | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/2258.6000/125.0000/125.0000/2/2258.6000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/2258.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 2.259 m | IT.02.30104 | A2 | 6774Obj0000020958 | Objekt | 2258.600/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 2.259 | 2259 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
macro | Půdorys 1.PP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.02.30105 | A2 | 6774Obj0000020972 | Objekt | 56555.731/8526.010/-637.501/56430.723/8216.007/-762.501/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/13; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.PP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.02.30106 | A2 | 6774Obj0000020986 | Objekt | 56928.204/7737.500/-637.500/56618.204/7612.500/-762.500/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/13; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.PP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.02.30107 | A2 | 6774Obj0000021003 | Objekt | 56857.349/12058.423/-637.500/56732.349/11748.423/-762.500/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/13; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.PP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.02.30108 | A2 | 6774Obj0000021020 | Objekt | 56857.349/11332.423/-637.500/56732.349/11022.423/-762.500/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/13; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.PP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/-1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.02.30109 | A2 | 6774Obj0000021034 | Objekt | 53418.077/8070.500/-859.000/53108.077/7945.500/-984.000/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/13; N_FREI_68: SPIRO POTRUBÍ
101058607601xxxxxxx0 | Půdorys 1.PP | Kus | 0.2 | 101058607601xxxxxxx0 | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/200.0000/0/0/0/0/0/0/200.0000/100.0000/1/ | 50/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/125.00/200.00/35.00/100.00/125.00/100.00/125.00/200.00/37.50/37.50/-12.50/-12.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 200 | 100 | 125 | 0.000 | 0 | 1.000 m2 | IT.02.30110 | A2 | 6774Obj0000021142 | Objekt | 200.000/100.000/62.500/0.000/-100.000/-62.500/0.000/0.000/0.000/1.000 | 1 | 200 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.10; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)
502161252x351x1251x1252x3838-13- | Půdorys 1.PP | Kus | 0.199 | 502161252x351x1251x1252x3838-13- | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/199.3560/125.0000/125.0000/2/199.3560/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/199.36/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.199 m | IT.02.30111 | A2 | 6774Obj0000021145 | Objekt | 199.356/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.199 | 199 | __ISO | 0.04 | 0,041 W/m.K
15204125125199xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15204125125199xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30112 | A2 | 6774Obj0000021148 | Objekt | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012519xxxxxx | Půdorys 1.PP | Kus | 0.295 | 252x125012519xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/295.1587/125.0000/125.0000/2/295.1587/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/295.16/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.295 m | IT.02.30113 | A2 | 6774Obj0000021151 | Objekt | 295.159/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.295 | 295 | __ISO | 0.04 | 0,041 W/m.K
15204125125295xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15204125125295xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30114 | A2 | 6774Obj0000021154 | Objekt | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012519xxxxxx | Půdorys 1.PP | Kus | 0.199 | 252x125012519xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/199.3560/125.0000/125.0000/2/199.3560/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/199.36/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.199 m | IT.02.30115 | A2 | 6774Obj0000021157 | Objekt | 199.356/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.199 | 199 | __ISO | 0.04 | 0,041 W/m.K
15204125125199xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15204125125199xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30116 | A2 | 6774Obj0000021160 | Objekt | 93.750/70.873/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012513xxxxxx | Půdorys 1.PP | Kus | 0.242 | 252x125012513xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/241.7349/125.0000/125.0000/2/241.7349/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/241.73/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.242 m | IT.02.30117 | A2 | 6774Obj0000021163 | Objekt | 241.735/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.242 | 242 | __ISO | 0.04 | 0,041 W/m.K
15205125125242xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15205125125242xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30118 | A2 | 6774Obj0000021166 | Objekt | 93.750/70.873/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
15205125125468xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15205125125468xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/0/125.0000/125.0000/125.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30119 | A2 | 6774Obj0000021172 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125145xxxxx0 | Půdorys 1.PP | Kus | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30120 | A2 | 6774Obj0000021175 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125145xxxxx0 | Půdorys 1.PP | Kus | 1.959 | 252x1250125145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1959.3000/125.0000/125.0000/2/1959.3000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/1959.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.959 m | IT.02.30121 | A2 | 6774Obj0000021178 | Objekt | 1959.300/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1.959 | 1959 | __ISO | 0.04 | 0,041 W/m.K
 | Půdorys 1.PP | Kus | 0.126 |  | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/126.2000/125.0000/125.0000/2/126.2000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/126.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.126 m | IT.02.30122 | A2 | 6774Obj0000021181 | Objekt | 126.200/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.126 | 126 | __ISO | 0.04 | 0,041 W/m.K
15205125125126xxxxxx0 | Půdorys 1.PP | Kus | 1.486 | 15205125125126xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1486.1000/125.0000/125.0000/2/1486.1000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/1486.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.486 m | IT.02.30123 | A2 | 6774Obj0000021184 | Objekt | 1486.100/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1.486 | 1486 | __ISO | 0.04 | 0,041 W/m.K
15204125125151xxxxxxx | Půdorys 1.PP | Kus | 0.089 | 15204125125151xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/89.0136/125.0000/125.0000/2/89.0136/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/89.01/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.089 m | IT.02.30124 | A2 | 6774Obj0000021240 | Objekt | 89.014/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.089 | 89 | __ISO | 0.04 | 0,041 W/m.K
1520412512589xxxxxx0 | Půdorys 1.PP | Kus | 0 | 1520412512589xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30125 | A2 | 6774Obj0000021243 | Objekt | 93.750/70.873/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012513xxxxxx | Půdorys 1.PP | Kus | 0.138 | 252x125012513xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/138.0128/125.0000/125.0000/2/138.0128/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/138.01/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.138 m | IT.02.30126 | A2 | 6774Obj0000021246 | Objekt | 138.013/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.138 | 138 | __ISO | 0.04 | 0,041 W/m.K
15204125125138xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15204125125138xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30127 | A2 | 6774Obj0000021249 | Objekt | 93.750/70.873/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012513xxxxxx | Půdorys 1.PP | Kus | 0.089 | 252x125012513xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/88.9721/125.0000/125.0000/2/88.9721/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/88.97/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.089 m | IT.02.30128 | A2 | 6774Obj0000021252 | Objekt | 88.972/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.089 | 89 | __ISO | 0.04 | 0,041 W/m.K
1520412512589xxxxxx0 | Půdorys 1.PP | Kus | 0 | 1520412512589xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30129 | A2 | 6774Obj0000021255 | Objekt | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012519xxxxxx | Půdorys 1.PP | Kus | 1.175 | 252x125012519xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1175.2995/125.0000/125.0000/2/1175.2995/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/1175.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.175 m | IT.02.30130 | A2 | 6774Obj0000021258 | Konstrukce v aktuální hladině | 1175.300/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1.175 | 1175 | __ISO | 0.04 | 0,041 W/m.K
 | Půdorys 1.PP | Kus | 0 |  | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30131 | A2 | 6774Obj0000021261 | Objekt | 93.750/70.873/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012513xxxxxx | Půdorys 1.PP | Kus | 0.038 | 252x125012513xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/38.0128/125.0000/125.0000/2/38.0128/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/38.01/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.038 m | IT.02.30132 | A2 | 6774Obj0000021264 | Objekt | 38.013/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.038 | 38 | __ISO | 0.04 | 0,041 W/m.K
1520412512538xxxxxx0 | Půdorys 1.PP | Kus | 0 | 1520412512538xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30133 | A2 | 6774Obj0000021267 | Objekt | 93.750/70.873/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012513xxxxxx | Půdorys 1.PP | Kus | 1.175 | 252x125012513xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1175.3000/125.0000/125.0000/2/1175.3000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/1175.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.175 m | IT.02.30134 | A2 | 6774Obj0000021270 | Objekt | 1175.300/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1.175 | 1175 | __ISO | 0.04 | 0,041 W/m.K
101048x125019xxxxxxx | Půdorys 1.PP | Kus | 0 | 101048x125019xxxxxxx | BOGEN ASY. | 20 | 1016 | 2/0/0/0/180.0/0/0/800.0000/800.0000/1250.0000/1/505.0000/550.0000/0/90.0/0/270.0/1.0000/1250.0000/710.0000/1/ | 21/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/800.00/710.00/0/50.00/50.00/1250.00/100.00/90.00/0/1.00/1250.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/1.00 | SB 30/SB 30/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 800x1250 | 1250 | 710 | 800 | 0.000 | 0 | 6.210 m2 | IT.02.30135 | A2 | 6774Obj0000021841 | Objekt | 880.000/550.000/645.000/0.000/-420.000/-645.000/0.000/0.000/0.000/1.000 | 6.21 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1250
211048x71x505012501x90125xxxx | Půdorys 1.PP | Kus | 0.895 | 211048x71x505012501x90125xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/1250.0000/710.0000/1/895.0000/0/0/0/0/0/1.0000/1250.0000/710.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/1250.00/710.00/895.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/1.00 | SB 30/SB 30/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1250x710 | 1250 | 710 | 1250 | 0.000 | 0 | 3.510 m2 | IT.02.30136 | A2 | 6774Obj0000021855 | Objekt | 895.000/645.000/375.000/0.000/-645.000/-375.000/0.000/0.000/0.000/1.000 | 3.51 | 895 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 710
 | Půdorys 1.PP | Kus | 0.19 |  | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/800.0000/1250.0000/1/190.0000/0/0/0/0/0/1.0000/800.0000/1250.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/800.00/1250.00/190.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/1.00 | SB 30/SB 30/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 800x1250 | 800 | 1250 | 800 | 0.000 | 0 | 1.000 m2 | IT.02.30137 | A2 | 6774Obj0000021869 | Objekt | 190.000/420.000/645.000/0.000/-420.000/-645.000/0.000/0.000/0.000/1.000 | 1 | 190 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1250
15206125125xxxxxxx | Půdorys 1.PP | Kus | 0.03 | 15206125125xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.030 m | IT.02.30138 | A2 | 6774Obj0000049411 | Objekt | 30.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K
152041251253xxxxxxx | Půdorys 1.PP | Kus | 0.067 | 152041251253xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/67.4175/125.0000/125.0000/2/67.4175/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/67.42/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.067 m | IT.02.30139 | A2 | 6774Obj0000049414 | Objekt | 67.417/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.067 | 67 | __ISO | 0.04 | 0,041 W/m.K
1520412512567xxxxxx0 | Půdorys 1.PP | Kus | 1.673 | 1520412512567xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1673.0315/160.0000/160.0000/2/1673.0315/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/1673.03/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.673 m | IT.02.30140 | A2 | 6774Obj0000049417 | Objekt | 1673.032/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1.673 | 1673 | __ISO | 0.04 | 0,041 W/m.K
 | Půdorys 1.PP | Kus | 0 |  | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30141 | A2 | 6774Obj0000049420 | Objekt | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
macro | Půdorys 1.PP | Kus | 0.05 | macro | Bundkragen | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/160.00/160.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN160 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.02.30142 | A2 | 6774Obj0000049434 | Objekt | 46266.268/12134.845/-606.500/46216.268/11942.845/-798.500/0.000/0.000/0.000/1.000 | 1 | 50 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_DWGNAME: ${PROD}l\einbauteile rund\bundkragen\; K_DP_EBT: 0.00; K_DATE: 2023/01/13; N_FREI_68: SPIRO POTRUBÍ
macro | Půdorys 1.PP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/160.00/160.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN160 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.02.30143 | A2 | 6774Obj0000049462 | Objekt | 47976.268/12118.845/-622.500/47666.268/11958.845/-782.500/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/13; N_FREI_68: SPIRO POTRUBÍ
 | Půdorys 1.PP | Kus | 0.897 |  | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/897.1336/160.0000/160.0000/2/897.1336/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/897.13/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.897 m | IT.02.30144 | A2 | 6774Obj0000049465 | Objekt | 897.134/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.897 | 897 | __ISO | 0.04 | 0,041 W/m.K
15204160160897xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15204160160897xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.02.30145 | A2 | 6774Obj0000049468 | Objekt | 120.000/90.718/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16013xxxxxx | Půdorys 1.PP | Kus | 0.096 | 252x16x16013xxxxxx | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/2/96.0000/0/0.0388/0/0/0/160.0000/160.0000/160.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/0/160.00/160.00/0/96.00/0/0/0.04/-0.04/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.02.30146 | A2 | 6774Obj0000049471 | Objekt | 96.000/80.000/80.039/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 96 | __ISO | 0.04 | 0,041 W/m.K
3020416016x016016x96x0-03xx | Půdorys 1.PP | Kus | 0.078 | 3020416016x016016x96x0-03xx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/78.1891/160.0000/160.0000/2/78.1891/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/78.19/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.078 m | IT.02.30147 | A2 | 6774Obj0000049474 | Objekt | 78.189/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.078 | 78 | __ISO | 0.04 | 0,041 W/m.K
1520416016078xxxxxx0 | Půdorys 1.PP | Kus | 0 | 1520416016078xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/270.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.00/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.02.30148 | A2 | 6774Obj0000049477 | Objekt | 120.000/90.718/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16013xxxxxx | Půdorys 1.PP | Kus | 0.897 | 252x16x16013xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/897.1336/160.0000/160.0000/2/897.1336/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/897.13/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.897 m | IT.02.30149 | A2 | 6774Obj0000049480 | Objekt | 897.134/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.897 | 897 | __ISO | 0.04 | 0,041 W/m.K
15204160160897xxxxxx0 | Půdorys 1.PP | Kus | 0.26 | 15204160160897xxxxxx0 | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/260.0000/0/0/0/0/0/50.0000/160.0000/160.0000/2/130.0000/130.0000/0/90.0/0/0/160.0000/160.0000/160.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/160.00/0/0/260.00/0/130.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.02.30150 | A2 | 6774Obj0000049484 | Objekt | 260.000/130.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 260 | __ISO | 0.04 | 0,041 W/m.K
7520416016016x26x13x9xxxx | Půdorys 1.PP | Kus | 0.078 | 7520416016016x26x13x9xxxx | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/78.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 30/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/160.00/0/0/125.00/160.00/0/78.00/17.50/17.50/17.50/17.50/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 160 | 160 | 125 | 0.000 | 0 | 1.0 | IT.02.30151 | A2 | 6774Obj0000049487 | Objekt | 78.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 78 | __ISO | 0.04 | 0,041 W/m.K
3020612516x012516x78181818183xx | Půdorys 1.PP | Kus | 1.4 | 3020612516x012516x78181818183xx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1400.0000/160.0000/160.0000/2/1400.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/1400.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.400 m | IT.02.30152 | A2 | 6774Obj0000049490 | Objekt | 1400.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1.4 | 1400 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
macro | Půdorys 1.PP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.02.30153 | A2 | 6774Obj0000049504 | Objekt | 48168.768/12556.845/-637.500/48043.768/12246.845/-762.500/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/13; N_FREI_68: SPIRO POTRUBÍ
 | Půdorys 1.PP | Kus | 0.559 |  | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/558.9708/125.0000/125.0000/2/558.9708/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/558.97/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.559 m | IT.02.30154 | A2 | 6774Obj0000049507 | Objekt | 558.971/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.559 | 559 | __ISO | 0.04 | 0,041 W/m.K
15206125125559xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15206125125559xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/269.6/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/269.6/125.0000/125.0000/125.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/269.60/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30155 | A2 | 6774Obj0000049510 | Objekt | 93.750/70.873/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012513xxxxxx | Půdorys 1.PP | Kus | 0.078 | 252x125012513xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/78.0012/125.0000/125.0000/2/78.0012/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/78.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.078 m | IT.02.30156 | A2 | 6774Obj0000049513 | Objekt | 78.001/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.078 | 78 | __ISO | 0.04 | 0,041 W/m.K
1520612512578xxxxxx0 | Půdorys 1.PP | Kus | 0 | 1520612512578xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/89.4/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/89.4/125.0000/125.0000/125.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/89.40/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30157 | A2 | 6774Obj0000049516 | Objekt | 93.750/70.873/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
1x01062x1504xxxxxxx | Půdorys 1.PP | Kus | 0.2 | 1x01062x1504xxxxxxx | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/200.0000/0/0/0/0/0/0/200.0000/150.0000/1/ | 50/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/125.00/200.00/35.00/100.00/125.00/150.00/125.00/200.00/37.50/37.50/12.50/12.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 200 | 150 | 125 | 0.000 | 0 | 1.000 m2 | IT.02.30158 | A2 | 6774Obj0000049521 | Objekt | 200.000/100.000/75.000/0.000/-100.000/-75.000/0.000/0.000/0.000/1.000 |  | 200 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)
502161252x351x1251501252x3838131 | Půdorys 1.PP | Kus | 0.2 | 502161252x351x1251501252x3838131 | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/200.0000/0/0/0/0/0/0/200.0000/150.0000/1/ | 50/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/125.00/200.00/35.00/100.00/125.00/150.00/125.00/200.00/37.50/37.50/12.50/12.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 200 | 150 | 125 | 0.000 | 0 | 1.000 m2 | IT.02.30159 | A2 | 6774Obj0000049523 | Objekt | 200.000/100.000/75.000/0.000/-100.000/-75.000/0.000/0.000/0.000/1.000 |  | 200 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)
101055604x498xxxxxx0 | Půdorys 1.PP | Kus | 1.233 | 101055604x498xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/1000.0000/225.0000/1/1232.8000/0/0/0/0/0/1.0000/1000.0000/225.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/1000.00/225.00/1232.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 30/SB 30/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1000x225 | 1000 | 225 | 1000 | 0.000 | 0 | 3.020 m2 | IT.02.30189 | A2 | 6774Obj0000052588 | Objekt | 1232.800/520.000/132.500/0.000/-520.000/-132.500/0.000/0.000/0.000/1.000 | 3.02 | 1233 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.16; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 225
 | Půdorys 1.PP | Kus | 1.21 |  | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/1000.0000/225.0000/1/1209.6000/0/0/0/0/0/1.0000/1000.0000/225.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/1000.00/225.00/1209.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 30/SB 30/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1000x225 | 1000 | 225 | 1000 | 0.000 | 0 | 2.960 m2 | IT.02.30190 | A2 | 6774Obj0000052602 | Objekt | 1209.600/520.000/132.500/0.000/-520.000/-132.500/0.000/0.000/0.000/1.000 | 2.96 | 1210 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.15; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 225
101051x0225121xxxxxxx | Půdorys 1.PP | Kus | 0 | 101051x0225121xxxxxxx | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/1000.0000/1000.0000/225.0000/1/509.6194/211.0913/0/45.0/0/0/1.0000/1000.0000/225.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/1000.00/1000.00/0/50.00/50.00/225.00/100.00/45.00/0/2.00/225.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 30/SB 30/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1000x225 | 1000 | 225 | 1000 | 0.000 | 0 | 2.490 m2 | IT.02.30191 | A2 | 6774Obj0000052684 | Objekt | 877.315/578.787/132.500/0.000/-520.000/-132.500/0.000/0.000/0.000/1.000 | 2.49 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.30; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 225
201051x01xx50502251x45225xxx0 | Půdorys 1.PP | Kus | 0 | 201051x01xx50502251x45225xxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/180.0/1000.0000/1000.0000/225.0000/1/509.6194/211.0913/0/45.0/0/180.0/1.0000/1000.0000/225.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/1000.00/1000.00/0/50.00/50.00/225.00/100.00/45.00/180.00/2.00/225.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 30/SB 30/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1000x225 | 1000 | 225 | 1000 | 0.000 | 0 | 2.490 m2 | IT.02.30192 | A2 | 6774Obj0000052766 | Objekt | 877.315/578.787/132.500/0.000/-520.000/-132.500/0.000/0.000/0.000/1.000 | 2.49 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.28; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 225
201051x01xx50502251x45225xxx0 | Půdorys 1.PP | Kus | 0.482 | 201051x01xx50502251x45225xxx0 | UEBERGANG ASYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/481.7000/-220.0000/87.5000/0/0/0/0/1000.0000/225.0000/1/ | 41/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/1000.00/50.00/50.00/400.00/225.00/0/481.70/440.00/0/0/-175.00/49.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 30/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 1000 | 225 | 560 | 0.000 | 0 | 1.600 m2 | IT.02.30193 | A2 | 6774Obj0000052788 | Objekt | 481.700/300.000/220.000/0.000/-740.000/-220.000/0.000/0.000/0.000/1.000 | 1.6 | 482 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
411055601x050504x225048244x0-175 | Půdorys 1.PP | Kus | 0.099 | 411055601x050504x225048244x0-175 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/1000.0000/225.0000/1/99.4000/0/0/0/0/0/1.0000/1000.0000/225.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/1000.00/225.00/99.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 30/SB 30/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1000x225 | 1000 | 225 | 1000 | 0.000 | 0 | 1.000 m2 | IT.02.30194 | A2 | 6774Obj0000052802 | Objekt | 99.400/520.000/132.500/0.000/-520.000/-132.500/0.000/0.000/0.000/1.000 | 1 | 99 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.7; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 225
macro | Půdorys 1.PP | Kus | 1.5 | macro | Schalldämpfer | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/0/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/560.00/400.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 |  | 560x400 | 1 | 1 | 1 | 0.000 | 0 |  | IT.02.30195 | A2 | 6774Obj0000052816 | Objekt | 55069.077/11839.354/-565.000/53569.077/11279.354/-965.000/0.000/0.000/0.000/1.000 | 0 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.6; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1; K_DWGNAME: ${PROD}l\einbauteile\schalldaempfer\; K_DP_EBT: 0.00; K_DATE: 2023/01/12; N_FREI_68: Blech ST37 verzinkt
1x01055604x15xxxxxxx0 | Půdorys 1.PP | Kus | 0 | 1x01055604x15xxxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/560.0000/560.0000/400.0000/1/430.0000/430.0000/0/90.0/0/0/1500.0000/560.0000/400.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/0/50.00/50.00/400.00/100.00/90.00/0/1.00/400.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 2.180 m2 | IT.02.30196 | A2 | 6774Obj0000052898 | Objekt | 730.000/430.000/220.000/0.000/-300.000/-220.000/0.000/0.000/0.000/1.000 | 2.18 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.8; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
2010556056x50504x1x904xxxx0 | Půdorys 1.PP | Kus | 0.266 | 2010556056x50504x1x904xxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/265.9000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/265.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30197 | A2 | 6774Obj0000052912 | Objekt | 265.900/300.000/220.000/0.000/-300.000/-220.000/0.000/0.000/0.000/1.000 | 1 | 266 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
101055604x266xxxxxx0 | Půdorys 1.PP | Kus | 0.379 | 101055604x266xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/379.0000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/379.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30198 | A2 | 6774Obj0000052926 | Objekt | 379.000/300.000/220.000/0.000/-300.000/-220.000/0.000/0.000/0.000/1.000 | 1 | 379 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.17; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
201054x4x050505601x9056xxxx | Půdorys 1.PP | Kus | 0 | 201054x4x050505601x9056xxxx | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/560.0000/560.0000/400.0000/1/430.0000/430.0000/0/90.0/0/90.0/1.0000/400.0000/560.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/0/50.00/50.00/400.00/100.00/90.00/0/1.00/400.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 400 | 560 | 560 | 0.000 | 0 | 2.180 m2 | IT.02.30199 | A2 | 6774Obj0000053090 | Objekt | 730.000/430.000/220.000/0.000/-300.000/-220.000/0.000/0.000/0.000/1.000 | 2.18 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
2010556056x50504x1x904xxxx0 | Půdorys 1.PP | Kus | 0.377 | 2010556056x50504x1x904xxxx0 | UEBERGANG ASYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/400.0000/400.0000/560.0000/1/377.1000/0/80.0000/0/0/0/0/560.0000/400.0000/1/ | 41/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/560.00/50.00/50.00/560.00/400.00/0/377.10/80.00/80.00/0/-160.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x560 | 560 | 400 | 400 | 0.000 | 0 | 1.000 m2 | IT.02.30200 | A2 | 6774Obj0000053112 | Objekt | 377.100/300.000/300.000/0.000/-300.000/-300.000/0.000/0.000/0.000/1.000 | 1 | 377 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 560
411054x56050505604x0377808x-1603 | Půdorys 1.PP | Kus | 0.1 | 411054x56050505604x0377808x-1603 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/100.0000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30201 | A2 | 6774Obj0000053126 | Objekt | 100.000/300.000/220.000/0.000/-300.000/-220.000/0.000/0.000/0.000/1.000 | 1 | 100 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.5; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
101055604x1xxxxxxx0 | Půdorys 1.PP | Kus | 0.982 | 101055604x1xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/981.5000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/981.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 1.880 m2 | IT.02.30202 | A2 | 6774Obj0000053140 | Objekt | 981.500/300.000/220.000/0.000/-300.000/-220.000/0.000/0.000/0.000/1.000 | 1.88 | 982 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400
101055604x982xxxxxx0 | Půdorys 1.PP | Kus | 0.065 | 101055604x982xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/860.0000/760.0000/1/64.7000/0/0/0/0/0/1.0000/860.0000/760.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/860.00/760.00/64.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 30/SB 30/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 860x760 | 860 | 760 | 860 | 0.000 | 0 | 1.000 m2 | IT.02.30203 | A2 | 6774Obj0000053154 | Objekt | 64.700/450.000/400.000/0.000/-450.000/-400.000/0.000/0.000/0.000/1.000 | 1 | 65 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.6; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 760
