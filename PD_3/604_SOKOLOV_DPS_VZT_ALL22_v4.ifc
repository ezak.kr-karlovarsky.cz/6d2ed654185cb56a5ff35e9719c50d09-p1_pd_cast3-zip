Properties of the parts of a building model (IFC2X3), part 42 of 51

# IfcFlowSegment (1090)
Name | In | Jednotka | Délka (m) | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_LAENGE | L_BES_DIM | L_BES_DIM_A2 = L_BES_DIM_A | L_BES_DIM_B2 | K_VOLSTROM | K_LISTVALUE | Kód prvku | Podlaží | Průměr | Teplonosná látka | Allright_Stavebni_dil_ID | Název_objektu | Označení | K_LISTVALUE_ISO
1520512512563xxxxxx0 | Půdorys 1.PP | m | 0.063 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/62.5000/125.0000/125.0000/2/62.5000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/62.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 63 | DN125 | 125 | 125 | 0.000 | 0.063 m | PO.02.30307 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000002157 | Kruhové potrubí | 1520512512563xxxxxx0 | 0.040 m2
15205125125105xxxxxx0 | Půdorys 1.PP | m | 0.105 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/104.6143/125.0000/125.0000/2/104.6143/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/104.61/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 105 | DN125 | 125 | 125 | 0.000 | 0.105 m | PO.02.30308 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000002167 | Kruhové potrubí | 15205125125105xxxxxx0 | 0.067 m2
15205125125103xxxxxx0 | Půdorys 1.PP | m | 0.103 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/103.3368/125.0000/125.0000/2/103.3368/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/103.34/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 103 | DN125 | 125 | 125 | 0.000 | 0.103 m | PO.02.30309 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000002182 | Kruhové potrubí | 15205125125103xxxxxx0 | 0.067 m2
1520512512523xxxxxx0 | Půdorys 1.PP | m | 0.023 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/22.9178/125.0000/125.0000/2/22.9178/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/22.92/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 23 | DN125 | 125 | 125 | 0.000 | 0.023 m | PO.02.30310 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000002442 | Kruhové potrubí | 1520512512523xxxxxx0 | 0.015 m2
15206125125619xxxxxx0 | Půdorys 1.PP | m | 0.619 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/618.9000/125.0000/125.0000/2/618.9000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/618.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 619 | DN125 | 125 | 125 | 0.000 | 0.619 m | PO.02.30311 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000002560 | Kruhové potrubí | 15206125125619xxxxxx0 | 0.399 m2
15204125125111xxxxxx0 | Půdorys 1.PP | m | 0.111 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/111.1000/125.0000/125.0000/2/111.1000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/111.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 111 | DN125 | 125 | 125 | 120.000 | 0.111 m | PO.02.30312 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000059684 | Kruhové potrubí | 15204125125111xxxxxx0 | 0.072 m2
1520412512534xxxxxxx | Půdorys 1.PP | m | 0.34 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/339.5545/125.0000/125.0000/2/339.5545/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/339.55/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 340 | DN125 | 125 | 125 | 120.000 | 0.340 m | PO.02.30313 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000059694 | Kruhové potrubí | 1520412512534xxxxxxx | 0.219 m2
15204125125164xxxxxx0 | Půdorys 1.PP | m | 0.164 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/163.5435/125.0000/125.0000/2/163.5435/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/163.54/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 164 | DN125 | 125 | 125 | 120.000 | 0.164 m | PO.02.30314 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000059704 | Kruhové potrubí | 15204125125164xxxxxx0 | 0.105 m2
1520412512534xxxxxxx | Půdorys 1.PP | m | 0.34 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/339.5479/125.0000/125.0000/2/339.5479/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/339.55/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 340 | DN125 | 125 | 125 | 120.000 | 0.340 m | PO.02.30315 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000059714 | Kruhové potrubí | 1520412512534xxxxxxx | 0.219 m2
1520412512545xxxxxxx | Půdorys 1.PP | m | 0.45 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/449.5000/125.0000/125.0000/2/449.5000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/449.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450 | DN125 | 125 | 125 | 120.000 | 0.450 m | PO.02.30316 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000059719 | Kruhové potrubí | 1520412512545xxxxxxx | 0.289 m2
15205125125107xxxxxx0 | Půdorys 1.PP | m | 0.107 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/107.4873/125.0000/125.0000/2/107.4873/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/107.49/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 107 | DN125 | 125 | 125 | 120.000 | 0.107 m | PO.02.30317 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000059724 | Kruhové potrubí | 15205125125107xxxxxx0 | 0.069 m2
1520512512584xxxxxx0 | Půdorys 1.PP | m | 0.084 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/84.0522/125.0000/125.0000/2/84.0522/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/84.05/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 84 | DN125 | 125 | 125 | 120.000 | 0.084 m | PO.02.30318 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000059734 | Kruhové potrubí | 1520512512584xxxxxx0 | 0.054 m2
15205125125108xxxxxx0 | Půdorys 1.PP | m | 0.108 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/107.5017/125.0000/125.0000/2/107.5017/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/107.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 108 | DN125 | 125 | 125 | 120.000 | 0.107 m | PO.02.30319 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000059744 | Kruhové potrubí | 15205125125108xxxxxx0 | 0.069 m2
1520516016018xxxxxxx | Půdorys 1.PP | m | 0.18 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/180.3755/160.0000/160.0000/2/180.3755/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/180.38/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 180 | DN160 | 160 | 160 | 0.000 | 0.180 m | PO.02.30320 | Podzemní podlaží 1.PP | DN160 | vzduch | 6772Obj0000059769 | Kruhové potrubí | 1520516016018xxxxxxx | 0.136 m2
1520516016067xxxxxx0 | Půdorys 1.PP | m | 0.067 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/67.0692/160.0000/160.0000/2/67.0692/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/67.07/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 67 | DN160 | 160 | 160 | 0.000 | 0.067 m | PO.02.30321 | Podzemní podlaží 1.PP | DN160 | vzduch | 6772Obj0000059779 | Kruhové potrubí | 1520516016067xxxxxx0 | 0.051 m2
1520516016018xxxxxxx | Půdorys 1.PP | m | 0.18 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/180.3809/160.0000/160.0000/2/180.3809/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/180.38/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 180 | DN160 | 160 | 160 | 0.000 | 0.180 m | PO.02.30322 | Podzemní podlaží 1.PP | DN160 | vzduch | 6772Obj0000059789 | Kruhové potrubí | 1520516016018xxxxxxx | 0.136 m2
15204160160108xxxxxxx | Půdorys 1.PP | m | 1.08 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/300.0000/160.0000/160.0000/2/300.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/300.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 300 | DN160 | 160 | 160 | 120.000 | 0.300 m | PO.02.30323 | Podzemní podlaží 1.PP | DN160 | vzduch | 6772Obj0000059794 | Kruhové potrubí | 15204160160108xxxxxxx | 0.226 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 1080.000|80.000|80.000|0.000|-80.000|-80.000|0.000|0.000|0.000|1.000
15204160160232xxxxxx0 | Půdorys 1.PP | m | 0.232 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/232.3660/160.0000/160.0000/2/232.3660/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/232.37/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 232 | DN160 | 160 | 160 | 120.000 | 0.232 m | PO.02.30324 | Podzemní podlaží 1.PP | DN160 | vzduch | 6772Obj0000059799 | Kruhové potrubí | 15204160160232xxxxxx0 | 0.175 m2
1520416016075xxxxxx0 | Půdorys 1.PP | m | 0.075 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/74.5349/160.0000/160.0000/2/74.5349/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/74.53/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 75 | DN160 | 160 | 160 | 120.000 | 0.074 m | PO.02.30325 | Podzemní podlaží 1.PP | DN160 | vzduch | 6772Obj0000059809 | Kruhové potrubí | 1520416016075xxxxxx0 | 0.056 m2
15204160160258xxxxxx0 | Půdorys 1.PP | m | 0.258 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/258.4078/160.0000/160.0000/2/258.4078/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/258.41/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 258 | DN160 | 160 | 160 | 120.000 | 0.258 m | PO.02.30326 | Podzemní podlaží 1.PP | DN160 | vzduch | 6772Obj0000059919 | Kruhové potrubí | 15204160160258xxxxxx0 | 0.195 m2
15204160160257xxxxxx0 | Půdorys 1.PP | m | 0.257 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/257.4039/160.0000/160.0000/2/257.4039/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/257.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 257 | DN160 | 160 | 160 | 120.000 | 0.257 m | PO.02.30327 | Podzemní podlaží 1.PP | DN160 | vzduch | 6772Obj0000059929 | Kruhové potrubí | 15204160160257xxxxxx0 | 0.194 m2
15204160160244xxxxxx0 | Půdorys 1.PP | m | 0.244 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/243.5264/160.0000/160.0000/2/243.5264/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/243.53/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 244 | DN160 | 160 | 160 | 120.000 | 0.243 m | PO.02.30328 | Podzemní podlaží 1.PP | DN160 | vzduch | 6772Obj0000059939 | Kruhové potrubí | 15204160160244xxxxxx0 | 0.184 m2
15206160160232xxxxxx0 | Půdorys 1.PP | m | 0.232 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/232.4000/160.0000/160.0000/2/232.4000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/232.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 232 | DN160 | 160 | 160 | 120.000 | 0.232 m | PO.02.30329 | Podzemní podlaží 1.PP | DN160 | vzduch | 6772Obj0000060141 | Kruhové potrubí | 15206160160232xxxxxx0 | 0.175 m2
15204125125419xxxxxx0 | Půdorys 1.PP | m | 0.419 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/419.2385/125.0000/125.0000/2/419.2385/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/419.24/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 419 | DN125 | 125 | 125 | 0.000 | 0.419 m | PO.02.30330 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000137962 | Kruhové potrubí | 15204125125419xxxxxx0 | 0.270 m2
15204125125723xxxxxx0 | Půdorys 1.PP | m | 0.723 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/723.0000/125.0000/125.0000/2/723.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/723.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | 723 | DN125 | 125 | 125 | 0.000 | 0.723 m | PO.02.30331 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000137987 | Kruhové potrubí | 15204125125723xxxxxx0 | 0.466 m2
1520412512534xxxxxx0 | Půdorys 1.PP | m | 0.034 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/33.8217/125.0000/125.0000/2/33.8217/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/33.82/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 34 | DN125 | 125 | 125 | 0.000 | 0.034 m | PO.02.30332 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000137992 | Kruhové potrubí | 1520412512534xxxxxx0 | 0.022 m2
15204125125176xxxxxx0 | Půdorys 1.PP | m | 0.176 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/175.7101/125.0000/125.0000/2/175.7101/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/175.71/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 176 | DN125 | 125 | 125 | 0.000 | 0.176 m | PO.02.30333 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000138007 | Kruhové potrubí | 15204125125176xxxxxx0 | 0.113 m2
1520412512534xxxxxx0 | Půdorys 1.PP | m | 0.034 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/33.8217/125.0000/125.0000/2/33.8217/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/33.82/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 34 | DN125 | 125 | 125 | 0.000 | 0.034 m | PO.02.30334 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000138017 | Kruhové potrubí | 1520412512534xxxxxx0 | 0.022 m2
15204125125106xxxxxx0 | Půdorys 1.PP | m | 0.106 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/106.4571/125.0000/125.0000/2/106.4571/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/106.46/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 106 | DN125 | 125 | 125 | 0.000 | 0.106 m | PO.02.30335 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000138172 | Kruhové potrubí | 15204125125106xxxxxx0 | 0.069 m2
1520512512561xxxxxx0 | Půdorys 1.PP | m | 0.061 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/60.9364/125.0000/125.0000/2/60.9364/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/60.94/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 61 | DN125 | 125 | 125 | 0.000 | 0.061 m | PO.02.30336 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000138222 | Kruhové potrubí | 1520512512561xxxxxx0 | 0.039 m2
15206125125295xxxxxx0 | Půdorys 1.PP | m | 0.295 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/34.9000/125.0000/125.0000/2/34.9000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/34.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 35 | DN125 | 125 | 125 | 0.000 | 0.035 m | PO.02.30337 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000138364 | Kruhové potrubí | 15206125125295xxxxxx0 | 0.022 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 294.900|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
15204125125383xxxxxx0 | Půdorys 1.PP | m | 0.383 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/382.8180/125.0000/125.0000/2/382.8180/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/382.82/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 383 | DN125 | 125 | 125 | 0.000 | 0.383 m | PO.02.30338 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000138467 | Kruhové potrubí | 15204125125383xxxxxx0 | 0.247 m2
15204125125383xxxxxx0 | Půdorys 1.PP | m | 0.383 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/382.9000/125.0000/125.0000/2/382.9000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/382.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 383 | DN125 | 125 | 125 | 0.000 | 0.383 m | PO.02.30339 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000138492 | Kruhové potrubí | 15204125125383xxxxxx0 | 0.247 m2
15205125125123xxxxxx0 | Půdorys 1.PP | m | 0.123 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/123.4052/125.0000/125.0000/2/123.4052/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/123.41/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 123 | DN125 | 125 | 125 | 0.000 | 0.123 m | PO.02.30340 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000138522 | Kruhové potrubí | 15205125125123xxxxxx0 | 0.079 m2
15204160160474xxxxxx0 | Půdorys 1.PP | m | 0.474 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/474.0000/160.0000/160.0000/2/474.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/474.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 474 | DN160 | 160 | 160 | 0.000 | 0.474 m | PO.02.30341 | Podzemní podlaží 1.PP | DN160 | vzduch | 6772Obj0000140020 | Kruhové potrubí | 15204160160474xxxxxx0 | 0.357 m2
15205125125271xxxxxx0 | Půdorys 1.PP | m | 0.271 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/271.1958/125.0000/125.0000/2/271.1958/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/271.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 271 | DN125 | 125 | 125 | 0.000 | 0.271 m | PO.02.30342 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000140025 | Kruhové potrubí | 15205125125271xxxxxx0 | 0.175 m2
1520412512535xxxxxx0 | Půdorys 1.PP | m | 0.035 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/35.3461/125.0000/125.0000/2/35.3461/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/35.35/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 35 | DN125 | 125 | 125 | 0.000 | 0.035 m | PO.02.30343 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000140065 | Kruhové potrubí | 1520412512535xxxxxx0 | 0.023 m2
15205125125383xxxxxx0 | Půdorys 1.PP | m | 0.383 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/383.4045/125.0000/125.0000/2/383.4045/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/383.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 383 | DN125 | 125 | 125 | 0.000 | 0.383 m | PO.02.30344 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000140270 | Kruhové potrubí | 15205125125383xxxxxx0 | 0.247 m2
15205125125202xxxxxx0 | Půdorys 1.PP | m | 0.202 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/201.7753/125.0000/125.0000/2/201.7753/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/201.78/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 202 | DN125 | 125 | 125 | 0.000 | 0.202 m | PO.02.30345 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000140280 | Kruhové potrubí | 15205125125202xxxxxx0 | 0.130 m2
15205125125383xxxxxx0 | Půdorys 1.PP | m | 0.383 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/383.4422/125.0000/125.0000/2/383.4422/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/383.44/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 383 | DN125 | 125 | 125 | 0.000 | 0.383 m | PO.02.30346 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000140290 | Kruhové potrubí | 15205125125383xxxxxx0 | 0.247 m2
1520412512523xxxxxx0 | Půdorys 1.PP | m | 0.023 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/23.2640/125.0000/125.0000/2/23.2640/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/23.26/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 23 | DN125 | 125 | 125 | 120.000 | 0.023 m | PO.02.30347 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000140305 | Kruhové potrubí | 1520412512523xxxxxx0 | 0.015 m2
1520412512512xxxxxx0 | Půdorys 1.PP | m | 0.012 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/11.7645/125.0000/125.0000/2/11.7645/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/11.76/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 12 | DN125 | 125 | 125 | 120.000 | 0.012 m | PO.02.30348 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000140320 | Kruhové potrubí | 1520412512512xxxxxx0 | 0.008 m2
1520412512523xxxxxx0 | Půdorys 1.PP | m | 0.023 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/23.2640/125.0000/125.0000/2/23.2640/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/23.26/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 23 | DN125 | 125 | 125 | 120.000 | 0.023 m | PO.02.30349 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000140330 | Kruhové potrubí | 1520412512523xxxxxx0 | 0.015 m2
152041x1x141xxxxxx0 | Půdorys 1.PP | m | 0.141 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/141.2629/100.0000/100.0000/2/141.2629/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/141.26/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 141 | DN100 | 100 | 100 | 120.000 | 0.141 m | PO.02.30350 | Podzemní podlaží 1.PP | DN100 | vzduch | 6772Obj0000140335 | Kruhové potrubí | 152041x1x141xxxxxx0 | 0.080 m2
152041x1x204xxxxxx0 | Půdorys 1.PP | m | 0.204 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/204.4809/100.0000/100.0000/2/204.4809/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/204.48/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 204 | DN100 | 100 | 100 | 120.000 | 0.205 m | PO.02.30351 | Podzemní podlaží 1.PP | DN100 | vzduch | 6772Obj0000140345 | Kruhové potrubí | 152041x1x204xxxxxx0 | 0.116 m2
152041x1x141xxxxxx0 | Půdorys 1.PP | m | 0.141 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/141.2827/100.0000/100.0000/2/141.2827/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/141.28/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 141 | DN100 | 100 | 100 | 120.000 | 0.141 m | PO.02.30352 | Podzemní podlaží 1.PP | DN100 | vzduch | 6772Obj0000140355 | Kruhové potrubí | 152041x1x141xxxxxx0 | 0.080 m2
1520412512548xxxxxx0 | Půdorys 1.PP | m | 0.048 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/47.8590/125.0000/125.0000/2/47.8590/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/47.86/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 48 | DN125 | 125 | 125 | 120.000 | 0.048 m | PO.02.30353 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000140360 | Kruhové potrubí | 1520412512548xxxxxx0 | 0.031 m2
15204125125181xxxxxx0 | Půdorys 1.PP | m | 0.181 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/180.5399/125.0000/125.0000/2/180.5399/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/180.54/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 181 | DN125 | 125 | 125 | 120.000 | 0.180 m | PO.02.30354 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000140370 | Kruhové potrubí | 15204125125181xxxxxx0 | 0.116 m2
1520412512548xxxxxx0 | Půdorys 1.PP | m | 0.048 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/47.8809/125.0000/125.0000/2/47.8809/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/47.88/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 48 | DN125 | 125 | 125 | 120.000 | 0.048 m | PO.02.30355 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000140380 | Kruhové potrubí | 1520412512548xxxxxx0 | 0.031 m2
15204125125398xxxxxx0 | Půdorys 1.PP | m | 0.398 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/398.1000/125.0000/125.0000/2/398.1000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/398.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 398 | DN125 | 125 | 125 | 120.000 | 0.398 m | PO.02.30356 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000140465 | Kruhové potrubí | 15204125125398xxxxxx0 | 0.256 m2
15204125125933xxxxxx0 | Půdorys 1.PP | m | 0.933 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/932.6112/125.0000/125.0000/2/932.6112/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/932.61/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 933 | DN125 | 125 | 125 | 120.000 | 0.933 m | PO.02.30357 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000140475 | Kruhové potrubí | 15204125125933xxxxxx0 | 0.601 m2
15204125125164xxxxxx0 | Půdorys 1.PP | m | 0.164 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/163.5414/125.0000/125.0000/2/163.5414/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/163.54/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 164 | DN125 | 125 | 125 | 120.000 | 0.164 m | PO.02.30358 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000140485 | Kruhové potrubí | 15204125125164xxxxxx0 | 0.105 m2
15204125125933xxxxxx0 | Půdorys 1.PP | m | 0.933 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/932.6044/125.0000/125.0000/2/932.6044/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/932.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 933 | DN125 | 125 | 125 | 120.000 | 0.933 m | PO.02.30359 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000140495 | Kruhové potrubí | 15204125125933xxxxxx0 | 0.601 m2
1520512512524xxxxxx0 | Půdorys 1.PP | m | 0.024 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/24.3519/125.0000/125.0000/2/24.3519/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/24.35/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 24 | DN125 | 125 | 125 | 0.000 | 0.024 m | PO.02.30360 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000140595 | Kruhové potrubí | 1520512512524xxxxxx0 | 0.016 m2
15204125125164xxxxxx0 | Půdorys 1.PP | m | 0.164 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/163.9094/125.0000/125.0000/2/163.9094/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/163.91/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 164 | DN125 | 125 | 125 | 120.000 | 0.164 m | PO.02.30361 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000140760 | Kruhové potrubí | 15204125125164xxxxxx0 | 0.106 m2
15204125125164xxxxxx0 | Půdorys 1.PP | m | 0.164 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/164.4372/125.0000/125.0000/2/164.4372/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/164.44/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 164 | DN125 | 125 | 125 | 120.000 | 0.164 m | PO.02.30362 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000140780 | Kruhové potrubí | 15204125125164xxxxxx0 | 0.106 m2
1520412512527xxxxxx0 | Půdorys 1.PP | m | 0.027 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/26.7000/125.0000/125.0000/2/26.7000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/26.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 27 | DN125 | 125 | 125 | 0.000 | 0.027 m | PO.02.30363 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000140890 | Kruhové potrubí | 1520412512527xxxxxx0 | 0.017 m2
1520512512591xxxxxx0 | Půdorys 1.PP | m | 0.091 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/91.3020/125.0000/125.0000/2/91.3020/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/91.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 91 | DN125 | 125 | 125 | 0.000 | 0.091 m | PO.02.30364 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000140910 | Kruhové potrubí | 1520512512591xxxxxx0 | 0.059 m2
152051251251xxxxxxx0 | Půdorys 1.PP | m | 0.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/100.1411/125.0000/125.0000/2/100.1411/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/100.14/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 100 | DN125 | 125 | 125 | 0.000 | 0.100 m | PO.02.30365 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000140920 | Kruhové potrubí | 152051251251xxxxxxx0 | 0.064 m2
152041x1x72xxxxxx0 | Půdorys 1.PP | m | 0.072 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/72.2927/100.0000/100.0000/2/72.2927/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/72.29/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 72 | DN100 | 100 | 100 | 120.000 | 0.072 m | PO.02.30366 | Podzemní podlaží 1.PP | DN100 | vzduch | 6772Obj0000141247 | Kruhové potrubí | 152041x1x72xxxxxx0 | 0.041 m2
1520512512585xxxxxx0 | Půdorys 1.PP | m | 0.085 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/85.4000/125.0000/125.0000/2/85.4000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/85.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 85 | DN125 | 125 | 125 | 0.000 | 0.085 m | PO.02.30367 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000141590 | Kruhové potrubí | 1520512512585xxxxxx0
1520612512529xxxxxx0 | Půdorys 1.PP | m | 0.029 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/28.7641/125.0000/125.0000/2/28.7641/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/28.76/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 29 | DN125 | 125 | 125 | 0.000 | 0.029 m | PO.02.30368 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000141595 | Kruhové potrubí | 1520612512529xxxxxx0
 | Půdorys 1.PP | m | 1.581 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1580.8739/160.0000/160.0000/2/1580.8739/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/1580.87/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1581 | DN160 | 160 | 160 | 0.000 | 1.581 m | PO.02.30369 | Podzemní podlaží 1.PP | DN160 | vzduch | 6772Obj0000141620 | Kruhové potrubí
15206160160538xxxxxx0 | Půdorys 1.PP | m | 0.538 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/538.3508/160.0000/160.0000/2/538.3508/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/538.35/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 538 | DN160 | 160 | 160 | 0.000 | 0.538 m | PO.02.30370 | Podzemní podlaží 1.PP | DN160 | vzduch | 6772Obj0000141630 | Kruhové potrubí | 15206160160538xxxxxx0
 | Půdorys 1.PP | m | 1.584 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1584.2376/160.0000/160.0000/2/1584.2376/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/1584.24/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1584 | DN160 | 160 | 160 | 0.000 | 1.584 m | PO.02.30371 | Podzemní podlaží 1.PP | DN160 | vzduch | 6772Obj0000141640 | Kruhové potrubí
1520612512559xxxxxx0 | Půdorys 1.PP | m | 0.059 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/59.4232/125.0000/125.0000/2/59.4232/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/59.42/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 59 | DN125 | 125 | 125 | 0.000 | 0.059 m | PO.02.30372 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000141775 | Kruhové potrubí | 1520612512559xxxxxx0
1520612512516xxxxxx0 | Půdorys 1.PP | m | 0.016 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/16.3358/125.0000/125.0000/2/16.3358/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/16.34/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 16 | DN125 | 125 | 125 | 0.000 | 0.016 m | PO.02.30373 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000141785 | Kruhové potrubí | 1520612512516xxxxxx0
1520612512559xxxxxx0 | Půdorys 1.PP | m | 0.059 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/59.0842/125.0000/125.0000/2/59.0842/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/59.08/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 59 | DN125 | 125 | 125 | 0.000 | 0.059 m | PO.02.30374 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000141795 | Kruhové potrubí | 1520612512559xxxxxx0
15204160160162xxxxxx0 | Půdorys 1.PP | m | 0.162 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/162.0000/160.0000/160.0000/2/162.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/162.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 162 | DN160 | 160 | 160 | 120.000 | 0.162 m | PO.02.30375 | Podzemní podlaží 1.PP | DN160 | vzduch | 6772Obj0000142115 | Kruhové potrubí | 15204160160162xxxxxx0
152041x1x72xxxxxx0 | Půdorys 1.PP | m | 0.072 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/72.3000/100.0000/100.0000/2/72.3000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/72.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 72 | DN100 | 100 | 100 | 120.000 | 0.072 m | PO.02.30376 | Podzemní podlaží 1.PP | DN100 | vzduch | 6772Obj0000142130 | Kruhové potrubí | 152041x1x72xxxxxx0
152041x1x314xxxxxx0 | Půdorys 1.PP | m | 0.314 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/313.9934/100.0000/100.0000/2/313.9934/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/313.99/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 314 | DN100 | 100 | 100 | 120.000 | 0.314 m | PO.02.30377 | Podzemní podlaží 1.PP | DN100 | vzduch | 6772Obj0000142140 | Kruhové potrubí | 152041x1x314xxxxxx0
152041x1x314xxxxxx0 | Půdorys 1.PP | m | 0.314 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/314.1452/100.0000/100.0000/2/314.1452/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/314.15/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 314 | DN100 | 100 | 100 | 120.000 | 0.314 m | PO.02.30378 | Podzemní podlaží 1.PP | DN100 | vzduch | 6772Obj0000142155 | Kruhové potrubí | 152041x1x314xxxxxx0
 | Půdorys 1.PP | m | 1.195 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1195.0000/125.0000/125.0000/2/1195.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/1195.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1195 | DN125 | 125 | 125 | 120.000 | 1.195 m | PO.02.30379 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000142180 | Kruhové potrubí
15204125125971xxxxxx0 | Půdorys 1.PP | m | 0.971 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/750.0000/125.0000/125.0000/2/750.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/750.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 750 | DN125 | 125 | 125 | 120.000 | 0.750 m | PO.02.30380 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000142230 | Kruhové potrubí | 15204125125971xxxxxx0 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 971.000|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
15204125125139xxxxxx0 | Půdorys 1.PP | m | 0.139 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/139.2797/125.0000/125.0000/2/139.2797/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/139.28/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 139 | DN125 | 125 | 125 | 120.000 | 0.139 m | PO.02.30381 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000142265 | Kruhové potrubí | 15204125125139xxxxxx0
152061251259xxxxxxx | Půdorys 1.PP | m | 0.09 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/89.5000/125.0000/125.0000/2/89.5000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/89.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 90 | DN125 | 125 | 125 | 120.000 | 0.089 m | PO.02.30382 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000142274 | Kruhové potrubí | 152061251259xxxxxxx
152041x1x104xxxxxx0 | Půdorys 1.PP | m | 0.104 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/103.5000/100.0000/100.0000/2/103.5000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/103.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 104 | DN100 | 100 | 100 | 120.000 | 0.104 m | PO.02.30383 | Podzemní podlaží 1.PP | DN100 | vzduch | 6772Obj0000142295 | Kruhové potrubí | 152041x1x104xxxxxx0
152041x1x104xxxxxx0 | Půdorys 1.PP | m | 0.104 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/103.5000/100.0000/100.0000/2/103.5000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/103.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 104 | DN100 | 100 | 100 | 120.000 | 0.104 m | PO.02.30384 | Podzemní podlaží 1.PP | DN100 | vzduch | 6772Obj0000142300 | Kruhové potrubí | 152041x1x104xxxxxx0
152041x9483xxxxxx0 | Půdorys 1.PP | m | 0.083 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/50.0000/100.0000/100.0000/2/50.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/94.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | CENTRÁLNÍ VYSAVAČ/3.00 | //// | Blech ummantelt/30.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/CENTRÁLNÍ VYSAVAČ/OVALROHR | 50 | DN100 | 100 | 100 | 120.000 | 0.050 m | PO.02.30385 | Podzemní podlaží 1.PP | DN100 | vzduch | 6772Obj0000142315 | Kruhové potrubí | 152041x9483xxxxxx0 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 83.100|50.000|50.000|0.000|-50.000|-50.000|0.000|0.000|0.000|1.000
152041x1x83xxxxxx0 | Půdorys 1.PP | m | 0.083 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/50.0000/100.0000/100.0000/2/50.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | 50 | DN100 | 100 | 100 | 120.000 | 0.050 m | PO.02.30386 | Podzemní podlaží 1.PP | DN100 | vzduch | 6772Obj0000142320 | Kruhové potrubí | 152041x1x83xxxxxx0 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 83.100|50.000|50.000|0.000|-50.000|-50.000|0.000|0.000|0.000|1.000
15204125125616xxxxxx0 | Půdorys 1.PP | m | 0.616 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/615.7945/125.0000/125.0000/2/615.7945/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/615.79/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 616 | DN125 | 125 | 125 | 0.000 | 0.616 m | PO.02.30387 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000142615 | Kruhové potrubí | 15204125125616xxxxxx0
1520412512518xxxxxxx | Půdorys 1.PP | m | 0.18 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/180.1333/125.0000/125.0000/2/180.1333/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/180.13/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 180 | DN125 | 125 | 125 | 0.000 | 0.180 m | PO.02.30388 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000142625 | Kruhové potrubí | 1520412512518xxxxxxx
15204125125288xxxxxx0 | Půdorys 1.PP | m | 0.288 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/287.7314/125.0000/125.0000/2/287.7314/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/287.73/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 288 | DN125 | 125 | 125 | 0.000 | 0.288 m | PO.02.30389 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000142649 | Kruhové potrubí | 15204125125288xxxxxx0
15204125125305xxxxxx0 | Půdorys 1.PP | m | 0.305 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/304.8011/125.0000/125.0000/2/304.8011/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/304.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 305 | DN125 | 125 | 125 | 0.000 | 0.305 m | PO.02.30390 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000142659 | Kruhové potrubí | 15204125125305xxxxxx0
15204125125288xxxxxx0 | Půdorys 1.PP | m | 0.288 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/287.7665/125.0000/125.0000/2/287.7665/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/287.77/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 288 | DN125 | 125 | 125 | 0.000 | 0.288 m | PO.02.30391 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000142669 | Kruhové potrubí | 15204125125288xxxxxx0
1520412512512xxxxxx0 | Půdorys 1.PP | m | 0.012 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/11.5050/125.0000/125.0000/2/11.5050/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/11.51/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 12 | DN125 | 125 | 125 | 0.000 | 0.011 m | PO.02.30392 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000142674 | Kruhové potrubí | 1520412512512xxxxxx0
15204125125121xxxxxx0 | Půdorys 1.PP | m | 0.121 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/120.8065/125.0000/125.0000/2/120.8065/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/120.81/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 121 | DN125 | 125 | 125 | 0.000 | 0.121 m | PO.02.30393 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000142684 | Kruhové potrubí | 15204125125121xxxxxx0
1520412512512xxxxxx0 | Půdorys 1.PP | m | 0.012 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/11.5124/125.0000/125.0000/2/11.5124/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/11.51/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 12 | DN125 | 125 | 125 | 0.000 | 0.011 m | PO.02.30394 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000142694 | Kruhové potrubí | 1520412512512xxxxxx0
15205125125646xxxxxx0 | Půdorys 1.PP | m | 0.646 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/646.3314/125.0000/125.0000/2/646.3314/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/646.33/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 646 | DN125 | 125 | 125 | 0.000 | 0.646 m | PO.02.30395 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000142744 | Kruhové potrubí | 15205125125646xxxxxx0
 | Půdorys 1.PP | m | 1.535 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1535.1596/160.0000/160.0000/2/1535.1596/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/1535.16/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1535 | DN160 | 160 | 160 | 0.000 | 1.535 m | PO.02.30396 | Podzemní podlaží 1.PP | DN160 | vzduch | 6772Obj0000142749 | Kruhové potrubí
15206160160598xxxxxx0 | Půdorys 1.PP | m | 0.598 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/598.4029/160.0000/160.0000/2/598.4029/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/598.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 598 | DN160 | 160 | 160 | 0.000 | 0.598 m | PO.02.30397 | Podzemní podlaží 1.PP | DN160 | vzduch | 6772Obj0000142774 | Kruhové potrubí | 15206160160598xxxxxx0
1520616016075xxxxxxx | Půdorys 1.PP | m | 0.75 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/749.5132/160.0000/160.0000/2/749.5132/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/749.51/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 750 | DN160 | 160 | 160 | 0.000 | 0.750 m | PO.02.30398 | Podzemní podlaží 1.PP | DN160 | vzduch | 6772Obj0000142784 | Kruhové potrubí | 1520616016075xxxxxxx
15204125125819xxxxxx0 | Půdorys 1.PP | m | 0.819 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/500.0000/125.0000/125.0000/2/500.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 500 | DN125 | 125 | 125 | 0.000 | 0.500 m | PO.02.30399 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000142786 | Kruhové potrubí | 15204125125819xxxxxx0 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 818.995|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
15204125125139xxxxxx0 | Půdorys 1.PP | m | 0.139 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/138.8085/125.0000/125.0000/2/138.8085/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/138.81/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 139 | DN125 | 125 | 125 | 0.000 | 0.139 m | PO.02.30400 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000142817 | Kruhové potrubí | 15204125125139xxxxxx0
1520412512533xxxxxx0 | Půdorys 1.PP | m | 0.033 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/33.0219/125.0000/125.0000/2/33.0219/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/33.02/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 33 | DN125 | 125 | 125 | 0.000 | 0.033 m | PO.02.30401 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000142827 | Kruhové potrubí | 1520412512533xxxxxx0
15204125125139xxxxxx0 | Půdorys 1.PP | m | 0.139 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/138.8112/125.0000/125.0000/2/138.8112/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/138.81/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 139 | DN125 | 125 | 125 | 0.000 | 0.139 m | PO.02.30402 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000142837 | Kruhové potrubí | 15204125125139xxxxxx0
1520512512524xxxxxx0 | Půdorys 1.PP | m | 0.024 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/24.0339/125.0000/125.0000/2/24.0339/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/24.03/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 24 | DN125 | 125 | 125 | 0.000 | 0.024 m | PO.02.30403 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000142842 | Kruhové potrubí | 1520512512524xxxxxx0
1520512512532xxxxxx0 | Půdorys 1.PP | m | 0.032 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/31.5138/125.0000/125.0000/2/31.5138/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/31.51/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 32 | DN125 | 125 | 125 | 0.000 | 0.032 m | PO.02.30404 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000142852 | Kruhové potrubí | 1520512512532xxxxxx0
1520512512524xxxxxx0 | Půdorys 1.PP | m | 0.024 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/24.0465/125.0000/125.0000/2/24.0465/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/24.05/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 24 | DN125 | 125 | 125 | 0.000 | 0.024 m | PO.02.30405 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000142862 | Kruhové potrubí | 1520512512524xxxxxx0
15205125125175xxxxxx0 | Půdorys 1.PP | m | 0.175 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/175.0162/125.0000/125.0000/2/175.0162/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/175.02/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 175 | DN125 | 125 | 125 | 0.000 | 0.175 m | PO.02.30406 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000142867 | Kruhové potrubí | 15205125125175xxxxxx0
15205125125199xxxxxx0 | Půdorys 1.PP | m | 0.199 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/199.2890/125.0000/125.0000/2/199.2890/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/199.29/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 199 | DN125 | 125 | 125 | 0.000 | 0.199 m | PO.02.30407 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000142877 | Kruhové potrubí | 15205125125199xxxxxx0
15205125125175xxxxxx0 | Půdorys 1.PP | m | 0.175 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/175.0379/125.0000/125.0000/2/175.0379/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/175.04/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 175 | DN125 | 125 | 125 | 0.000 | 0.175 m | PO.02.30408 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000142887 | Kruhové potrubí | 15205125125175xxxxxx0
