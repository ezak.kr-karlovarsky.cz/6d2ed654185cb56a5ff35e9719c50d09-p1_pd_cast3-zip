Properties of the parts of a building model (IFC2X3), part 27 of 51

# IfcFlowFitting (2887)
Name | In | Jednotka | Délka (m) | Označení | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_DIM | L_BES_DIM_A2 | L_BES_DIM_B2 | L_BES_DIM_A | K_VOLSTROM | K_MLH_GOST = K_MLD_GOST | K_LISTVALUE | Kód prvku | Třída reakce na oheň | Allright_Stavebni_dil_ID | Název_objektu | K_EBT_BOX_WC | Plocha | L_BES_LAENGE | K_INTERNAL_ISO | Tloušťka (m) | Součinitel tepelné vodivost
1520412512512xxxxxxx | Půdorys 1.NP | Kus | 0 | 1520412512512xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/350.6/125.0000/125.0000/125.0000/2/74.0016/24.2590/0/36.3/0/350.6/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/350.60/0/125.00/1.00/36.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | IT.03.30156 | B | 6784Obj0000010970 | Objekt | 111.002/74.629/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125136xxxxx0 | Půdorys 1.NP | Kus | 0 | 252x1250125136xxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/335.3/125.0000/125.0000/125.0000/2/101.3830/51.8803/0/54.2/0/335.3/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/335.30/0/125.00/1.00/54.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | IT.03.30157 | B | 6784Obj0000010973 | Objekt | 152.074/88.440/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125154xxxxx0 | Půdorys 1.NP | Kus | 0.097 | 252x1250125154xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/97.4845/125.0000/125.0000/2/97.4845/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/97.48/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 0.098 m | IT.03.30158 | B | 6784Obj0000010976 | Objekt | 97.485/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.098 | 97 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.063 m2
1520412512597xxxxxx0 | Půdorys 1.NP | Kus | 0.021 | 1520412512597xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/20.7000/125.0000/125.0000/2/20.7000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/20.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 0.021 m | IT.03.30159 | B | 6784Obj0000010979 | Objekt | 20.700/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.021 | 21 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.013 m2
macro | Půdorys 1.NP | Kus | 0.24 | macro | Absperrklappe elektrisch NAK-E | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/-1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/240.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 |  | DN125 | 1 | 1 | 1 | 120.000 | 0 | 1.0 | IT.03.30160 | B | 6784Obj0000010993 | Objekt | 38352.689/-7616.329/3051.990/38054.923/-7921.239/2823.484/0.000/0.000/0.000/1.000 | 1 | 240 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_DP_EBT: 0.00; K_DATE: 2023/01/13; N_FREI_68: POZINK
 | Půdorys 1.NP | Kus | 0 |  | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | IT.03.30161 | B | 6784Obj0000010996 | Objekt | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
252x125012519xxxxxx | Půdorys 1.NP | Kus | 0.29 | 252x125012519xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/290.0000/125.0000/125.0000/2/290.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/290.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.290 m | IT.03.30162 | B | 6784Obj0000010999 | Objekt | 290.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.29 | 290 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.187 m2
1520412512529xxxxxxx | Půdorys 1.NP | Kus | 0.172 | 1520412512529xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/171.6221/125.0000/125.0000/2/171.6221/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/171.62/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.172 m | IT.03.30163 | B | 6784Obj0000011002 | Objekt | 171.622/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.172 | 172 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.111 m2
15204125125172xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15204125125172xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/302.9/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/302.9/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/302.90/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.03.30164 | B | 6784Obj0000011005 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125145xxxxx0 | Půdorys 1.NP | Kus | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/132.5/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/132.5/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/132.50/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.03.30165 | B | 6784Obj0000011008 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125145xxxxx0 | Půdorys 1.NP | Kus | 0.172 | 252x1250125145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/171.5713/125.0000/125.0000/2/171.5713/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/171.57/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.172 m | IT.03.30166 | B | 6784Obj0000011011 | Objekt | 171.571/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.172 | 172 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.111 m2
15204125125172xxxxxx0 | Půdorys 1.NP | Kus | 0.096 | 15204125125172xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/95.9000/125.0000/125.0000/2/95.9000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/95.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.096 m | IT.03.30167 | B | 6784Obj0000011014 | Objekt | 95.900/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.096 | 96 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.062 m2
macro | Půdorys 1.NP | Kus | 0.24 | macro | Absperrklappe elektrisch NAK-E | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/-1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/240.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30168 | B | 6784Obj0000011028 | Objekt | 39673.915/-7436.437/2992.617/39364.417/-7701.342/2749.543/0.000/0.000/0.000/1.000 | 1 | 240 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_DP_EBT: 0.00; K_DATE: 2023/01/13; N_FREI_68: POZINK
15204160160167xxxxxx0 | Půdorys 1.NP | Kus | 0.04 | 15204160160167xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/40.0000/160.0000/160.0000/2/40.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/40.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.040 m | IT.03.30169 | B | 6784Obj0000011037 | Objekt | 40.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.04 | 40 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.030 m2
15204160160147xxxxxx0 | Půdorys 1.NP | Kus | 0.253 | 15204160160147xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/252.8560/160.0000/160.0000/2/252.8560/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/252.86/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.253 m | IT.03.30170 | B | 6784Obj0000011055 | Objekt | 252.856/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.253 | 253 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.191 m2
15204160160253xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15204160160253xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/41.4110/5.4519/0/15.0/0/0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/0/0/160.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30171 | B | 6784Obj0000011058 | Objekt | 62.117/82.726/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x160115xxxxx0 | Půdorys 1.NP | Kus | 0.145 | 252x16x160115xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/145.1552/160.0000/160.0000/2/145.1552/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/145.16/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.145 m | IT.03.30172 | B | 6784Obj0000011061 | Objekt | 145.155/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.145 | 145 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.109 m2
15204160160145xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15204160160145xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/41.4110/5.4519/0/15.0/0/180.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/180.00/0/160.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30173 | B | 6784Obj0000011064 | Objekt | 62.117/82.726/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x160115xxxxx0 | Půdorys 1.NP | Kus | 0.253 | 252x16x160115xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/252.9683/160.0000/160.0000/2/252.9683/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/252.97/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.253 m | IT.03.30174 | B | 6784Obj0000011067 | Objekt | 252.968/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.253 | 253 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.191 m2
15204160160245xxxxxx0 | Půdorys 1.NP | Kus | 0.23 | 15204160160245xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/230.0000/315.0000/315.0000/2/230.0000/0/0/0/0/0/315.0000/315.0000/315.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/230.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Alu kaschiert/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN315 | 315 | 315 | 315 | 0.000 | 0 | 0.230 m | IT.03.30175 | B | 6784Obj0000049001 | Objekt | 230.000/157.500/157.500/0.000/-157.500/-157.500/0.000/0.000/0.000/1.000 | 0.23 | 230 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.285 m2
152042x2x76xxxxxx0 | Půdorys 1.NP | Kus | 0.19 | 152042x2x76xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/190.4131/200.0000/200.0000/2/190.4131/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/190.41/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.190 m | IT.03.30176 | B | 6784Obj0000160384 | Objekt | 190.413/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.19 | 190 | __ISO | 0.04 | 0,041 W/m.K
152042x2x19xxxxxxx | Půdorys 1.NP | Kus | 0.064 | 152042x2x19xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/64.2417/200.0000/200.0000/2/64.2417/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/64.24/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.064 m | IT.03.30177 | B | 6784Obj0000160387 | Objekt | 64.242/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.064 | 64 | __ISO | 0.04 | 0,041 W/m.K
152042x2x64xxxxxx0 | Půdorys 1.NP | Kus | 0 | 152042x2x64xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/200.0000/200.0000/200.0000/2/173.2051/100.0000/0/60.0/0/0/200.0000/200.0000/200.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/0/0/200.00/1.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | IT.03.30178 | B | 6784Obj0000160390 | Objekt | 259.808/150.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x2x02x16xxxxxx | Půdorys 1.NP | Kus | 0.112 | 252x2x02x16xxxxxx | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/2/112.0000/-0.0766/0.1816/0/0/0/200.0000/200.0000/200.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/0/0/200.00/200.00/0/112.00/0.08/-0.08/0.18/-0.18/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | IT.03.30179 | B | 6784Obj0000160393 | Objekt | 112.000/100.000/100.182/0.000/-100.077/-100.000/0.000/0.000/0.000/1.000 | 1 | 112 | __ISO | 0.04 | 0,041 W/m.K
302042x2xx2x2x01120-x-03xx | Půdorys 1.NP | Kus | 0.119 | 302042x2xx2x2x01120-x-03xx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/118.9066/200.0000/200.0000/2/118.9066/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/118.91/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.119 m | IT.03.30180 | B | 6784Obj0000160396 | Objekt | 118.907/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.119 | 119 | __ISO | 0.04 | 0,041 W/m.K
152042x2x119xxxxxx0 | Půdorys 1.NP | Kus | 0 | 152042x2x119xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/200.0000/200.0000/200.0000/2/173.2051/100.0000/0/60.0/0/180.0/200.0000/200.0000/200.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/180.00/0/200.00/1.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | IT.03.30181 | B | 6784Obj0000160399 | Objekt | 259.808/150.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
152042x2x4xxxxxxx0 | Půdorys 1.NP | Kus | 1 | 152042x2x4xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1000.0000/200.0000/200.0000/2/1000.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/1000.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.000 m | IT.03.30182 | B | 6784Obj0000160405 | Objekt | 1000.000/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 1000 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
152042x2x1xxxxxxxx | Půdorys 1.NP | Kus | 0.064 | 152042x2x1xxxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/64.2417/200.0000/200.0000/2/64.2417/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/64.24/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.064 m | IT.03.30183 | B | 6784Obj0000160408 | Objekt | 64.242/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.064 | 64 | __ISO | 0.04 | 0,041 W/m.K
macro | Půdorys 1.NP | Kus | 1.25 | macro | Schalldämpfer | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/250.00/250.00/1250.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 |  | DN250 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30184 | B | 6784Obj0000160422 | Objekt | 30996.474/-6550.000/3155.000/29746.474/-6800.000/2905.000/0.000/0.000/0.000/1.000 | 1 | 1250 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_DWGNAME: ${PROD}l\einbauteile\schalldaempfer\; K_DP_EBT: 0.00; K_DATE: 2022/05/10; N_FREI_68: POZINK
1015205250250125xxxxxxx | Půdorys 1.NP | Kus | 0.432 | 1015205250250125xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/432.0000/250.0000/250.0000/2/432.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/432.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.432 m | IT.03.30185 | B | 6784Obj0000160425 | Objekt | 432.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 0.432 | 432 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.448 m2
15205250250432xxxxxx0 | Půdorys 1.NP | Kus | 0.156 | 15205250250432xxxxxx0 | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/250.0000/250.0000/2/156.3000/0/0/0/0/0/315.0000/315.0000/315.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/315.00/0/0/250.00/315.00/0/156.30/32.50/32.50/32.50/32.50/30.00/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN250 | 315 | 315 | 250 | 0.000 | 0 | 1.0 | IT.03.30186 | B | 6784Obj0000160428 | Objekt | 156.300/157.500/157.500/0.000/-157.500/-157.500/0.000/0.000/0.000/1.000 | 1 | 156 | __ISO | 0.04 | 0,041 W/m.K
30204250315x2503150156333333333x | Půdorys 1.NP | Kus | 0.025 | 30204250315x2503150156333333333x | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/24.7000/250.0000/250.0000/2/24.7000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/24.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.025 m | IT.03.30187 | B | 6784Obj0000160431 | Objekt | 24.700/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 0.025 | 25 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.026 m2
1520425025025xxxxxx0 | Půdorys 1.NP | Kus | 0.047 | 1520425025025xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/47.2352/160.0000/160.0000/2/47.2352/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/47.24/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.047 m | IT.03.30188 | B | 6784Obj0000160434 | Objekt | 47.235/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.047 | 47 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.036 m2
1520416016047xxxxxx0 | Půdorys 1.NP | Kus | 0 | 1520416016047xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/150.8/160.0000/160.0000/160.0000/2/159.3912/146.0551/0/85.0/0/150.8/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/150.80/0/160.00/1.00/85.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30189 | B | 6784Obj0000160437 | Objekt | 239.087/153.028/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x160185xxxxx0 | Půdorys 1.NP | Kus | 0.019 | 252x16x160185xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/19.2872/160.0000/160.0000/2/19.2872/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/19.29/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.019 m | IT.03.30190 | B | 6784Obj0000160440 | Objekt | 19.287/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.019 | 19 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.015 m2
1520416016019xxxxxx0 | Půdorys 1.NP | Kus | 0 | 1520416016019xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/357.2/160.0000/160.0000/160.0000/2/159.3912/146.0551/0/85.0/0/357.2/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/357.20/0/160.00/1.00/85.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30191 | B | 6784Obj0000160443 | Objekt | 239.087/153.028/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x160185xxxxx0 | Půdorys 1.NP | Kus | 0.06 | 252x16x160185xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/60.0000/160.0000/160.0000/2/60.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.060 m | IT.03.30192 | B | 6784Obj0000160446 | Objekt | 60.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.06 | 60 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.045 m2
152041601606xxxxxxx | Půdorys 1.NP | Kus | 0.06 | 152041601606xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/60.0000/160.0000/160.0000/2/60.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.060 m | IT.03.30193 | B | 6784Obj0000160449 | Objekt | 60.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.06 | 60 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.045 m2
152041601606xxxxxxx | Půdorys 1.NP | Kus | 0.615 | 152041601606xxxxxxx | T-STCK. GERADE | 20 | 1016 | 3/0/0/0/180.0/0/0/315.0000/315.0000/160.0000/1/230.0000/-307.5000/0/270.0/0/0/1.0000/160.0000/160.0000/1/230.0000/307.5000/0/90.0/0/0/160.0000/160.0000/160.0000/1/ | 70/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/315.00/315.00/50.00/50.00/50.00/50.00/160.00/0/0/0/615.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 160 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.03.30194 | B | 6784Obj0000160505 | Objekt | 330.000/307.500/100.000/0.000/-307.500/-100.000/0.000/0.000/0.000/1.000 | 1 | 615 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
701061601603153155050505016x0615 | Půdorys 1.NP | Kus | 0.269 | 701061601603153155050505016x0615 | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/2/269.2000/0/0/0/0/0/0/160.0000/160.0000/1/ | 50/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/160.00/160.00/35.00/100.00/160.00/160.00/160.00/269.20/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.03.30195 | B | 6784Obj0000160527 | Objekt | 269.200/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 269 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); K_LISTVALUE_ISO: 1.000 m2
50216160160351x160160160269xxxx | Půdorys 1.NP | Kus | 0.15 | 50216160160351x160160160269xxxx | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/2/150.0000/0/0/0/0/0/0/160.0000/160.0000/1/ | 50/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/160.00/160.00/35.00/100.00/160.00/160.00/160.00/150.00/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.03.30196 | B | 6784Obj0000160549 | Objekt | 150.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 150 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); K_LISTVALUE_ISO: 1.000 m2
50216160160351x16016016015xxxx0 | Půdorys 1.NP | Kus | 0.073 | 50216160160351x16016016015xxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/73.2210/160.0000/160.0000/2/73.2210/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/73.22/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.073 m | IT.03.30197 | B | 6784Obj0000160552 | Objekt | 73.221/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.073 | 73 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.055 m2
1520616016073xxxxxx0 | Půdorys 1.NP | Kus | 0 | 1520616016073xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/270.0/160.0000/160.0000/160.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.00/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30198 | B | 6784Obj0000160555 | Objekt | 120.000/90.718/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16013xxxxxx | Půdorys 1.NP | Kus | 0.064 | 252x16x16013xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/64.2563/160.0000/160.0000/2/64.2563/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/64.26/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.064 m | IT.03.30199 | B | 6784Obj0000160558 | Objekt | 64.256/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.064 | 64 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.048 m2
1520616016064xxxxxx0 | Půdorys 1.NP | Kus | 0 | 1520616016064xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30200 | B | 6784Obj0000160561 | Objekt | 120.000/90.718/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16013xxxxxx | Půdorys 1.NP | Kus | 0.073 | 252x16x16013xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/73.1716/160.0000/160.0000/2/73.1716/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/73.17/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.073 m | IT.03.30201 | B | 6784Obj0000160564 | Objekt | 73.172/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.073 | 73 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.055 m2
1520616016073xxxxxx0 | Půdorys 1.NP | Kus | 0.021 | 1520616016073xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/21.1806/160.0000/160.0000/2/21.1806/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/21.18/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.021 m | IT.03.30202 | B | 6784Obj0000160567 | Objekt | 21.181/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.021 | 21 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.016 m2
1520616016021xxxxxx0 | Půdorys 1.NP | Kus | 0 | 1520616016021xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/270.0/160.0000/160.0000/160.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.00/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30203 | B | 6784Obj0000160570 | Objekt | 120.000/90.718/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16013xxxxxx | Půdorys 1.NP | Kus | 0.064 | 252x16x16013xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/64.2563/160.0000/160.0000/2/64.2563/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/64.26/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.064 m | IT.03.30204 | B | 6784Obj0000160573 | Objekt | 64.256/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.064 | 64 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.048 m2
1520616016064xxxxxx0 | Půdorys 1.NP | Kus | 0 | 1520616016064xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30205 | B | 6784Obj0000160576 | Objekt | 120.000/90.718/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16013xxxxxx | Půdorys 1.NP | Kus | 0.021 | 252x16x16013xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/20.9316/160.0000/160.0000/2/20.9316/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/20.93/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.021 m | IT.03.30206 | B | 6784Obj0000160579 | Objekt | 20.932/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.021 | 21 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.016 m2
1520616016021xxxxxx0 | Půdorys 1.NP | Kus | 0.4 | 1520616016021xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/400.0000/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/400.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.03.30207 | B | 6784Obj0000160593 | Objekt | 400.000/177.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1 | 400 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
101063151604xxxxxxx0 | Půdorys 1.NP | Kus | 0.06 | 101063151604xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/60.0000/160.0000/160.0000/2/60.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.060 m | IT.03.30208 | B | 6784Obj0000160596 | Objekt | 60.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.06 | 60 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.045 m2
152041601606xxxxxxx | Půdorys 1.NP | Kus | 0.083 | 152041601606xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/82.9124/160.0000/160.0000/2/82.9124/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/82.91/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.083 m | IT.03.30209 | B | 6784Obj0000160599 | Objekt | 82.912/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.083 | 83 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.063 m2
1520416016083xxxxxx0 | Půdorys 1.NP | Kus | 0.06 | 1520416016083xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/60.0000/100.0000/100.0000/2/60.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 0.060 m | IT.03.30210 | B | 6784Obj0000160602 | Objekt | 60.000/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.06 | 60 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.034 m2
152041x1x6xxxxxxx | Půdorys 1.NP | Kus | 0.024 | 152041x1x6xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/24.3714/100.0000/100.0000/2/24.3714/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/24.37/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 0.024 m | IT.03.30211 | B | 6784Obj0000160605 | Objekt | 24.371/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.024 | 24 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.014 m2
152041x1x24xxxxxx0 | Půdorys 1.NP | Kus | 0 | 152041x1x24xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/231.7/100.0000/100.0000/100.0000/2/70.7107/29.2893/0/45.0/0/231.7/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/231.70/0/100.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | IT.03.30212 | B | 6784Obj0000160608 | Objekt | 106.066/64.645/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1x01x145xxxxx0 | Půdorys 1.NP | Kus | 0.044 | 252x1x01x145xxxxx0 | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/100.0000/100.0000/2/44.0000/-0.1273/0.0314/0/0/0/100.0000/100.0000/100.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/0/0/100.00/100.00/0/44.00/0.13/-0.13/0.03/-0.03/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | IT.03.30213 | B | 6784Obj0000160611 | Objekt | 44.000/50.000/50.031/0.000/-50.127/-50.000/0.000/0.000/0.000/1.000 | 1 | 44 | __ISO | 0.04 | 0,041 W/m.K
302041x1xx1x1x0440-x-03xx | Půdorys 1.NP | Kus | 0 | 302041x1xx1x1x0440-x-03xx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/41.8/100.0000/100.0000/100.0000/2/70.7107/29.2893/0/45.0/0/41.8/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/41.80/0/100.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | IT.03.30214 | B | 6784Obj0000160614 | Objekt | 106.066/64.645/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1x01x145xxxxx0 | Půdorys 1.NP | Kus | 0.024 | 252x1x01x145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/24.3714/100.0000/100.0000/2/24.3714/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/24.37/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 0.024 m | IT.03.30215 | B | 6784Obj0000160617 | Objekt | 24.371/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.024 | 24 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.014 m2
152041x1x24xxxxxx0 | Půdorys 1.NP | Kus | 0.232 | 152041x1x24xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/231.8000/100.0000/100.0000/2/231.8000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/231.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 0.232 m | IT.03.30216 | B | 6784Obj0000160620 | Objekt | 231.800/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.232 | 232 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.131 m2
macro | Půdorys 1.NP | Kus | 0.2 | macro | Absperrklappe händisch NAK-H | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/-1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/100.00/100.00/200.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 |  | DN100 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30217 | B | 6784Obj0000160634 | Objekt | 35640.138/-7028.562/2940.589/35385.698/-7251.694/2746.414/0.000/0.000/0.000/1.000 | 1 | 200 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_DP_EBT: 0.00; K_DATE: 2023/01/04; N_FREI_68: SPIRO POTRUBÍ
10152041x1x2xxxxxxx0 | Půdorys 1.NP | Kus | 0.566 | 10152041x1x2xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/566.0000/160.0000/160.0000/2/566.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/566.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.566 m | IT.03.30218 | B | 6784Obj0000160637 | Objekt | 566.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.566 | 566 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.427 m2
macro | Půdorys 1.NP | Kus | 0.31 | macro | Absperrklappe elektrisch NAK-E | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/-1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/160.00/160.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 |  | DN160 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30219 | B | 6784Obj0000160651 | Objekt | 31943.474/-7592.747/3110.000/31633.474/-7792.747/2950.000/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_DP_EBT: 0.00; K_DATE: 2023/01/04; N_FREI_68: SPIRO POTRUBÍ
 | Půdorys 1.NP | Kus | 0.245 |  | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/245.0000/160.0000/160.0000/2/245.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/245.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.245 m | IT.03.30220 | B | 6784Obj0000160654 | Objekt | 245.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.245 | 245 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.185 m2
15204160160245xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15204160160245xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/180.0/315.0000/315.0000/160.0000/1/222.0513/59.4985/0/30.0/0/180.0/1.0000/315.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/0/50.00/50.00/160.00/100.00/30.00/180.00/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.03.30221 | B | 6784Obj0000160736 | Objekt | 310.801/213.218/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
20104315315050501601x3016xxxx | Půdorys 1.NP | Kus | 0.531 | 20104315315050501601x3016xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/530.5193/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/530.52/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.03.30222 | B | 6784Obj0000160750 | Objekt | 530.519/177.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1 | 531 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
10104315160531xxxxxx0 | Půdorys 1.NP | Kus | 0 | 10104315160531xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/315.0000/315.0000/160.0000/1/222.0513/59.4985/0/30.0/0/0/1.0000/315.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/0/50.00/50.00/160.00/100.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.03.30223 | B | 6784Obj0000160832 | Objekt | 310.801/213.218/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
20104315315050501601x3016xxxx | Půdorys 1.NP | Kus | 1.097 | 20104315315050501601x3016xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/1097.0867/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/1097.09/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.040 m2 | IT.03.30224 | B | 6784Obj0000160846 | Objekt | 1097.087/177.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1.04 | 1097 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.390 m2
 | Půdorys 1.NP | Kus | 0.085 |  | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/2/85.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/160.00/0/0/200.00/160.00/0/85.00/-20.00/-20.00/-20.00/-20.00/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 160 | 160 | 200 | 0.000 | 0 | 1.0 | IT.03.30225 | B | 6784Obj0000160849 | Objekt | 85.000/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 85 | __ISO | 0.04 | 0,041 W/m.K
302042x16x02x16x85-20-20-20-203x | Půdorys 1.NP | Kus | 0.19 | 302042x16x02x16x85-20-20-20-203x | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/180.0/200.0000/200.0000/200.0000/2/190.0000/0/0/0/0/180.0/1.0000/200.0000/200.0000/2/95.0000/145.0000/0/90.0/0/180.0/100.0000/100.0000/100.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/100.00/0/180.00/190.00/0/145.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | IT.03.30226 | B | 6784Obj0000160853 | Objekt | 190.000/145.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 190 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
752042x2x1x019x14509xxxx | Půdorys 1.NP | Kus | 0.38 | 752042x2x1x019x14509xxxx | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/0/250.0000/250.0000/250.0000/2/190.0000/-190.0000/0/270.0/0/0/1.0000/250.0000/250.0000/2/190.0000/190.0000/0/90.0/0/0/250.0000/250.0000/250.0000/2/ | 75/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/250.00/0/0/380.00/0/190.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | IT.03.30227 | B | 6784Obj0000160857 | Objekt | 315.000/190.000/125.000/0.000/-190.000/-125.000/0.000/0.000/0.000/1.000 | 1 | 380 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
macro | Půdorys 1.NP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/200.00/200.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 |  | DN200 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30228 | B | 6784Obj0000160871 | Objekt | 34347.474/-6575.000/3175.000/34037.474/-6775.000/2975.000/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/03; N_FREI_68: POZINK
10152062x2x31xxxxxxx | Půdorys 1.NP | Kus | 0.099 | 10152062x2x31xxxxxxx | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/250.0000/250.0000/250.0000/2/99.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 30/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/200.00/0/0/250.00/200.00/0/99.00/-25.00/-25.00/-25.00/-25.00/30.00/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 200 | 200 | 250 | 0.000 | 0 | 1.0 | IT.03.30229 | B | 6784Obj0000160874 | Objekt | 99.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 1 | 99 | __ISO | 0.04 | 0,041 W/m.K
302062502xx2502x099-25-25-25-253 | Půdorys 1.NP | Kus | 0.238 | 302062502xx2502x099-25-25-25-253 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/238.1588/250.0000/250.0000/2/238.1588/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/238.16/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.238 m | IT.03.30230 | B | 6784Obj0000160877 | Objekt | 238.159/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 0.238 | 238 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.247 m2
15206250250238xxxxxx0 | Půdorys 1.NP | Kus | 0.208 | 15206250250238xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/208.4000/160.0000/160.0000/2/208.4000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/208.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.208 m | IT.03.30231 | B | 6784Obj0000160880 | Objekt | 208.400/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.208 | 208 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.157 m2
15206160160208xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15206160160208xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/0/160.0000/160.0000/160.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/0/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30232 | B | 6784Obj0000160883 | Objekt | 240.000/160.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16019xxxxxx | Půdorys 1.NP | Kus | 0.015 | 252x16x16019xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/14.6973/160.0000/160.0000/2/14.6973/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/14.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.015 m | IT.03.30233 | B | 6784Obj0000160886 | Objekt | 14.697/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.015 | 15 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.011 m2
1520616016015xxxxxx0 | Půdorys 1.NP | Kus | 0 | 1520616016015xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/270.0/160.0000/160.0000/160.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30234 | B | 6784Obj0000160889 | Objekt | 169.706/103.431/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x160145xxxxx0 | Půdorys 1.NP | Kus | 0.334 | 252x16x160145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/334.1770/160.0000/160.0000/2/334.1770/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/334.18/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.334 m | IT.03.30235 | B | 6784Obj0000160892 | Objekt | 334.177/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.334 | 334 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.252 m2
15206160160334xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15206160160334xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30236 | B | 6784Obj0000160895 | Objekt | 169.706/103.431/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x160145xxxxx0 | Půdorys 1.NP | Kus | 0.015 | 252x16x160145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/14.6426/160.0000/160.0000/2/14.6426/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/14.64/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.015 m | IT.03.30237 | B | 6784Obj0000160898 | Objekt | 14.643/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.015 | 15 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.011 m2
1520616016015xxxxxx0 | Půdorys 1.NP | Kus | 0.035 | 1520616016015xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/35.0386/100.0000/100.0000/2/35.0386/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/35.04/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 0.035 m | IT.03.30238 | B | 6784Obj0000160901 | Objekt | 35.039/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.035 | 35 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.020 m2
152041x1x35xxxxxx0 | Půdorys 1.NP | Kus | 0 | 152041x1x35xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/0/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | IT.03.30239 | B | 6784Obj0000160904 | Objekt | 150.000/100.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1x01x19xxxxxx | Půdorys 1.NP | Kus | 0.402 | 252x1x01x19xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/402.0000/100.0000/100.0000/2/402.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/402.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 0.402 m | IT.03.30240 | B | 6784Obj0000160907 | Objekt | 402.000/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.402 | 402 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.227 m2
152041x1x402xxxxxx0 | Půdorys 1.NP | Kus | 0.209 | 152041x1x402xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/209.0000/200.0000/200.0000/2/209.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/209.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.209 m | IT.03.30241 | B | 6784Obj0000160910 | Objekt | 209.000/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.209 | 209 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.184 m2
