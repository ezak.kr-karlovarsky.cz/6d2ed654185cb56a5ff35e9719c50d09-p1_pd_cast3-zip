Properties of the parts of a building model (IFC2X3), part 47 of 51

# IfcFlowSegment (1090)
Name | In | Jednotka | Délka (m) | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_LAENGE | L_BES_DIM | L_BES_DIM_A2 = L_BES_DIM_A | L_BES_DIM_B2 | K_VOLSTROM | K_LISTVALUE | Kód prvku | Podlaží | Průměr | Teplonosná látka | Allright_Stavebni_dil_ID | Název_objektu | Označení | K_LISTVALUE_ISO
101052502x182xxxxxx0 | Půdorys 1.NP | m2 | 0.182 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/250.0000/200.0000/1/182.0000/0/0/0/0/0/1.0000/250.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/200.00/182.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 182 | 250x200 | 250 | 200 | 0.000 | 1.000 m2 | PO.03.30129 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798480051 | Objekt | 101052502x182xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.58; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.25 m; Výška: 0.2 m
101052502x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/250.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/250.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 250x200 | 250 | 200 | 0.000 | 1.350 m2 | PO.03.30130 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798480091 | Objekt | 101052502x15xxxxxxx0 | 1.830 m2 | NEMSOK - K_POSITION: L.62; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.25 m; Výška: 0.2 m
101052502x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/250.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/250.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 250x200 | 250 | 200 | 0.000 | 1.350 m2 | PO.03.30131 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798480106 | Objekt | 101052502x15xxxxxxx0 | 1.830 m2 | NEMSOK - K_POSITION: L.63; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.25 m; Výška: 0.2 m
101052502x162xxxxxx0 | Půdorys 1.NP | m2 | 0.162 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/250.0000/200.0000/1/162.0000/0/0/0/0/0/1.0000/250.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/200.00/162.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 162 | 250x200 | 250 | 200 | 0.000 | 1.000 m2 | PO.03.30132 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798480121 | Objekt | 101052502x162xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.64; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.25 m; Výška: 0.2 m
101052802x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/280.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/280.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 280x200 | 280 | 200 | 0.000 | 1.440 m2 | PO.03.30133 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798480136 | Objekt | 101052802x15xxxxxxx0 | 1.920 m2 | NEMSOK - K_POSITION: L.65; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.28 m; Výška: 0.2 m
101052802x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/280.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/280.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 280x200 | 280 | 200 | 0.000 | 1.440 m2 | PO.03.30134 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798480151 | Objekt | 101052802x15xxxxxxx0 | 1.920 m2 | NEMSOK - K_POSITION: L.66; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.28 m; Výška: 0.2 m
101052802x181xxxxxx0 | Půdorys 1.NP | m2 | 0.181 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/280.0000/200.0000/1/181.0000/0/0/0/0/0/1.0000/280.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/200.00/181.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 181 | 280x200 | 280 | 200 | 0.000 | 1.000 m2 | PO.03.30135 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798480166 | Objekt | 101052802x181xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.67; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.28 m; Výška: 0.2 m
101052802x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/280.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/280.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 280x200 | 280 | 200 | 0.000 | 1.440 m2 | PO.03.30136 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798480181 | Objekt | 101052802x15xxxxxxx0 | 1.920 m2 | NEMSOK - K_POSITION: L.68; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.28 m; Výška: 0.2 m
101052802x1313xxxxxx0 | Půdorys 1.NP | m2 | 1.313 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/280.0000/200.0000/1/1312.5000/0/0/0/0/0/1.0000/280.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/200.00/1312.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1313 | 280x200 | 280 | 200 | 0.000 | 1.260 m2 | PO.03.30137 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798480196 | Objekt | 101052802x1313xxxxxx0 | 1.680 m2 | NEMSOK - K_POSITION: L.69; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.28 m; Výška: 0.2 m
101053152x1093xxxxxx0 | Půdorys 1.NP | m2 | 1.093 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/200.0000/1/1093.4000/0/0/0/0/0/1.0000/315.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/200.00/1093.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1093 | 315x200 | 315 | 200 | 0.000 | 1.130 m2 | PO.03.30138 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798480211 | Objekt | 101053152x1093xxxxxx0 | 1.480 m2 | NEMSOK - K_POSITION: L.70; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.315 m; Výška: 0.2 m
1520516016022xxxxxxx | Půdorys 1.NP | m | 0.22 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/219.9826/160.0000/160.0000/2/219.9826/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/219.98/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 220 | DN160 | 160 | 160 | 0.000 | 0.220 m | PO.03.30139 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798480256 | Objekt | 1520516016022xxxxxxx | 0.166 m2
101054x2x1415xxxxxx0 | Půdorys 1.NP | m2 | 1.415 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/400.0000/200.0000/1/1414.5000/0/0/0/0/0/1.0000/400.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/200.00/1414.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1415 | 400x200 | 400 | 200 | 0.000 | 1.700 m2 | PO.03.30140 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798480276 | Objekt | 101054x2x1415xxxxxx0 | 2.150 m2 | NEMSOK - K_POSITION: L.77; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.4 m; Výška: 0.2 m
1520512512521xxxxxx0 | Půdorys 1.NP | m | 0.021 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/21.4000/125.0000/125.0000/2/21.4000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/21.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 21 | DN125 | 125 | 125 | 0.000 | 0.021 m | PO.03.30141 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798480281 | Objekt | 1520512512521xxxxxx0 | 0.014 m2
1520512512569xxxxxx0 | Půdorys 1.NP | m | 0.069 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/69.4000/125.0000/125.0000/2/69.4000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/69.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 69 | DN125 | 125 | 125 | 0.000 | 0.069 m | PO.03.30142 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798480286 | Objekt | 1520512512569xxxxxx0 | 0.045 m2
1520512512557xxxxxx0 | Půdorys 1.NP | m | 0.057 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/57.4000/125.0000/125.0000/2/57.4000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/57.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 57 | DN125 | 125 | 125 | 0.000 | 0.057 m | PO.03.30143 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798480291 | Objekt | 1520512512557xxxxxx0 | 0.037 m2
152051251252xxxxxxx | Půdorys 1.NP | m | 0.02 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/20.4000/125.0000/125.0000/2/20.4000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/20.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 20 | DN125 | 125 | 125 | 0.000 | 0.020 m | PO.03.30144 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798480296 | Objekt | 152051251252xxxxxxx | 0.013 m2
1520512512527xxxxxx0 | Půdorys 1.NP | m | 0.027 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/27.4000/125.0000/125.0000/2/27.4000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/27.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 27 | DN125 | 125 | 125 | 0.000 | 0.027 m | PO.03.30145 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798480301 | Objekt | 1520512512527xxxxxx0 | 0.018 m2
101054x2x1315xxxxxx0 | Půdorys 1.NP | m2 | 1.315 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/400.0000/200.0000/1/1315.0000/0/0/0/0/0/1.0000/400.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/200.00/1315.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1315 | 400x200 | 400 | 200 | 0.000 | 1.580 m2 | PO.03.30146 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798480316 | Objekt | 101054x2x1315xxxxxx0 | 2.000 m2 | NEMSOK - K_POSITION: L.83; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.4 m; Výška: 0.2 m
152042x2x381xxxxxx0 | Půdorys 1.NP | m | 0.381 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/381.1573/200.0000/200.0000/2/381.1573/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/381.16/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 381 | DN200 | 200 | 200 | 0.000 | 0.381 m | PO.03.30147 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798482977 | Objekt | 152042x2x381xxxxxx0 | 0.335 m2
152062x2x319xxxxxx0 | Půdorys 1.NP | m | 0.319 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/318.9317/200.0000/200.0000/2/318.9317/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/318.93/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 319 | DN200 | 200 | 200 | 0.000 | 0.319 m | PO.03.30148 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798483007 | Objekt | 152062x2x319xxxxxx0 | 0.281 m2
1520512512549xxxxxx0 | Půdorys 1.NP | m | 0.049 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/48.6000/125.0000/125.0000/2/48.6000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/48.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 49 | DN125 | 125 | 125 | 0.000 | 0.049 m | PO.03.30149 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798483202 | Objekt | 1520512512549xxxxxx0 | 0.031 m2
101052802x129xxxxxxx | Půdorys 1.NP | m2 | 1.29 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/280.0000/200.0000/1/1290.2000/0/0/0/0/0/1.0000/280.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/200.00/1290.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1290 | 280x200 | 280 | 200 | 0.000 | 1.240 m2 | PO.03.30150 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798483372 | Objekt | 101052802x129xxxxxxx | 1.650 m2 | NEMSOK - K_POSITION: L.47; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.28 m; Výška: 0.2 m
101052502x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/250.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/250.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 250x200 | 250 | 200 | 0.000 | 1.350 m2 | PO.03.30151 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798483432 | Objekt | 101052502x15xxxxxxx0 | 1.830 m2 | NEMSOK - K_POSITION: L.51; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.25 m; Výška: 0.2 m
101052502x556xxxxxx0 | Půdorys 1.NP | m2 | 0.556 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/250.0000/200.0000/1/555.5000/0/0/0/0/0/1.0000/250.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/200.00/555.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 556 | 250x200 | 250 | 200 | 0.000 | 1.000 m2 | PO.03.30152 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798483447 | Objekt | 101052502x556xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.52; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.25 m; Výška: 0.2 m
101052502x474xxxxxx0 | Půdorys 1.NP | m2 | 0.474 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/250.0000/200.0000/1/474.4000/0/0/0/0/0/1.0000/250.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/200.00/474.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 474 | 250x200 | 250 | 200 | 0.000 | 1.000 m2 | PO.03.30153 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798483462 | Objekt | 101052502x474xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.53; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.25 m; Výška: 0.2 m
101052x2x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/200.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 200x200 | 200 | 200 | 0.000 | 1.200 m2 | PO.03.30154 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798483477 | Objekt | 101052x2x15xxxxxxx0 | 1.680 m2 | NEMSOK - K_POSITION: L.54; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.2 m; Výška: 0.2 m
101052x2x509xxxxxx0 | Půdorys 1.NP | m2 | 0.509 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/1/508.5000/0/0/0/0/0/1.0000/200.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/508.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 509 | 200x200 | 200 | 200 | 0.000 | 1.000 m2 | PO.03.30155 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798483492 | Objekt | 101052x2x509xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.55; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.2 m; Výška: 0.2 m
101052802x103xxxxxxx | Půdorys 1.NP | m2 | 1.03 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/280.0000/200.0000/1/1029.6000/0/0/0/0/0/1.0000/280.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/200.00/1029.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1030 | 280x200 | 280 | 200 | 0.000 | 0.990 m2 | PO.03.30156 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798483557 | Objekt | 101052802x103xxxxxxx | 1.320 m2 | NEMSOK - K_POSITION: L.62; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.28 m; Výška: 0.2 m
152041x1x422xxxxxx0 | Půdorys 1.NP | m | 0.422 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/422.0000/100.0000/100.0000/2/422.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/422.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 422 | DN100 | 100 | 100 | 0.000 | 0.422 m | PO.03.30157 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798483649 | Objekt | 152041x1x422xxxxxx0 | 0.239 m2
152041x1x412xxxxxx0 | Půdorys 1.NP | m | 0.412 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/412.0000/100.0000/100.0000/2/412.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/412.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 412 | DN100 | 100 | 100 | 0.000 | 0.412 m | PO.03.30158 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798483656 | Objekt | 152041x1x412xxxxxx0 | 0.233 m2
152041x1x507xxxxxx0 | Půdorys 1.NP | m | 0.507 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/507.0000/100.0000/100.0000/2/507.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/507.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 507 | DN100 | 100 | 100 | 0.000 | 0.507 m | PO.03.30159 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798483661 | Objekt | 152041x1x507xxxxxx0 | 0.287 m2
152051x1x788xxxxxx0 | Půdorys 1.NP | m | 0.788 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/478.1000/100.0000/100.0000/2/478.1000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/478.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 478 | DN100 | 100 | 100 | 0.000 | 0.478 m | PO.03.30160 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798483687 | Objekt | 152051x1x788xxxxxx0 | 0.270 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 788.100|50.000|50.000|0.000|-50.000|-50.000|0.000|0.000|0.000|1.000
1520616016062xxxxxxx | Půdorys 1.NP | m | 0.62 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/619.9000/160.0000/160.0000/2/619.9000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/619.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 620 | DN160 | 160 | 160 | 0.000 | 0.620 m | PO.03.30161 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798483711 | Objekt | 1520616016062xxxxxxx | 0.467 m2
1520416016022xxxxxxx | Půdorys 1.NP | m | 0.22 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/219.9826/160.0000/160.0000/2/219.9826/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/219.98/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 220 | DN160 | 160 | 160 | 0.000 | 0.220 m | PO.03.30162 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798483892 | Objekt | 1520416016022xxxxxxx | 0.166 m2
152042x2x3785xxxxxx0 | Půdorys 1.NP | m | 3.785 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/3784.6000/200.0000/200.0000/2/3784.6000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/3784.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 3785 | DN200 | 200 | 200 | 0.000 | 3.785 m | PO.03.30163 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798483976 | Konstrukce v aktuální hladině | 152042x2x3785xxxxxx0 | 3.329 m2
1520516016022xxxxxxx | Půdorys 1.NP | m | 0.22 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/219.6934/160.0000/160.0000/2/219.6934/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/219.69/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 220 | DN160 | 160 | 160 | 0.000 | 0.220 m | PO.03.30164 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798484024 | Objekt | 1520516016022xxxxxxx | 0.166 m2
15205160160384xxxxxx0 | Půdorys 1.NP | m | 0.384 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/73.8000/160.0000/160.0000/2/73.8000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/73.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 74 | DN160 | 160 | 160 | 0.000 | 0.074 m | PO.03.30165 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798484036 | Objekt | 15205160160384xxxxxx0 | 0.056 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 383.800|80.000|80.000|0.000|-80.000|-80.000|0.000|0.000|0.000|1.000
15205125125666xxxxxx0 | Půdorys 1.NP | m | 0.666 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/356.4000/125.0000/125.0000/2/356.4000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/356.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 356 | DN125 | 125 | 125 | 0.000 | 0.356 m | PO.03.30166 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798484046 | Objekt | 15205125125666xxxxxx0 | 0.230 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 666.400|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
15205125125605xxxxxx0 | Půdorys 1.NP | m | 0.605 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/295.4000/125.0000/125.0000/2/295.4000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/295.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 295 | DN125 | 125 | 125 | 0.000 | 0.295 m | PO.03.30167 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798484056 | Objekt | 15205125125605xxxxxx0 | 0.190 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 605.400|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
15205125125609xxxxxx0 | Půdorys 1.NP | m | 0.609 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/299.4000/125.0000/125.0000/2/299.4000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/299.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 299 | DN125 | 125 | 125 | 0.000 | 0.299 m | PO.03.30168 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798484066 | Objekt | 15205125125609xxxxxx0 | 0.193 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 609.400|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
1520512512559xxxxxxx | Půdorys 1.NP | m | 0.59 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/280.4000/125.0000/125.0000/2/280.4000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/280.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 280 | DN125 | 125 | 125 | 0.000 | 0.280 m | PO.03.30169 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798484076 | Objekt | 1520512512559xxxxxxx | 0.181 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 590.400|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
15205125125585xxxxxx0 | Půdorys 1.NP | m | 0.585 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/275.4000/125.0000/125.0000/2/275.4000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/275.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 275 | DN125 | 125 | 125 | 0.000 | 0.275 m | PO.03.30170 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798484089 | Objekt | 15205125125585xxxxxx0 | 0.177 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 585.400|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
15205160160427xxxxxx0 | Půdorys 1.NP | m | 0.427 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/117.1000/160.0000/160.0000/2/117.1000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/117.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 117 | DN160 | 160 | 160 | 0.000 | 0.117 m | PO.03.30171 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798484099 | Objekt | 15205160160427xxxxxx0 | 0.088 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 427.128|80.000|80.000|0.000|-80.000|-80.000|0.000|0.000|0.000|1.000
15205125125367xxxxxx0 | Půdorys 1.NP | m | 0.367 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/56.7000/125.0000/125.0000/2/56.7000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/56.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 57 | DN125 | 125 | 125 | 0.000 | 0.057 m | PO.03.30172 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798484109 | Objekt | 15205125125367xxxxxx0 | 0.037 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 366.673|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
15205125125367xxxxxx0 | Půdorys 1.NP | m | 0.367 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/56.7000/125.0000/125.0000/2/56.7000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/56.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 57 | DN125 | 125 | 125 | 0.000 | 0.057 m | PO.03.30173 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798484119 | Objekt | 15205125125367xxxxxx0 | 0.037 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 366.673|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
15205125125367xxxxxx0 | Půdorys 1.NP | m | 0.367 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/56.7000/125.0000/125.0000/2/56.7000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/56.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 57 | DN125 | 125 | 125 | 0.000 | 0.057 m | PO.03.30174 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798484129 | Objekt | 15205125125367xxxxxx0 | 0.037 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 366.673|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
15205125125367xxxxxx0 | Půdorys 1.NP | m | 0.367 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/56.7000/125.0000/125.0000/2/56.7000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/56.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 57 | DN125 | 125 | 125 | 0.000 | 0.057 m | PO.03.30175 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798484139 | Objekt | 15205125125367xxxxxx0 | 0.037 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 366.673|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
15205125125367xxxxxx0 | Půdorys 1.NP | m | 0.367 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/56.7000/125.0000/125.0000/2/56.7000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/56.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 57 | DN125 | 125 | 125 | 0.000 | 0.057 m | PO.03.30176 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798484149 | Objekt | 15205125125367xxxxxx0 | 0.037 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 366.673|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
15205125125558xxxxxx0 | Půdorys 1.NP | m | 0.558 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/248.0000/125.0000/125.0000/2/248.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/248.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 248 | DN125 | 125 | 125 | 0.000 | 0.248 m | PO.03.30177 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798484212 | Objekt | 15205125125558xxxxxx0 | 0.160 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 558.000|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
152052x2x389xxxxxx0 | Půdorys 1.NP | m | 0.389 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/78.5000/200.0000/200.0000/2/78.5000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/78.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 79 | DN200 | 200 | 200 | 0.000 | 0.079 m | PO.03.30178 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798484232 | Objekt | 152052x2x389xxxxxx0 | 0.069 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 388.500|100.000|100.000|0.000|-100.000|-100.000|0.000|0.000|0.000|1.000
152052x2x414xxxxxx0 | Půdorys 1.NP | m | 0.414 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/103.5000/200.0000/200.0000/2/103.5000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/103.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 104 | DN200 | 200 | 200 | 0.000 | 0.104 m | PO.03.30179 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798484242 | Objekt | 152052x2x414xxxxxx0 | 0.091 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 413.500|100.000|100.000|0.000|-100.000|-100.000|0.000|0.000|0.000|1.000
152052x2x2473xxxxxx0 | Půdorys 1.NP | m | 2.473 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/2163.1000/200.0000/200.0000/2/2163.1000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/2163.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 2163 | DN200 | 200 | 200 | 0.000 | 2.163 m | PO.03.30180 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798484252 | Objekt | 152052x2x2473xxxxxx0 | 1.903 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 2473.100|100.000|100.000|0.000|-100.000|-100.000|0.000|0.000|0.000|1.000
15205125125294xxxxxx0 | Půdorys 1.NP | m | 0.294 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/3.5000/125.0000/125.0000/2/3.5000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/3.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 4 | DN125 | 125 | 125 | 0.000 | 0.004 m | PO.03.30181 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798484321 | Objekt | 15205125125294xxxxxx0 | 0.002 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 293.500|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
15204160160303xxxxxx0 | Půdorys 1.NP | m | 0.303 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/302.8000/160.0000/160.0000/2/302.8000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/302.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 303 | DN160 | 160 | 160 | 0.000 | 0.303 m | PO.03.30182 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798484428 | Objekt | 15204160160303xxxxxx0 | 0.228 m2
15204160160125xxxxxx0 | Půdorys 1.NP | m | 0.125 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/125.0000/160.0000/160.0000/2/125.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/125.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 125 | DN160 | 160 | 160 | 0.000 | 0.125 m | PO.03.30183 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798484504 | Objekt | 15204160160125xxxxxx0 | 0.094 m2
152042x2x761xxxxxx0 | Půdorys 1.NP | m | 0.761 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/451.2000/200.0000/200.0000/2/451.2000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/451.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 451 | DN200 | 200 | 200 | 0.000 | 0.451 m | PO.03.30184 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798484516 | Objekt | 152042x2x761xxxxxx0 | 0.397 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 761.200|100.000|100.000|0.000|-100.000|-100.000|0.000|0.000|0.000|1.000
15204125125583xxxxxx0 | Půdorys 1.NP | m | 0.583 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/272.9000/125.0000/125.0000/2/272.9000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/272.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 273 | DN125 | 125 | 125 | 0.000 | 0.273 m | PO.03.30185 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798484526 | Objekt | 15204125125583xxxxxx0 | 0.176 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 582.863|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/160.0000/160.0000/2/30.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN160 | 160 | 160 | 0.000 | 0.030 m | PO.03.30186 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798484552 | Objekt | 152041251253xxxxxxx | 0.023 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 30.000|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/160.0000/160.0000/2/30.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN160 | 160 | 160 | 0.000 | 0.030 m | PO.03.30187 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798484554 | Objekt | 152041251253xxxxxxx | 0.023 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 30.000|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
15204125125271xxxxxx0 | Půdorys 1.NP | m | 0.271 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/270.5000/125.0000/125.0000/2/270.5000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/270.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 271 | DN125 | 125 | 125 | 0.000 | 0.271 m | PO.03.30188 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798484759 | Objekt | 15204125125271xxxxxx0 | 0.174 m2
15205160160219xxxxxx0 | Půdorys 1.NP | m | 0.219 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/219.2031/160.0000/160.0000/2/219.2031/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/219.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 219 | DN160 | 160 | 160 | 0.000 | 0.219 m | PO.03.30189 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798484846 | Objekt | 15205160160219xxxxxx0 | 0.165 m2
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/160.0000/160.0000/2/30.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN160 | 160 | 160 | 0.000 | 0.030 m | PO.03.30190 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798484918 | Objekt | 152041251253xxxxxxx | 0.023 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 30.000|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
15204125125271xxxxxx0 | Půdorys 1.NP | m | 0.271 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/270.5000/125.0000/125.0000/2/270.5000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/270.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 271 | DN125 | 125 | 125 | 0.000 | 0.271 m | PO.03.30191 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798484943 | Objekt | 15204125125271xxxxxx0 | 0.174 m2
101043152x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/315.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 315x200 | 315 | 200 | 0.000 | 1.550 m2 | PO.03.30192 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798485048 | Objekt | 101043152x15xxxxxxx0 | 2.030 m2 | NEMSOK - K_POSITION: L.15; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.315 m; Výška: 0.2 m
101043152x1111xxxxxx0 | Půdorys 1.NP | m2 | 1.111 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/200.0000/1/1111.0000/0/0/0/0/0/1.0000/315.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/200.00/1111.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1111 | 315x200 | 315 | 200 | 0.000 | 1.140 m2 | PO.03.30193 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798485063 | Objekt | 101043152x1111xxxxxx0 | 1.500 m2 | NEMSOK - K_POSITION: L.16; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.315 m; Výška: 0.2 m
101043552x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/355.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/355.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/355.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 355x200 | 355 | 200 | 0.000 | 1.660 m2 | PO.03.30194 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798485098 | Objekt | 101043552x15xxxxxxx0 | 2.150 m2 | NEMSOK - K_POSITION: L.18; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.355 m; Výška: 0.2 m
101043552x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/355.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/355.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/355.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 355x200 | 355 | 200 | 0.000 | 1.660 m2 | PO.03.30195 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798485113 | Objekt | 101043552x15xxxxxxx0 | 2.150 m2 | NEMSOK - K_POSITION: L.19; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.355 m; Výška: 0.2 m
101043552x195xxxxxx0 | Půdorys 1.NP | m2 | 0.195 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/355.0000/200.0000/1/195.0000/0/0/0/0/0/1.0000/355.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/355.00/200.00/195.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 195 | 355x200 | 355 | 200 | 0.000 | 1.000 m2 | PO.03.30196 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798485128 | Objekt | 101043552x195xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.20; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.355 m; Výška: 0.2 m
101043552x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/355.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/355.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/355.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 355x200 | 355 | 200 | 0.000 | 1.660 m2 | PO.03.30197 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798485163 | Objekt | 101043552x15xxxxxxx0 | 2.150 m2 | NEMSOK - K_POSITION: L.22; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.355 m; Výška: 0.2 m
101043552x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/355.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/355.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/355.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 355x200 | 355 | 200 | 0.000 | 1.660 m2 | PO.03.30198 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798485178 | Objekt | 101043552x15xxxxxxx0 | 2.150 m2 | NEMSOK - K_POSITION: L.23; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.355 m; Výška: 0.2 m
101043552x17xxxxxxx | Půdorys 1.NP | m2 | 0.17 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/355.0000/200.0000/1/170.0000/0/0/0/0/0/1.0000/355.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/355.00/200.00/170.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 170 | 355x200 | 355 | 200 | 0.000 | 1.000 m2 | PO.03.30199 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798485193 | Objekt | 101043552x17xxxxxxx | 1.000 m2 | NEMSOK - K_POSITION: L.24; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.355 m; Výška: 0.2 m
15204125125221xxxxxx0 | Půdorys 1.NP | m | 0.221 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/220.5000/125.0000/125.0000/2/220.5000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/220.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 221 | DN125 | 125 | 125 | 0.000 | 0.221 m | PO.03.30200 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798485238 | Objekt | 15204125125221xxxxxx0 | 0.142 m2
15204160160364xxxxxx0 | Půdorys 1.NP | m | 0.364 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/364.4000/160.0000/160.0000/2/364.4000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/364.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 364 | DN160 | 160 | 160 | 0.000 | 0.364 m | PO.03.30201 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798485248 | Objekt | 15204160160364xxxxxx0 | 0.275 m2
15204160160199xxxxxx0 | Půdorys 1.NP | m | 0.199 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/198.7000/160.0000/160.0000/2/198.7000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/198.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 199 | DN160 | 160 | 160 | 0.000 | 0.199 m | PO.03.30202 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798485273 | Objekt | 15204160160199xxxxxx0 | 0.150 m2
15204160160199xxxxxx0 | Půdorys 1.NP | m | 0.199 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/198.7000/160.0000/160.0000/2/198.7000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/198.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 199 | DN160 | 160 | 160 | 0.000 | 0.199 m | PO.03.30203 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798485278 | Objekt | 15204160160199xxxxxx0 | 0.150 m2
15205125125207xxxxxx0 | Půdorys 1.NP | m | 0.207 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/206.6134/125.0000/125.0000/2/206.6134/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/206.61/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 207 | DN125 | 125 | 125 | 0.000 | 0.207 m | PO.03.30204 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798485284 | Objekt | 15205125125207xxxxxx0 | 0.133 m2
 | Půdorys 1.NP | m | 1.516 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1516.1000/160.0000/160.0000/2/1516.1000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/1516.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1516 | DN160 | 160 | 160 | 0.000 | 1.516 m | PO.03.30205 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798485362 | Objekt |  | 1.143 m2
15204160160229xxxxxx0 | Půdorys 1.NP | m | 0.229 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/229.2031/160.0000/160.0000/2/229.2031/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/229.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 229 | DN160 | 160 | 160 | 0.000 | 0.229 m | PO.03.30206 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798485400 | Objekt | 15204160160229xxxxxx0 | 0.173 m2
15204160160313xxxxxx0 | Půdorys 1.NP | m | 0.313 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/312.9290/160.0000/160.0000/2/312.9290/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/312.93/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 313 | DN160 | 160 | 160 | 0.000 | 0.313 m | PO.03.30207 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798485420 | Objekt | 15204160160313xxxxxx0 | 0.236 m2
 | Půdorys 1.NP | m | 4.796 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/4796.3000/160.0000/160.0000/2/4796.3000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/4796.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 4796 | DN160 | 160 | 160 | 0.000 | 4.796 m | PO.03.30208 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798485435 | Objekt |  | 3.616 m2
 | Půdorys 1.NP | m | 1.449 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1448.9000/160.0000/160.0000/2/1448.9000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/1448.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1449 | DN160 | 160 | 160 | 0.000 | 1.449 m | PO.03.30209 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798485440 | Objekt |  | 1.092 m2
101043152x549xxxxxx0 | Půdorys 1.NP | m2 | 0.549 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/200.0000/1/549.0000/0/0/0/0/0/1.0000/315.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/200.00/549.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 549 | 315x200 | 315 | 200 | 0.000 | 1.000 m2 | PO.03.30210 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798485500 | Objekt | 101043152x549xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.5; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.315 m; Výška: 0.2 m
101043152x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/315.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 315x200 | 315 | 200 | 0.000 | 1.550 m2 | PO.03.30211 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798485535 | Objekt | 101043152x15xxxxxxx0 | 2.030 m2 | NEMSOK - K_POSITION: L.7; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.315 m; Výška: 0.2 m
101043152x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/315.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 315x200 | 315 | 200 | 0.000 | 1.550 m2 | PO.03.30212 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798485550 | Objekt | 101043152x15xxxxxxx0 | 2.030 m2 | NEMSOK - K_POSITION: L.8; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.315 m; Výška: 0.2 m
101043152x172xxxxxx0 | Půdorys 1.NP | m2 | 0.172 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/200.0000/1/172.0000/0/0/0/0/0/1.0000/315.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/200.00/172.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 172 | 315x200 | 315 | 200 | 0.000 | 1.000 m2 | PO.03.30213 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798485565 | Objekt | 101043152x172xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.9; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.315 m; Výška: 0.2 m
101042802x1443xxxxxx0 | Půdorys 1.NP | m2 | 1.443 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/280.0000/200.0000/1/1442.9000/0/0/0/0/0/1.0000/280.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/200.00/1442.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1443 | 280x200 | 280 | 200 | 0.000 | 1.390 m2 | PO.03.30214 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798485600 | Objekt | 101042802x1443xxxxxx0 | 1.850 m2 | NEMSOK - K_POSITION: L.11; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.28 m; Výška: 0.2 m
101043152x1042xxxxxx0 | Půdorys 1.NP | m2 | 1.042 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/200.0000/1/1042.2000/0/0/0/0/0/1.0000/315.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/200.00/1042.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1042 | 315x200 | 315 | 200 | 0.000 | 1.070 m2 | PO.03.30215 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798485664 | Objekt | 101043152x1042xxxxxx0 | 1.410 m2 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.315 m; Výška: 0.2 m; K_EBT_BOX_WC: 1392.200|177.500|120.000|0.000|-177.500|-120.000|0.000|0.000|0.000|1.000
10104560355112xxxxxx0 | Půdorys 1.NP | m2 | 0.112 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/355.0000/1/112.2000/0/0/0/0/0/1.0000/560.0000/355.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/355.00/112.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 112 | 560x355 | 560 | 355 | 0.000 | 1.000 m2 | PO.03.30216 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798485668 | Objekt | 10104560355112xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355; Šířka: 0.56 m; Výška: 0.355 m; K_EBT_BOX_WC: 462.200|300.000|197.500|0.000|-300.000|-197.500|0.000|0.000|0.000|1.000
101046302x115xxxxxxx | Půdorys 1.NP | m2 | 1.15 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/630.0000/200.0000/1/1150.0000/0/0/0/0/0/1.0000/630.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/630.00/200.00/1150.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1150 | 630x200 | 630 | 200 | 0.000 | 1.910 m2 | PO.03.30217 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798485670 | Objekt | 101046302x115xxxxxxx | 2.280 m2 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.63 m; Výška: 0.2 m; K_EBT_BOX_WC: 1500.000|335.000|120.000|0.000|-335.000|-120.000|0.000|0.000|0.000|1.000
152051251252xxxxxxx0 | Půdorys 1.NP | m | 0.2 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/200.0000/125.0000/125.0000/2/200.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/200.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200 | DN125 | 125 | 125 | 0.000 | 0.200 m | PO.03.30218 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798485838 | Objekt | 152051251252xxxxxxx0 | 0.129 m2
152041x1x504xxxxxx0 | Půdorys 1.NP | m | 0.504 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/504.3000/100.0000/100.0000/2/504.3000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/504.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 504 | DN100 | 100 | 100 | 0.000 | 0.504 m | PO.03.30219 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798485865 | Objekt | 152041x1x504xxxxxx0 | 0.285 m2
