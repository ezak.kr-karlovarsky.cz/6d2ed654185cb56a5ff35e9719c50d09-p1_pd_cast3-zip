Properties of the parts of a building model (IFC2X3), part 12 of 51

# IfcFlowFitting (2887)
Name | In | Jednotka | Délka (m) | Označení | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_DIM | L_BES_DIM_A2 | L_BES_DIM_B2 | L_BES_DIM_A | K_VOLSTROM | K_MLH_GOST = K_MLD_GOST | K_LISTVALUE | Kód prvku | Třída reakce na oheň | Allright_Stavebni_dil_ID | Název_objektu | K_EBT_BOX_WC | Plocha | L_BES_LAENGE | K_INTERNAL_ISO | Tloušťka (m) | Součinitel tepelné vodivost
252x1250125115xxxxx0 | Půdorys 1.PP | Kus | 0.092 | 252x1250125115xxxxx0 | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/125.0000/125.0000/2/92.0000/-0.0497/-0.0027/0/0/0/125.0000/125.0000/125.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/0/0/125.00/125.00/0/92.00/0.05/-0.05/-0.00/0.00/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30245 | A1 | 6774Obj0000045317 | Objekt | 92.000/62.500/62.500/0.000/-62.550/-62.503/0.000/0.000/0.000/1.000 | 1 | 92 | __ISO | 0.04 | 0,041 W/m.K
30204125125x1251250920-0-x3xx | Půdorys 1.PP | Kus | 0.11 | 30204125125x1251250920-0-x3xx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/110.0538/125.0000/125.0000/2/110.0538/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/110.05/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.110 m | IT.02.30246 | A1 | 6774Obj0000045320 | Objekt | 110.054/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.11 | 110 | __ISO | 0.04 | 0,041 W/m.K
1520412512511xxxxxxx | Půdorys 1.PP | Kus | 0 | 1520412512511xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/317.4/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/317.4/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/317.40/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30247 | A1 | 6774Obj0000045323 | Objekt | 48.529/64.630/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125115xxxxx0 | Půdorys 1.PP | Kus | 0.106 | 252x1250125115xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/105.7952/125.0000/125.0000/2/105.7952/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/105.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.106 m | IT.02.30248 | A1 | 6774Obj0000045326 | Objekt | 105.795/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.106 | 106 | __ISO | 0.04 | 0,041 W/m.K
15204125125106xxxxxx0 | Půdorys 1.PP | Kus | 0.025 | 15204125125106xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/24.8463/125.0000/125.0000/2/24.8463/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/24.85/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.025 m | IT.02.30249 | A1 | 6774Obj0000045329 | Objekt | 24.846/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.025 | 25 | __ISO | 0.04 | 0,041 W/m.K
1520612512525xxxxxx0 | Půdorys 1.PP | Kus | 0 | 1520612512525xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/349.7/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/349.7/125.0000/125.0000/125.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/349.70/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30250 | A1 | 6774Obj0000045332 | Objekt | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012519xxxxxx | Půdorys 1.PP | Kus | 0.03 | 252x125012519xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.4854/125.0000/125.0000/2/30.4854/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.49/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.030 m | IT.02.30251 | A1 | 6774Obj0000045335 | Objekt | 30.485/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K
152061251253xxxxxxx | Půdorys 1.PP | Kus | 0 | 152061251253xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30252 | A1 | 6774Obj0000045338 | Objekt | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012519xxxxxx | Půdorys 1.PP | Kus | 0.025 | 252x125012519xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/24.8463/125.0000/125.0000/2/24.8463/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/24.85/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.025 m | IT.02.30253 | A1 | 6774Obj0000045341 | Objekt | 24.846/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.025 | 25 | __ISO | 0.04 | 0,041 W/m.K
1520612512525xxxxxx0 | Půdorys 1.PP | Kus | 0.061 | 1520612512525xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/61.3830/125.0000/125.0000/2/61.3830/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/61.38/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.061 m | IT.02.30254 | A1 | 6774Obj0000045344 | Objekt | 61.383/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.061 | 61 | __ISO | 0.04 | 0,041 W/m.K
1520512512561xxxxxx0 | Půdorys 1.PP | Kus | 0 | 1520512512561xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/327.3/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/327.3/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/327.30/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30255 | A1 | 6774Obj0000045347 | Objekt | 48.529/64.630/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125115xxxxx0 | Půdorys 1.PP | Kus | 0.274 | 252x1250125115xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/274.3875/125.0000/125.0000/2/274.3875/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/274.39/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.274 m | IT.02.30256 | A1 | 6774Obj0000045350 | Objekt | 274.388/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.274 | 274 | __ISO | 0.04 | 0,041 W/m.K
15205125125274xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15205125125274xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/148.2/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/148.2/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/148.20/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30257 | A1 | 6774Obj0000045353 | Objekt | 48.529/64.630/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125115xxxxx0 | Půdorys 1.PP | Kus | 0.061 | 252x1250125115xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/61.3706/125.0000/125.0000/2/61.3706/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/61.37/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.061 m | IT.02.30258 | A1 | 6774Obj0000045356 | Objekt | 61.371/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.061 | 61 | __ISO | 0.04 | 0,041 W/m.K
1520512512561xxxxxx0 | Půdorys 1.PP | Kus | 0 | 1520512512561xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/9.2/125.0000/125.0000/125.0000/2/82.8275/31.3805/0/41.5/0/9.2/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/9.20/0/125.00/1.00/41.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30259 | A1 | 6774Obj0000045359 | Objekt | 124.241/78.190/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125142xxxxx0 | Půdorys 1.PP | Kus | 0.092 | 252x1250125142xxxxx0 | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/125.0000/125.0000/2/92.0000/0.2771/-0.1652/0/0/0/125.0000/125.0000/125.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/0/0/125.00/125.00/0/92.00/-0.28/0.28/-0.17/0.17/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30260 | A1 | 6774Obj0000045362 | Objekt | 92.000/62.777/62.500/0.000/-62.500/-62.665/0.000/0.000/0.000/1.000 | 1 | 92 | __ISO | 0.04 | 0,041 W/m.K
30204125125x125125092-x-x3xx | Půdorys 1.PP | Kus | 0.221 | 30204125125x125125092-x-x3xx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/220.7225/125.0000/125.0000/2/220.7225/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/220.72/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.221 m | IT.02.30261 | A1 | 6774Obj0000045365 | Objekt | 220.723/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.221 | 221 | __ISO | 0.04 | 0,041 W/m.K
15204125125221xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15204125125221xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/186.9/125.0000/125.0000/125.0000/2/82.8275/31.3805/0/41.5/0/186.9/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/186.90/0/125.00/1.00/41.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30262 | A1 | 6774Obj0000045368 | Objekt | 124.241/78.190/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125142xxxxx0 | Půdorys 1.PP | Kus | 0 | 252x1250125142xxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30263 | A1 | 6774Obj0000045371 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125145xxxxx0 | Půdorys 1.PP | Kus | 1.3 | 252x1250125145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1300.0000/125.0000/125.0000/2/1300.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/1300.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.300 m | IT.02.30264 | A1 | 6774Obj0000045374 | Objekt | 1300.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1.3 | 1300 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.837 m2
1520412512513xxxxxxx0 | Půdorys 1.PP | Kus | 1.145 | 1520412512513xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1144.9923/125.0000/125.0000/2/1144.9923/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/1144.99/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.145 m | IT.02.30265 | A1 | 6774Obj0000045377 | Objekt | 1144.992/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1.145 | 1145 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.737 m2
 | Půdorys 1.PP | Kus | 0.288 |  | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/287.7314/125.0000/125.0000/2/287.7314/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/287.73/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.288 m | IT.02.30266 | A1 | 6774Obj0000045380 | Objekt | 287.731/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.288 | 288 | __ISO | 0.04 | 0,041 W/m.K
15204125125288xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15204125125288xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/181.4/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/181.4/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/181.40/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30267 | A1 | 6774Obj0000045383 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125145xxxxx0 | Půdorys 1.PP | Kus | 0.305 | 252x1250125145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/304.8011/125.0000/125.0000/2/304.8011/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/304.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.305 m | IT.02.30268 | A1 | 6774Obj0000045386 | Objekt | 304.801/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.305 | 305 | __ISO | 0.04 | 0,041 W/m.K
15204125125305xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15204125125305xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/1.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/1.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/1.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30269 | A1 | 6774Obj0000045389 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125145xxxxx0 | Půdorys 1.PP | Kus | 0.288 | 252x1250125145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/287.7665/125.0000/125.0000/2/287.7665/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/287.77/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.288 m | IT.02.30270 | A1 | 6774Obj0000045392 | Objekt | 287.767/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.288 | 288 | __ISO | 0.04 | 0,041 W/m.K
15204125125288xxxxxx0 | Půdorys 1.PP | Kus | 0.5 | 15204125125288xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/500.0000/125.0000/125.0000/2/500.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.500 m | IT.02.30271 | A1 | 6774Obj0000045395 | Objekt | 500.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.5 | 500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
152041251255xxxxxxx0 | Půdorys 1.PP | Kus | 0.012 | 152041251255xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/11.5050/125.0000/125.0000/2/11.5050/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/11.51/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.011 m | IT.02.30272 | A1 | 6774Obj0000045398 | Objekt | 11.505/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.011 | 12 | __ISO | 0.04 | 0,041 W/m.K
1520412512512xxxxxx0 | Půdorys 1.PP | Kus | 0 | 1520412512512xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/195.4/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/195.4/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/195.40/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30273 | A1 | 6774Obj0000045401 | Objekt | 93.750/70.873/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012513xxxxxx | Půdorys 1.PP | Kus | 0.121 | 252x125012513xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/120.8065/125.0000/125.0000/2/120.8065/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/120.81/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.121 m | IT.02.30274 | A1 | 6774Obj0000045404 | Objekt | 120.807/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.121 | 121 | __ISO | 0.04 | 0,041 W/m.K
15204125125121xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15204125125121xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/13.4/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/13.4/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/13.40/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30275 | A1 | 6774Obj0000045407 | Objekt | 93.750/70.873/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012513xxxxxx | Půdorys 1.PP | Kus | 1.145 | 252x125012513xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1145.0192/125.0000/125.0000/2/1145.0192/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/1145.02/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.145 m | IT.02.30276 | A1 | 6774Obj0000045410 | Objekt | 1145.019/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1.145 | 1145 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.737 m2
 | Půdorys 1.PP | Kus | 0.061 |  | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/60.6258/125.0000/125.0000/2/60.6258/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/60.63/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.061 m | IT.02.30277 | A1 | 6774Obj0000045413 | Objekt | 60.626/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.061 | 61 | __ISO | 0.04 | 0,041 W/m.K
1520412512561xxxxxx0 | Půdorys 1.PP | Kus | 0 | 1520412512561xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30278 | A1 | 6774Obj0000045416 | Objekt | 93.750/70.873/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012513xxxxxx | Půdorys 1.PP | Kus | 0.084 | 252x125012513xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/84.0128/125.0000/125.0000/2/84.0128/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/84.01/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.084 m | IT.02.30279 | A1 | 6774Obj0000045419 | Objekt | 84.013/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.084 | 84 | __ISO | 0.04 | 0,041 W/m.K
1520412512584xxxxxx0 | Půdorys 1.PP | Kus | 0.03 | 1520412512584xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.030 m | IT.02.30280 | A1 | 6774Obj0000045422 | Objekt | 30.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.03 | 30 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.019 m2
152041251253xxxxxxx | Půdorys 1.PP | Kus | 0 | 152041251253xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30281 | A1 | 6774Obj0000045425 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125145xxxxx0 | Půdorys 1.PP | Kus | 0.035 | 252x1250125145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/35.3461/125.0000/125.0000/2/35.3461/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/35.35/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.035 m | IT.02.30282 | A1 | 6774Obj0000045428 | Objekt | 35.346/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.035 | 35 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.023 m2
1520412512535xxxxxx0 | Půdorys 1.PP | Kus | 0.061 | 1520412512535xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/60.6116/125.0000/125.0000/2/60.6116/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/60.61/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.061 m | IT.02.30283 | A1 | 6774Obj0000045431 | Objekt | 60.612/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.061 | 61 | __ISO | 0.04 | 0,041 W/m.K
1520412512561xxxxxx0 | Půdorys 1.PP | Kus | 0 | 1520412512561xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30284 | A1 | 6774Obj0000045434 | Objekt | 93.750/70.873/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012513xxxxxx | Půdorys 1.PP | Kus | 0.26 | 252x125012513xxxxxx | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/260.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/130.0000/130.0000/0/90.0/0/0/160.0000/160.0000/160.0000/2/ | 75/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/160.00/0/0/260.00/0/130.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | IT.02.30285 | A1 | 6774Obj0000045438 | Objekt | 260.000/130.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 260 | __ISO | 0.04 | 0,041 W/m.K
7520516016016x26x13x9xxxx | Půdorys 1.PP | Kus | 0.19 | 7520516016016x26x13x9xxxx | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/190.0000/0/0/0/0/0/125.0000/160.0000/160.0000/2/95.0000/125.0000/0/90.0/0/0/100.0000/100.0000/100.0000/2/ | 75/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/100.00/0/0/190.00/0/125.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | IT.02.30286 | A1 | 6774Obj0000045442 | Objekt | 190.000/125.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 190 | __ISO | 0.04 | 0,041 W/m.K
752051601601x019x12509xxxx | Půdorys 1.PP | Kus | 0.078 | 752051601601x019x12509xxxx | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/78.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 30/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/0/0/160.00/125.00/0/78.00/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 125 | 125 | 160 | 120.000 | 0 | 1.0 | IT.02.30287 | A1 | 6774Obj0000045445 | Objekt | 78.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 78 | __ISO | 0.04 | 0,041 W/m.K
30205160125x160125078-18-18-18-1 | Půdorys 1.PP | Kus | 0.456 | 30205160125x160125078-18-18-18-1 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/455.6968/125.0000/125.0000/2/455.6968/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/455.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 0.456 m | IT.02.30288 | A1 | 6774Obj0000045448 | Objekt | 455.697/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.456 | 456 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.293 m2
15205125125456xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15205125125456xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/100.0000/100.0000/2/70.7107/29.2893/0/45.0/0/0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/0/0/100.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 1.0 | IT.02.30289 | A1 | 6774Obj0000045451 | Objekt | 106.066/64.645/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1x01x145xxxxx0 | Půdorys 1.PP | Kus | 0.215 | 252x1x01x145xxxxx0 | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/215.0000/0/0/0/0/180.0/1.0000/160.0000/160.0000/2/107.5000/125.0000/0/90.0/0/180.0/125.0000/125.0000/125.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/125.00/0/180.00/215.00/0/125.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | IT.02.30290 | A1 | 6774Obj0000045455 | Objekt | 215.000/125.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 215 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2
752041601601250215012509xxxx | Půdorys 1.PP | Kus | 0.06 | 752041601601250215012509xxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/60.1801/125.0000/125.0000/2/60.1801/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/60.18/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 0.060 m | IT.02.30291 | A1 | 6774Obj0000045458 | Objekt | 60.180/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.06 | 60 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.039 m2
152041251256xxxxxxx | Půdorys 1.PP | Kus | 0.215 | 152041251256xxxxxxx | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/215.0000/0/0/0/0/0/1.0000/160.0000/160.0000/2/107.5000/125.0000/0/90.0/0/0/125.0000/125.0000/125.0000/2/ | 75/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/125.00/0/0/215.00/0/125.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | IT.02.30292 | A1 | 6774Obj0000045462 | Objekt | 215.000/125.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 215 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
752051601601250215012509xxxx | Půdorys 1.PP | Kus | 0.111 | 752051601601250215012509xxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/110.6849/125.0000/125.0000/2/110.6849/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/110.68/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 0.111 m | IT.02.30293 | A1 | 6774Obj0000045465 | Objekt | 110.685/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.111 | 111 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.071 m2
15204125125111xxxxxx0 | Půdorys 1.PP | Kus | 0.215 | 15204125125111xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/215.0000/160.0000/160.0000/2/215.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/215.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 0.215 m | IT.02.30294 | A1 | 6774Obj0000045468 | Objekt | 215.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.215 | 215 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.162 m2
15205160160215xxxxxx0 | Půdorys 1.PP | Kus | 0.738 | 15205160160215xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/738.4000/160.0000/160.0000/2/738.4000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/738.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 0.738 m | IT.02.30295 | A1 | 6774Obj0000045471 | Objekt | 738.400/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.738 | 738 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.557 m2
15205160160738xxxxxx0 | Půdorys 1.PP | Kus | 0.189 | 15205160160738xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/188.5000/160.0000/160.0000/2/188.5000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/188.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 0.189 m | IT.02.30296 | A1 | 6774Obj0000045474 | Objekt | 188.500/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.189 | 189 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.142 m2
15204160160189xxxxxx0 | Půdorys 1.PP | Kus | 0.62 | 15204160160189xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/620.0000/160.0000/160.0000/2/620.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/620.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 0.620 m | IT.02.30297 | A1 | 6774Obj0000045477 | Objekt | 620.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.62 | 620 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.467 m2
1520516016062xxxxxxx | Půdorys 1.PP | Kus | 0.3 | 1520516016062xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/300.0000/160.0000/160.0000/2/300.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/300.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 0.300 m | IT.02.30298 | A1 | 6774Obj0000045480 | Objekt | 300.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.3 | 300 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.226 m2
152041601603xxxxxxx0 | Půdorys 1.PP | Kus | 0.232 | 152041601603xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/232.3660/160.0000/160.0000/2/232.3660/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/232.37/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 0.232 m | IT.02.30299 | A1 | 6774Obj0000045483 | Objekt | 232.366/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.232 | 232 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.175 m2
15204160160232xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15204160160232xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/0/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | IT.02.30300 | A1 | 6774Obj0000045486 | Objekt | 120.000/90.718/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16013xxxxxx | Půdorys 1.PP | Kus | 0.075 | 252x16x16013xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/74.5349/160.0000/160.0000/2/74.5349/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/74.53/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 0.074 m | IT.02.30301 | A1 | 6774Obj0000045489 | Objekt | 74.535/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.074 | 75 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.056 m2
1520416016075xxxxxx0 | Půdorys 1.PP | Kus | 0 | 1520416016075xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/180.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/180.00/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | IT.02.30302 | A1 | 6774Obj0000045492 | Objekt | 120.000/90.718/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16013xxxxxx | Půdorys 1.PP | Kus | 0.258 | 252x16x16013xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/258.4078/160.0000/160.0000/2/258.4078/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/258.41/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 0.258 m | IT.02.30303 | A1 | 6774Obj0000045495 | Objekt | 258.408/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.258 | 258 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.195 m2
15204160160258xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15204160160258xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/103.9117/38.3350/0/40.5/0/0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/0/0/160.00/1.00/40.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | IT.02.30304 | A1 | 6774Obj0000045498 | Objekt | 155.868/99.168/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x160141xxxxx0 | Půdorys 1.PP | Kus | 0.257 | 252x16x160141xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/257.4039/160.0000/160.0000/2/257.4039/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/257.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 0.257 m | IT.02.30305 | A1 | 6774Obj0000045501 | Objekt | 257.404/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.257 | 257 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.194 m2
15204160160257xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15204160160257xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/121.6650/56.0883/0/49.5/0/0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/0/0/160.00/1.00/49.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | IT.02.30306 | A1 | 6774Obj0000045504 | Objekt | 182.497/108.044/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16015xxxxxx | Půdorys 1.PP | Kus | 0.244 | 252x16x16015xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/243.5264/160.0000/160.0000/2/243.5264/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/243.53/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 0.243 m | IT.02.30307 | A1 | 6774Obj0000045507 | Objekt | 243.526/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.243 | 244 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.184 m2
15204160160244xxxxxx0 | Půdorys 1.PP | Kus | 0.232 | 15204160160244xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/232.4000/160.0000/160.0000/2/232.4000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/232.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 0.232 m | IT.02.30308 | A1 | 6774Obj0000045510 | Objekt | 232.400/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.232 | 232 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.175 m2
15206160160232xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15206160160232xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/90.0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/0/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 |  | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 100 | 100 | 100 | 120.000 |  | 1.0 | IT.02.30309 | A1 | 6774Obj0000045513 | Objekt | 150.000/100.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; L_BES_DIM_B: 100
252x1x01x19xxxxxx | Půdorys 1.PP | Kus | 0 | 252x1x01x19xxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 |  | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 125 | 125 | 125 | 120.000 |  | 1.0 | IT.02.30310 | A1 | 6774Obj0000045516 | Objekt | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; L_BES_DIM_B: 125
252x125012519xxxxxx | Půdorys 1.PP | Kus | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 |  | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 125 | 125 | 125 | 120.000 |  | 1.0 | IT.02.30311 | A1 | 6774Obj0000045519 | Objekt | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; L_BES_DIM_B: 125
252x125012519xxxxxx | Půdorys 1.PP | Kus | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 |  | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 125 | 125 | 125 | 120.000 |  | 1.0 | IT.02.30312 | A1 | 6774Obj0000045522 | Objekt | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; L_BES_DIM_B: 125
252x125012519xxxxxx | Půdorys 1.PP | Kus | 0.023 | 252x125012519xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/23.2640/125.0000/125.0000/2/23.2640/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/23.26/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 0.023 m | IT.02.30313 | A1 | 6774Obj0000045525 | Objekt | 23.264/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.023 | 23 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.015 m2
1520412512523xxxxxx0 | Půdorys 1.PP | Kus | 0 | 1520412512523xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/143.4/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/143.4/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/143.40/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | IT.02.30314 | A1 | 6774Obj0000045528 | Objekt | 93.750/70.873/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012513xxxxxx | Půdorys 1.PP | Kus | 0.092 | 252x125012513xxxxxx | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/125.0000/125.0000/2/92.0000/-0.0093/-0.0336/0/0/0/125.0000/125.0000/125.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/0/0/125.00/125.00/0/92.00/0.01/-0.01/-0.03/0.03/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | IT.02.30315 | A1 | 6774Obj0000045531 | Objekt | 92.000/62.500/62.500/0.000/-62.509/-62.534/0.000/0.000/0.000/1.000 | 1 | 92 | __ISO | 0.04 | 0,041 W/m.K
30204125125x1251250920-0-x3xx | Půdorys 1.PP | Kus | 0.012 | 30204125125x1251250920-0-x3xx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/11.7645/125.0000/125.0000/2/11.7645/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/11.76/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 0.012 m | IT.02.30316 | A1 | 6774Obj0000045534 | Objekt | 11.764/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.012 | 12 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.008 m2
1520412512512xxxxxx0 | Půdorys 1.PP | Kus | 0 | 1520412512512xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/327.3/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/327.3/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/327.30/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | IT.02.30317 | A1 | 6774Obj0000045537 | Objekt | 93.750/70.873/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012513xxxxxx | Půdorys 1.PP | Kus | 0.023 | 252x125012513xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/23.2640/125.0000/125.0000/2/23.2640/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/23.26/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 0.023 m | IT.02.30318 | A1 | 6774Obj0000045540 | Objekt | 23.264/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.023 | 23 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.015 m2
1520412512523xxxxxx0 | Půdorys 1.PP | Kus | 0.141 | 1520412512523xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/141.2629/100.0000/100.0000/2/141.2629/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/141.26/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 0.141 m | IT.02.30319 | A1 | 6774Obj0000045543 | Objekt | 141.263/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.141 | 141 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.080 m2
152041x1x141xxxxxx0 | Půdorys 1.PP | Kus | 0 | 152041x1x141xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/158.1/100.0000/100.0000/100.0000/2/70.7107/29.2893/0/45.0/0/158.1/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/158.10/0/100.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 1.0 | IT.02.30320 | A1 | 6774Obj0000045546 | Objekt | 106.066/64.645/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1x01x145xxxxx0 | Půdorys 1.PP | Kus | 0.204 | 252x1x01x145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/204.4809/100.0000/100.0000/2/204.4809/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/204.48/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 0.205 m | IT.02.30321 | A1 | 6774Obj0000045549 | Objekt | 204.481/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.205 | 204 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.116 m2
152041x1x204xxxxxx0 | Půdorys 1.PP | Kus | 0 | 152041x1x204xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/344.1/100.0000/100.0000/100.0000/2/70.7107/29.2893/0/45.0/0/344.1/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/344.10/0/100.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 1.0 | IT.02.30322 | A1 | 6774Obj0000045552 | Objekt | 106.066/64.645/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1x01x145xxxxx0 | Půdorys 1.PP | Kus | 0.141 | 252x1x01x145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/141.2827/100.0000/100.0000/2/141.2827/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/141.28/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 0.141 m | IT.02.30323 | A1 | 6774Obj0000045555 | Objekt | 141.283/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.141 | 141 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.080 m2
152041x1x141xxxxxx0 | Půdorys 1.PP | Kus | 0.048 | 152041x1x141xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/47.8590/125.0000/125.0000/2/47.8590/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/47.86/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 0.048 m | IT.02.30324 | A1 | 6774Obj0000045558 | Objekt | 47.859/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.048 | 48 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.031 m2
1520412512548xxxxxx0 | Půdorys 1.PP | Kus | 0 | 1520412512548xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/345.3/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/345.3/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/345.30/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | IT.02.30325 | A1 | 6774Obj0000045561 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125145xxxxx0 | Půdorys 1.PP | Kus | 0.181 | 252x1250125145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/180.5399/125.0000/125.0000/2/180.5399/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/180.54/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 0.180 m | IT.02.30326 | A1 | 6774Obj0000045564 | Objekt | 180.540/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.18 | 181 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.116 m2
15204125125181xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15204125125181xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/169.5/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/169.5/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/169.50/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | IT.02.30327 | A1 | 6774Obj0000045567 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125145xxxxx0 | Půdorys 1.PP | Kus | 0.048 | 252x1250125145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/47.8809/125.0000/125.0000/2/47.8809/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/47.88/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 0.048 m | IT.02.30328 | A1 | 6774Obj0000045570 | Objekt | 47.881/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.048 | 48 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.031 m2
1520412512548xxxxxx0 | Půdorys 1.PP | Kus | 0 | 1520412512548xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | IT.02.30329 | A1 | 6774Obj0000045573 | Objekt | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012519xxxxxx | Půdorys 1.PP | Kus | 0.164 | 252x125012519xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/163.9094/125.0000/125.0000/2/163.9094/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/163.91/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 0.164 m | IT.02.30330 | A1 | 6774Obj0000045576 | Objekt | 163.909/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.164 | 164 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.106 m2
15204125125164xxxxxx0 | Půdorys 1.PP | Kus | 0 | 15204125125164xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/139.2/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/139.2/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/139.20/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | IT.02.30331 | A1 | 6774Obj0000045579 | Objekt | 93.750/70.873/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012513xxxxxx | Půdorys 1.PP | Kus | 0.092 | 252x125012513xxxxxx | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/125.0000/125.0000/2/92.0000/0.0564/0.0355/0/0/0/125.0000/125.0000/125.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/0/0/125.00/125.00/0/92.00/-0.06/0.06/0.04/-0.04/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | IT.02.30332 | A1 | 6774Obj0000045582 | Objekt | 92.000/62.556/62.535/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 | 92 | __ISO | 0.04 | 0,041 W/m.K
