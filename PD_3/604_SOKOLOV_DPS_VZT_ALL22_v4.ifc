Properties of the parts of a building model (IFC2X3), part 25 of 51

# IfcFlowFitting (2887)
Name | In | Jednotka | Délka (m) | Označení | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_DIM | L_BES_DIM_A2 | L_BES_DIM_B2 | L_BES_DIM_A | K_VOLSTROM | K_MLH_GOST = K_MLD_GOST | K_LISTVALUE | Kód prvku | Třída reakce na oheň | Allright_Stavebni_dil_ID | Název_objektu | K_EBT_BOX_WC | Plocha | L_BES_LAENGE | K_INTERNAL_ISO | Tloušťka (m) | Součinitel tepelné vodivost
752042x2x16x26x15x9xxxx | Půdorys 1.NP | Stk | 0.26 | 752042x2x16x26x15x9xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/315.0/200.0000/200.0000/200.0000/2/260.0000/0/0/0/0/315.0/1.0000/200.0000/200.0000/2/130.0000/150.0000/0/90.0/0/315.0/160.0000/160.0000/160.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/160.00/0/315.00/260.00/0/150.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30166 | A1 | 6782Obj0798483913 | Objekt | 260.000/150.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 |  | 260 | NEMSOK - K_POSITION: L.1; Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
752042x2x16x26x15x9xxxx | Půdorys 1.NP | Stk | 0.26 | 752042x2x16x26x15x9xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/225.0/200.0000/200.0000/200.0000/2/260.0000/0/0/0/0/225.0/200.0000/200.0000/200.0000/2/130.0000/150.0000/0/90.0/0/225.0/160.0000/160.0000/160.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/160.00/0/225.00/260.00/0/150.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30176 | A1 | 6782Obj0798485395 | Objekt |  |  | 260 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
252x2x02x145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x2x02x145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/200.0000/200.0000/200.0000/2/141.4214/58.5786/0/45.0/0/90.0/200.0000/200.0000/200.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/90.00/0/200.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30214 | A1 | 6782Obj0798487297 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
252x2x02x145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x2x02x145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/200.0000/200.0000/200.0000/2/141.4214/58.5786/0/45.0/0/270.0/200.0000/200.0000/200.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/270.00/0/200.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30215 | A1 | 6782Obj0798487307 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
252x2x02x19xxxxxx | Půdorys 1.NP | Stk | 0 | 252x2x02x19xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/200.0000/200.0000/200.0000/2/200.0000/200.0000/0/90.0/0/180.0/200.0000/200.0000/200.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/180.00/0/200.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30216 | A1 | 6782Obj0798487322 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
752052x2x16x26x15x9xxxx | Půdorys 1.NP | Stk | 0.26 | 752052x2x16x26x15x9xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/180.0/200.0000/200.0000/200.0000/2/260.0000/0/0/0/0/180.0/350.0000/200.0000/200.0000/2/130.0000/150.0000/0/90.0/0/180.0/160.0000/160.0000/160.0000/2/ | 75/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/160.00/0/180.00/260.00/0/150.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30217 | A1 | 6782Obj0798487366 | Objekt |  |  | 260 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
252x2x02x13xxxxxx | Půdorys 1.NP | Stk | 0 | 252x2x02x13xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/200.0000/200.0000/200.0000/2/100.0000/26.7949/0/30.0/0/270.0/200.0000/200.0000/200.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/270.00/0/200.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30243 | A1 | 6782Obj0798489177 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
252x2x02x13xxxxxx | Půdorys 1.NP | Stk | 0 | 252x2x02x13xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/200.0000/200.0000/200.0000/2/100.0000/26.7949/0/30.0/0/90.0/200.0000/200.0000/200.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/90.00/0/200.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30244 | A1 | 6782Obj0798489179 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
252x2x02x13xxxxxx | Půdorys 1.NP | Stk | 0 | 252x2x02x13xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/200.0000/200.0000/200.0000/2/100.0000/26.7949/0/30.0/0/270.0/200.0000/200.0000/200.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/270.00/0/200.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30257 | A1 | 6782Obj0798489620 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
252x2x02x13xxxxxx | Půdorys 1.NP | Stk | 0 | 252x2x02x13xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/200.0000/200.0000/200.0000/2/100.0000/26.7949/0/30.0/0/90.0/200.0000/200.0000/200.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/90.00/0/200.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30258 | A1 | 6782Obj0798489630 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
252x2x02x19xxxxxx | Půdorys 1.NP | Stk | 0 | 252x2x02x19xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/200.0000/200.0000/200.0000/2/200.0000/200.0000/0/90.0/0/0/200.0000/200.0000/200.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/0/0/200.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30265 | A1 | 6782Obj0798490242 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
252x2x02x145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x2x02x145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/200.0000/200.0000/200.0000/2/141.4214/58.5786/0/45.0/0/180.0/200.0000/200.0000/200.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/180.00/0/200.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30271 | A1 | 6782Obj0798490689 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
252x2x02x145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x2x02x145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/200.0000/200.0000/200.0000/2/141.4214/58.5786/0/45.0/0/0/200.0000/200.0000/200.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/0/0/200.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30272 | A1 | 6782Obj0798490699 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
752042x2x16x26x15x9xxxx | Půdorys 1.NP | Stk | 0.26 | 752042x2x16x26x15x9xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/45.0/200.0000/200.0000/200.0000/2/260.0000/0/0/0/0/45.0/1.0000/200.0000/200.0000/2/130.0000/150.0000/0/90.0/0/45.0/160.0000/160.0000/160.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/160.00/0/45.00/260.00/0/150.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30275 | A1 | 6782Obj0798490820 | Objekt | 260.000/150.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 |  | 260 | NEMSOK - K_POSITION: L.1; Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
252x2x02x145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x2x02x145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/12.7/200.0000/200.0000/200.0000/2/141.4214/58.5786/0/45.0/0/12.7/200.0000/200.0000/200.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/12.70/0/200.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30279 | A1 | 6782Obj0798491545 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
302042x2xx2x2x01120-0-x3xx | Půdorys 1.NP | Stk | 0.112 | 302042x2xx2x2x01120-0-x3xx | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/2/112.0000/-0.1021/-0.2295/0/0/0/200.0000/200.0000/200.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/0/0/200.00/200.00/0/112.00/0.10/-0.10/-0.23/0.23/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30280 | A1 | 6782Obj0798491550 | Objekt |  |  | 112 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
252x2x02x145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x2x02x145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/189.1/200.0000/200.0000/200.0000/2/141.4214/58.5786/0/45.0/0/189.1/200.0000/200.0000/200.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/189.10/0/200.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30281 | A1 | 6782Obj0798491560 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
252x2x02x145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x2x02x145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/200.0000/200.0000/200.0000/2/141.4214/58.5786/0/45.0/0/270.0/200.0000/200.0000/200.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/270.00/0/200.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30282 | A1 | 6782Obj0798493039 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
252x2x02x145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x2x02x145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/200.0000/200.0000/200.0000/2/141.4214/58.5786/0/45.0/0/90.0/200.0000/200.0000/200.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/90.00/0/200.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30283 | A1 | 6782Obj0798493049 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
502162x250351x2x2x2x1782525x3xx | Půdorys 1.NP | m2 | 0.178 | 502162x250351x2x2x2x1782525x3xx | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/200.0000/200.0000/200.0000/2/178.3000/0/0/0/0/0/0/250.0000/200.0000/1/ | 50/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/200.00/250.00/35.00/100.00/200.00/200.00/200.00/178.30/25.00/25.00/0/0/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 250 | 200 | 200 | 0.000 | 0 | 1.000 m2 | TA.03.30097 | A1 | 6782Obj0798479612 | Objekt |  |  | 178 | NEMSOK - K_POSITION: L.73; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: 250 mm
101052x1253xxxxxxx | Půdorys 1.NP | m2 | 0.03 | 101052x1253xxxxxxx | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/200.0000/125.0000/1/30.0000/0/0/0/0/0/1.0000/200.0000/125.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x125 | 200 | 125 | 200 | 0.000 | 0 | 1.000 m2 | PO.03.30233 | A1 | 6782Obj0798486573 | Objekt |  |  | 30 | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 125; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.2 m; Výška: 0.125 m; Teplonosná látka: -
502162505x701x250250250352125125 | Půdorys 1.NP | Kus | 0 | 502162505x701x250250250352125125 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/250.0000/250.0000/250.0000/2/250.0000/250.0000/0/90.0/0/180.0/250.0000/250.0000/250.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/180.00/0/250.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Mineralwolle/100.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | IT.03.30001 | B | 6784Obj0000007691 | Objekt | 375.000/250.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.1 | 0,041 W/m.K
1015205250250125xxxxxxx | Půdorys 1.NP | Kus | 0.635 | 1015205250250125xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/634.6871/250.0000/250.0000/2/634.6871/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/634.69/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Mineralwolle/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.635 m | IT.03.30002 | B | 6784Obj0000007711 | Objekt | 634.687/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 0.635 | 635 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.897 m2
15205250250635xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15205250250635xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/250.0000/250.0000/250.0000/2/250.0000/250.0000/0/90.0/0/0/250.0000/250.0000/250.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/0/0/250.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Mineralwolle/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | IT.03.30003 | B | 6784Obj0000007714 | Objekt | 375.000/250.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.1 | 0,041 W/m.K
252x25x25019xxxxxx | Půdorys 1.NP | Kus | 0.389 | 252x25x25019xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/388.5000/250.0000/250.0000/2/388.5000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/388.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Mineralwolle/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.389 m | IT.03.30004 | B | 6784Obj0000007717 | Objekt | 388.500/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 0.389 | 389 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.549 m2
15205250250389xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15205250250389xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/250.0000/250.0000/250.0000/2/250.0000/250.0000/0/90.0/0/0/250.0000/250.0000/250.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/0/0/250.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Mineralwolle/100.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | IT.03.30005 | B | 6784Obj0000007720 | Objekt | 375.000/250.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.1 | 0,041 W/m.K
macro | Půdorys 1.NP | Kus | 1 | macro | Schalldämpfer | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/250.00/250.00/1000.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/100.00 |  | DN250 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30006 | B | 6784Obj0000007734 | Objekt | 26506.127/-5778.240/3155.000/25515.101/-6494.747/2905.000/0.000/0.000/0.000/1.000 | 1 | 1000 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\schalldaempfer\; K_DP_EBT: 0.00; K_DATE: 2023/01/04; N_FREI_68: SPIRO POTRUBÍ
 | Půdorys 1.NP | Kus | 0.011 |  | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/11.3925/250.0000/250.0000/2/11.3925/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/11.39/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.011 m | IT.03.30007 | B | 6784Obj0000007737 | Objekt | 11.392/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 0.011 | 11 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.016 m2
1520425025011xxxxxx0 | Půdorys 1.NP | Kus | 0 | 1520425025011xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/250.0000/250.0000/250.0000/2/125.0000/33.4936/0/30.0/0/0/250.0000/250.0000/250.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/0/0/250.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | IT.03.30008 | B | 6784Obj0000007740 | Objekt | 187.500/141.747/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.1 | 0,041 W/m.K
252x25x25013xxxxxx | Půdorys 1.NP | Kus | 0 | 252x25x25013xxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/250.0000/250.0000/250.0000/2/125.0000/33.4936/0/30.0/0/180.0/250.0000/250.0000/250.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/180.00/0/250.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | IT.03.30009 | B | 6784Obj0000007743 | Objekt | 187.500/141.747/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.1 | 0,041 W/m.K
252x25x25013xxxxxx | Půdorys 1.NP | Kus | 0.013 | 252x25x25013xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/13.4408/250.0000/250.0000/2/13.4408/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/13.44/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.013 m | IT.03.30010 | B | 6784Obj0000007746 | Objekt | 13.441/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 0.013 | 13 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.019 m2
1520425025013xxxxxx0 | Půdorys 1.NP | Kus | 0.126 | 1520425025013xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/126.0000/250.0000/250.0000/2/126.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/126.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.126 m | IT.03.30011 | B | 6784Obj0000007749 | Objekt | 126.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 0.126 | 126 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.178 m2
15206250250126xxxxxx0 | Půdorys 1.NP | Kus | 0.13 | 15206250250126xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/130.0000/250.0000/250.0000/2/130.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/130.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Mineralwolle/100.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.130 m | IT.03.30012 | B | 6784Obj0000007752 | Objekt | 130.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 0.13 | 130 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.184 m2
macro | Půdorys 1.NP | Kus | 0.5 | macro | Schalldämpfer | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/250.00/250.00/500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Mineralwolle/100.00 |  | DN250 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30013 | B | 6784Obj0000007766 | Objekt | 25314.139/-5670.000/3155.000/25064.139/-6170.000/2905.000/0.000/0.000/0.000/1.000 | 1 | 500 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\schalldaempfer\; K_DP_EBT: 0.00; K_DATE: 2023/01/04; N_FREI_68: POZINK
1520431531523xxxxxxx | Půdorys 1.NP | Kus | 0 | 1520431531523xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/250.0000/250.0000/250.0000/2/250.0000/250.0000/0/90.0/0/0/250.0000/250.0000/250.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/0/0/250.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | IT.03.30014 | B | 6784Obj0000008536 | Objekt | 375.000/250.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.1 | 0,041 W/m.K
252x25x25019xxxxxx | Půdorys 1.NP | Kus | 0.021 | 252x25x25019xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/21.3000/250.0000/250.0000/2/21.3000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/21.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.021 m | IT.03.30015 | B | 6784Obj0000008539 | Objekt | 21.300/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 0.021 | 21 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.030 m2
1520525025021xxxxxx0 | Půdorys 1.NP | Kus | 0 | 1520525025021xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/250.0000/250.0000/250.0000/2/250.0000/250.0000/0/90.0/0/0/250.0000/250.0000/250.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/0/0/250.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | IT.03.30016 | B | 6784Obj0000008542 | Objekt | 375.000/250.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.1 | 0,041 W/m.K
252x25x25019xxxxxx | Půdorys 1.NP | Kus | 0.2 | 252x25x25019xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/200.0000/250.0000/250.0000/2/200.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/200.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.200 m | IT.03.30017 | B | 6784Obj0000008545 | Objekt | 200.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 0.2 | 200 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.283 m2
152052502502xxxxxxx0 | Půdorys 1.NP | Kus | 0.445 | 152052502502xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/445.0000/250.0000/250.0000/2/445.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/445.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Alu kaschiert/100.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.445 m | IT.03.30018 | B | 6784Obj0000008548 | Objekt | 445.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 0.445 | 445 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.629 m2
macro | Půdorys 1.NP | Kus | 1.25 | macro | Schalldämpfer | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/250.00/250.00/1250.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Alu kaschiert/100.00 |  | DN250 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30019 | B | 6784Obj0000008565 | Objekt | 26689.139/-7435.000/3155.000/25439.139/-7685.000/2905.000/0.000/0.000/0.000/1.000 | 1 | 1250 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_DWGNAME: ${PROD}l\einbauteile\schalldaempfer\; K_DP_EBT: 0.00; K_DATE: 2022/05/10; N_FREI_68: POZINK
macro | Půdorys 1.NP | Kus | 1.25 | macro | Schalldämpfer | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/250.00/250.00/1250.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Alu kaschiert/100.00 |  | DN250 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30020 | B | 6784Obj0000008579 | Objekt | 26710.439/-6735.000/3155.000/25460.439/-6985.000/2905.000/0.000/0.000/0.000/1.000 | 1 | 1250 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_DWGNAME: ${PROD}l\einbauteile\schalldaempfer\; K_DP_EBT: 0.00; K_DATE: 2022/05/10; N_FREI_68: POZINK
152042x2x117xxxxxxx | Půdorys 1.NP | Kus | 0.1 | 152042x2x117xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/200.0000/200.0000/2/100.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.100 m | IT.03.30021 | B | 6784Obj0000008594 | Objekt | 100.000/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.1 | 100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.126 m2
macro | Půdorys 1.NP | Kus | 1.25 | macro | Schalldämpfer | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/250.00/250.00/1250.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 |  | DN250 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30022 | B | 6784Obj0000010353 | Objekt | 30996.474/-5665.000/3155.000/29746.474/-5915.000/2905.000/0.000/0.000/0.000/1.000 | 1 | 1250 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_DWGNAME: ${PROD}l\einbauteile\schalldaempfer\; K_DP_EBT: 0.00; K_DATE: 2022/05/10; N_FREI_68: POZINK
macro | Půdorys 1.NP | Kus | 1.25 | macro | Schalldämpfer | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/250.00/250.00/1250.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 |  | DN250 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30023 | B | 6784Obj0000010367 | Objekt | 32576.474/-5665.000/3155.000/31326.474/-5915.000/2905.000/0.000/0.000/0.000/1.000 | 1 | 1250 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_DWGNAME: ${PROD}l\einbauteile\schalldaempfer\; K_DP_EBT: 0.00; K_DATE: 2022/05/10; N_FREI_68: POZINK
1015205250250125xxxxxxx | Půdorys 1.NP | Kus | 0.33 | 1015205250250125xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/330.0000/250.0000/250.0000/2/330.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/330.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.330 m | IT.03.30024 | B | 6784Obj0000010370 | Objekt | 330.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 0.33 | 330 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.342 m2
1520525025033xxxxxxx | Půdorys 1.NP | Kus | 0.23 | 1520525025033xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/230.0000/250.0000/250.0000/2/230.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/230.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.230 m | IT.03.30025 | B | 6784Obj0000010373 | Objekt | 230.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 0.23 | 230 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.238 m2
1520425025023xxxxxxx | Půdorys 1.NP | Kus | 0.26 | 1520425025023xxxxxxx | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/260.0000/0/0/0/0/0/1.0000/160.0000/160.0000/2/130.0000/130.0000/0/90.0/0/0/160.0000/160.0000/160.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/160.00/0/0/260.00/0/130.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30026 | B | 6784Obj0000010377 | Objekt | 260.000/130.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 260 | __ISO | 0.04 | 0,041 W/m.K
7520416016016x26x13x9xxxx | Půdorys 1.NP | Kus | 0 | 7520416016016x26x13x9xxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/100.0000/100.0000/2/70.7107/29.2893/0/45.0/0/0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/0/0/100.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 1.0 | IT.03.30027 | B | 6784Obj0000010380 | Objekt | 106.066/64.645/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
252x1x01x145xxxxx0 | Půdorys 1.NP | Kus | 0 | 252x1x01x145xxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/0/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 1.0 | IT.03.30028 | B | 6784Obj0000010383 | Objekt | 150.000/100.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1x01x19xxxxxx | Půdorys 1.NP | Kus | 0.104 | 252x1x01x19xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/104.2526/100.0000/100.0000/2/104.2526/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/104.25/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 0.104 m | IT.03.30029 | B | 6784Obj0000010386 | Objekt | 104.253/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.104 | 104 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.059 m2
152041x1x104xxxxxx0 | Půdorys 1.NP | Kus | 0 | 152041x1x104xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/100.0000/100.0000/100.0000/2/70.7107/29.2893/0/45.0/0/270.0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/270.00/0/100.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 1.0 | IT.03.30030 | B | 6784Obj0000010389 | Objekt | 106.066/64.645/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1x01x145xxxxx0 | Půdorys 1.NP | Kus | 0.276 | 252x1x01x145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/276.2438/100.0000/100.0000/2/276.2438/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/276.24/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 0.276 m | IT.03.30031 | B | 6784Obj0000010392 | Objekt | 276.244/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.276 | 276 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.156 m2
152041x1x276xxxxxx0 | Půdorys 1.NP | Kus | 0.146 | 152041x1x276xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/145.6739/100.0000/100.0000/2/145.6739/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/145.67/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 0.146 m | IT.03.30032 | B | 6784Obj0000010395 | Objekt | 145.674/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.146 | 146 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.082 m2
152041x1x146xxxxxx0 | Půdorys 1.NP | Kus | 0.112 | 152041x1x146xxxxxx0 | UE RUND AS | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/2/112.0000/0/12.5000/0/0/0/100.0000/100.0000/100.0000/2/ | 31/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/100.00/0/0/160.00/100.00/0/112.00/-30.00/-30.00/-17.50/-30.00/30.00/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN160 | 100 | 100 | 160 | 0.000 | 0 | 1.0 | IT.03.30033 | B | 6784Obj0000010398 | Objekt | 112.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 112 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
252x16x16013xxxxxx | Půdorys 1.NP | Kus | 0.522 | 252x16x16013xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/521.6011/160.0000/160.0000/2/521.6011/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/521.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.522 m | IT.03.30034 | B | 6784Obj0000010413 | Objekt | 521.601/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.522 | 522 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.393 m2
15204160160522xxxxxx0 | Půdorys 1.NP | Kus | 0.033 | 15204160160522xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/33.0000/160.0000/160.0000/2/33.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/33.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.033 m | IT.03.30035 | B | 6784Obj0000010416 | Objekt | 33.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.033 | 33 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 0.025 m2
macro | Půdorys 1.NP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/-1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/160.00/160.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 |  | DN160 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.30036 | B | 6784Obj0000010430 | Objekt | 33016.474/-5305.000/3110.000/32856.474/-5615.000/2950.000/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/04; N_FREI_68: SPIRO POTRUBÍ
 | Půdorys 1.NP | Kus | 0.156 |  | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/250.0000/250.0000/2/156.3000/0/0/0/0/0/315.0000/315.0000/315.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/315.00/0/0/250.00/315.00/0/156.30/32.50/32.50/32.50/32.50/30.00/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN250 | 315 | 315 | 250 | 0.000 | 0 | 1.0 | IT.03.30037 | B | 6784Obj0000010433 | Objekt | 156.300/157.500/157.500/0.000/-157.500/-157.500/0.000/0.000/0.000/1.000 | 1 | 156 | __ISO | 0.04 | 0,041 W/m.K
30204250315x2503150156333333333x | Půdorys 1.NP | Kus | 0.025 | 30204250315x2503150156333333333x | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/24.7000/250.0000/250.0000/2/24.7000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/24.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.025 m | IT.03.30038 | B | 6784Obj0000010436 | Objekt | 24.700/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 0.025 | 25 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.026 m2
1520425025025xxxxxx0 | Půdorys 1.NP | Kus | 0.623 | 1520425025025xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/623.2233/250.0000/250.0000/2/623.2233/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/623.22/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.623 m | IT.03.30039 | B | 6784Obj0000010439 | Objekt | 623.223/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 0.623 | 623 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.646 m2
252x25x250145xxxxx0 | Půdorys 1.NP | Kus | 0.26 | 252x25x250145xxxxx0 | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/0/250.0000/250.0000/250.0000/2/260.0000/0/0/0/0/0/1.0000/250.0000/250.0000/2/130.0000/175.0000/0/90.0/0/0/160.0000/160.0000/160.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/160.00/0/0/260.00/0/175.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.0 | IT.03.30040 | B | 6784Obj0000010459 | Objekt | 260.000/175.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 1 | 260 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
7520425025016x26x17509xxxx | Půdorys 1.NP | Kus | 0.12 | 7520425025016x26x17509xxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/120.0000/250.0000/250.0000/2/120.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/120.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.120 m | IT.03.30041 | B | 6784Obj0000010462 | Objekt | 120.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 | 0.12 | 120 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.124 m2
1520425025012xxxxxxx | Půdorys 1.NP | Kus | 0.06 | 1520425025012xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/60.0000/160.0000/160.0000/2/60.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.060 m | IT.03.30042 | B | 6784Obj0000010465 | Objekt | 60.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.06 | 60 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.045 m2
152041601606xxxxxxx | Půdorys 1.NP | Kus | 0.06 | 152041601606xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/60.0000/100.0000/100.0000/2/60.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 0.060 m | IT.03.30043 | B | 6784Obj0000010468 | Objekt | 60.000/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.06 | 60 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.034 m2
152041x1x6xxxxxxx | Půdorys 1.NP | Kus | 0.142 | 152041x1x6xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/141.8842/160.0000/160.0000/2/141.8842/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/141.88/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.142 m | IT.03.30044 | B | 6784Obj0000010471 | Objekt | 141.884/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.142 | 142 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.107 m2
15204160160142xxxxxx0 | Půdorys 1.NP | Kus | 0.26 | 15204160160142xxxxxx0 | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/0/200.0000/200.0000/200.0000/2/150.0000/-130.0000/0/270.0/0/0/1.0000/200.0000/200.0000/2/150.0000/130.0000/0/90.0/0/0/200.0000/200.0000/200.0000/2/ | 75/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/200.00/0/0/260.00/0/150.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | IT.03.30045 | B | 6784Obj0000010475 | Objekt | 250.000/130.000/100.000/0.000/-130.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 260 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1
752062x2x2x026x15x9xxxx | Půdorys 1.NP | Kus | 0.15 | 752062x2x2x026x15x9xxxx | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/2/150.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/100.00/0/0/200.00/100.00/0/150.00/-50.00/-50.00/-50.00/-50.00/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 100 | 100 | 200 | 0.000 | 0 | 1.0 | IT.03.30046 | B | 6784Obj0000010478 | Objekt | 150.000/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 150 | __ISO | 0.04 | 0,041 W/m.K
302042x1xx2x1x0150-50-50-50-503x | Půdorys 1.NP | Kus | 0.085 | 302042x1xx2x1x0150-50-50-50-503x | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/2/85.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/160.00/0/0/200.00/160.00/0/85.00/-20.00/-20.00/-20.00/-20.00/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 160 | 160 | 200 | 0.000 | 0 | 1.0 | IT.03.30047 | B | 6784Obj0000010481 | Objekt | 85.000/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 85 | __ISO | 0.04 | 0,041 W/m.K
302042x16x02x16x85-20-20-20-203x | Půdorys 1.NP | Kus | 0 | 302042x16x02x16x85-20-20-20-203x | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/91.2/100.0000/100.0000/100.0000/2/50.0000/13.3975/0/30.0/0/91.2/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/91.20/0/100.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | IT.03.30048 | B | 6784Obj0000010484 | Objekt | 75.000/56.699/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1x01x13xxxxxx | Půdorys 1.NP | Kus | 0.016 | 252x1x01x13xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/16.4077/100.0000/100.0000/2/16.4077/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/16.41/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 0.016 m | IT.03.30049 | B | 6784Obj0000010487 | Objekt | 16.408/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.016 | 16 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.009 m2
152041x1x16xxxxxx0 | Půdorys 1.NP | Kus | 0 | 152041x1x16xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/271.4/100.0000/100.0000/100.0000/2/50.0000/13.3975/0/30.0/0/271.4/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/271.40/0/100.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | IT.03.30050 | B | 6784Obj0000010490 | Objekt | 75.000/56.699/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1x01x13xxxxxx | Půdorys 1.NP | Kus | 0.129 | 252x1x01x13xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/129.2499/100.0000/100.0000/2/129.2499/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/129.25/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 0.129 m | IT.03.30051 | B | 6784Obj0000010493 | Objekt | 129.250/50.000/50.000/0.000/-50.000/-50.000/0.000/0.000/0.000/1.000 | 0.129 | 129 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.073 m2
152041x1x129xxxxxx0 | Půdorys 1.NP | Kus | 0.155 | 152041x1x129xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/154.9112/160.0000/160.0000/2/154.9112/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/154.91/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.155 m | IT.03.30052 | B | 6784Obj0000010496 | Objekt | 154.911/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.155 | 155 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.117 m2
15204160160155xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15204160160155xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.8/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/270.8/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.80/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30053 | B | 6784Obj0000010499 | Objekt | 120.000/90.718/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16013xxxxxx | Půdorys 1.NP | Kus | 0.024 | 252x16x16013xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/24.1884/160.0000/160.0000/2/24.1884/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/24.19/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.024 m | IT.03.30054 | B | 6784Obj0000010502 | Objekt | 24.188/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.024 | 24 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.018 m2
1520416016024xxxxxx0 | Půdorys 1.NP | Kus | 0 | 1520416016024xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.9/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/90.9/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.90/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.03.30055 | B | 6784Obj0000010505 | Objekt | 120.000/90.718/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16013xxxxxx | Půdorys 1.NP | Kus | 0.155 | 252x16x16013xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/154.9118/160.0000/160.0000/2/154.9118/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/154.91/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 0.155 m | IT.03.30056 | B | 6784Obj0000010508 | Objekt | 154.912/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 0.155 | 155 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.117 m2
15204160160155xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15204160160155xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 |  | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 125 | 125 | 125 | 120.000 |  | 1.0 | IT.03.30057 | B | 6784Obj0000010511 | Objekt | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; L_BES_DIM_B: 125
252x125012519xxxxxx | Půdorys 1.NP | Kus | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 |  | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 125 | 125 | 125 | 120.000 |  | 1.0 | IT.03.30058 | B | 6784Obj0000010514 | Objekt | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; L_BES_DIM_B: 125
252x125012519xxxxxx | Půdorys 1.NP | Kus | 0.622 | 252x125012519xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/622.2540/125.0000/125.0000/2/622.2540/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/622.25/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 0.622 m | IT.03.30059 | B | 6784Obj0000010517 | Objekt | 622.254/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.622 | 622 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.401 m2
15204125125622xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15204125125622xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | IT.03.30060 | B | 6784Obj0000010520 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125145xxxxx0 | Půdorys 1.NP | Kus | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 |  | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 125 | 125 | 125 | 120.000 |  | 1.0 | IT.03.30061 | B | 6784Obj0000010523 | Objekt | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; L_BES_DIM_B: 125
252x125012519xxxxxx | Půdorys 1.NP | Kus | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 |  | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 125 | 125 | 125 | 120.000 |  | 1.0 | IT.03.30062 | B | 6784Obj0000010526 | Objekt | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; L_BES_DIM_B: 125
252x125012519xxxxxx | Půdorys 1.NP | Kus | 0.215 | 252x125012519xxxxxx | T-RUND90 | 20 | 1016 | 3/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/215.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/107.5000/125.0000/0/90.0/0/0/125.0000/125.0000/125.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/125.00/0/0/215.00/0/125.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | IT.03.30063 | B | 6784Obj0000010530 | Objekt | 215.000/125.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 215 | __ISO | 0.04 | 0,041 W/m.K
752041601601250215012509xxxx | Půdorys 1.NP | Kus | 0.078 | 752041601601250215012509xxxx | UE RUND S | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/78.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/0/0/160.00/125.00/0/78.00/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 125 | 125 | 160 | 120.000 | 0 | 1.0 | IT.03.30064 | B | 6784Obj0000010533 | Objekt | 78.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 78 | __ISO | 0.04 | 0,041 W/m.K
30204160125x160125078-18-18-18-1 | Půdorys 1.NP | Kus | 0.336 | 30204160125x160125078-18-18-18-1 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/335.6578/125.0000/125.0000/2/335.6578/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/335.66/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 0.336 m | IT.03.30065 | B | 6784Obj0000010536 | Objekt | 335.658/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.336 | 336 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.216 m2
15204125125336xxxxxx0 | Půdorys 1.NP | Kus | 0 | 15204125125336xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | IT.03.30066 | B | 6784Obj0000010539 | Objekt | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x1250125145xxxxx0 | Půdorys 1.NP | Kus | 0.05 | 252x1250125145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/50.0000/200.0000/200.0000/2/50.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.050 m | IT.03.30067 | B | 6784Obj0000010542 | Objekt | 50.000/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.05 | 50 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.044 m2
152042x2x5xxxxxxx | Půdorys 1.NP | Kus | 0 | 152042x2x5xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/0/200.0000/200.0000/200.0000/2/200.0000/200.0000/0/90.0/0/0/200.0000/200.0000/200.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/0/0/200.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | IT.03.30068 | B | 6784Obj0000010545 | Objekt | 300.000/200.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
