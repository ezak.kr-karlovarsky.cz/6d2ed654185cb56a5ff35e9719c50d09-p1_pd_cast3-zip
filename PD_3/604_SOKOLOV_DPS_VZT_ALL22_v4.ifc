Properties of the parts of a building model (IFC2X3), part 22 of 51

# IfcFlowFitting (2887)
Name | In | Jednotka | Délka (m) | Označení | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_DIM | L_BES_DIM_A2 | L_BES_DIM_B2 | L_BES_DIM_A | K_VOLSTROM | K_MLH_GOST = K_MLD_GOST | K_LISTVALUE | Kód prvku | Třída reakce na oheň | Allright_Stavebni_dil_ID | Název_objektu | K_EBT_BOX_WC | Plocha | L_BES_LAENGE | K_INTERNAL_ISO | Tloušťka (m) | Součinitel tepelné vodivost
50105125125351x2x1251252xx-38-38 | Půdorys 1.NP | m2 | 0.2 | 50105125125351x2x1251252xx-38-38 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/125.0000/125.0000/200.0000/1/200.0000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/35.00/100.00/200.00/125.00/125.00/200.00/0/0/-37.50/-37.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 125x200 | 125 | 125 | 125 | 0.000 | 0 | 1.000 m2 | TA.03.30069 | A1 | 6782Obj0798479454 | Objekt |  |  | 200 | NEMSOK - K_POSITION: L.23; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.125 m; Výška: 0.2 m
50105125125351x2x1251252xx-38-38 | Půdorys 1.NP | m2 | 0.2 | 50105125125351x2x1251252xx-38-38 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/125.0000/125.0000/200.0000/1/200.0000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/35.00/100.00/200.00/125.00/125.00/200.00/0/0/-37.50/-37.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 125x200 | 125 | 125 | 125 | 0.000 | 0 | 1.000 m2 | TA.03.30070 | A1 | 6782Obj0798479455 | Objekt |  |  | 200 | NEMSOK - K_POSITION: L.23; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.125 m; Výška: 0.2 m
50105125125351x2x1251252xx-38-38 | Půdorys 1.NP | m2 | 0.2 | 50105125125351x2x1251252xx-38-38 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/125.0000/125.0000/200.0000/1/200.0000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/35.00/100.00/200.00/125.00/125.00/200.00/0/0/-37.50/-37.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 125x200 | 125 | 125 | 125 | 0.000 | 0 | 1.000 m2 | TA.03.30122 | A1 | 6782Obj0798479684 | Objekt |  |  | 200 | NEMSOK - K_POSITION: L.59; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.125 m; Výška: 0.2 m
50105125125351x2x1251252xx-38-38 | Půdorys 1.NP | m2 | 0.2 | 50105125125351x2x1251252xx-38-38 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/125.0000/125.0000/200.0000/1/200.0000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/35.00/100.00/200.00/125.00/125.00/200.00/0/0/-37.50/-37.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 125x200 | 125 | 125 | 125 | 0.000 | 0 | 1.000 m2 | TA.03.30129 | A1 | 6782Obj0798479717 | Objekt |  |  | 200 | NEMSOK - K_POSITION: L.121; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.125 m; Výška: 0.2 m
50105160160351x2x16016017x0-20-2 | Půdorys 1.NP | m2 | 0.17 | 50105160160351x2x16016017x0-20-2 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/160.0000/160.0000/200.0000/1/169.6000/0/0/0/0/0/0/160.0000/160.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/35.00/100.00/200.00/160.00/160.00/169.60/0/0/-20.00/-20.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x200 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | TA.03.30002 | A1 | 6782Obj0798479188 | Objekt |  |  | 170 | NEMSOK - K_POSITION: L.12; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.16 m; Výška: 0.2 m
50105160160351x2x16016017x0-20-2 | Půdorys 1.NP | m2 | 0.17 | 50105160160351x2x16016017x0-20-2 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/160.0000/160.0000/200.0000/1/169.6000/0/0/0/0/0/0/160.0000/160.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/35.00/100.00/200.00/160.00/160.00/169.60/0/0/-20.00/-20.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x200 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | TA.03.30014 | A1 | 6782Obj0798479256 | Objekt |  |  | 170 | NEMSOK - K_POSITION: L.33; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.16 m; Výška: 0.2 m
50105160160351x2x16016017x0-20-2 | Půdorys 1.NP | m2 | 0.17 | 50105160160351x2x16016017x0-20-2 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/160.0000/160.0000/200.0000/1/169.6000/0/0/0/0/0/0/160.0000/160.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/35.00/100.00/200.00/160.00/160.00/169.60/0/0/-20.00/-20.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x200 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | TA.03.30111 | A1 | 6782Obj0798479650 | Objekt |  |  | 170 | NEMSOK - K_POSITION: L.106; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.16 m; Výška: 0.2 m
50105160160351x2x16016017x0-20-2 | Půdorys 1.NP | m2 | 0.17 | 50105160160351x2x16016017x0-20-2 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/160.0000/160.0000/200.0000/1/169.6000/0/0/0/0/0/0/160.0000/160.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/35.00/100.00/200.00/160.00/160.00/169.60/0/0/-20.00/-20.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x200 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | TA.03.30227 | A1 | 6782Obj0798487854 | Objekt |  |  | 170 | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.16 m; Výška: 0.2 m
501052x125351x1251251252x-38-38x | Půdorys 1.NP | m2 | 0.2 | 501052x125351x1251251252x-38-38x | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/200.0000/200.0000/125.0000/1/200.0000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/125.00/35.00/100.00/125.00/125.00/125.00/200.00/-37.50/-37.50/0/0/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x125 | 125 | 125 | 200 | 0.000 | 0 | 1.000 m2 | TA.03.30191 | A1 | 6782Obj0798486579 | Objekt |  |  | 200 | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 125; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.2 m; Výška: 0.125 m
501052x125351x125125125136-38-38 | Půdorys 1.NP | m2 | 0.136 | 501052x125351x125125125136-38-38 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/200.0000/200.0000/125.0000/1/135.9000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/125.00/35.00/100.00/125.00/125.00/125.00/135.90/-37.50/-37.50/0/0/89.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x125 | 125 | 125 | 200 | 0.000 | 0 | 1.000 m2 | TA.03.30199 | A1 | 6782Obj0798487004 | Objekt |  |  | 136 | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 125; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.2 m; Výška: 0.125 m
501052x125351x2x1251252x-38-38-3 | Půdorys 1.NP | m2 | 0.2 | 501052x125351x2x1251252x-38-38-3 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/200.0000/200.0000/200.0000/1/200.0000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/125.00/35.00/100.00/200.00/125.00/125.00/200.00/-37.50/-37.50/-37.50/-37.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x200 | 125 | 125 | 200 | 0.000 | 0 | 1.000 m2 | TA.03.30231 | A1 | 6782Obj0798487941 | Objekt |  |  | 200 | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.2 m; Výška: 0.2 m
501052x160351x2x160160170-20-20- | Půdorys 1.NP | m2 | 0.17 | 501052x160351x2x160160170-20-20- | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/200.0000/200.0000/200.0000/1/169.6000/0/0/0/0/0/0/160.0000/160.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/160.00/35.00/100.00/200.00/160.00/160.00/169.60/-20.00/-20.00/-20.00/-20.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x200 | 160 | 160 | 200 | 0.000 | 0 | 1.000 m2 | TA.03.30078 | A1 | 6782Obj0798479528 | Objekt |  |  | 170 | NEMSOK - K_POSITION: L.25; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.2 m; Výška: 0.2 m
501052x160351x2x160160170-20-20- | Půdorys 1.NP | m2 | 0.17 | 501052x160351x2x160160170-20-20- | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/200.0000/200.0000/200.0000/1/169.6000/0/0/0/0/0/0/160.0000/160.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/160.00/35.00/100.00/200.00/160.00/160.00/169.60/-20.00/-20.00/-20.00/-20.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x200 | 160 | 160 | 200 | 0.000 | 0 | 1.000 m2 | TA.03.30087 | A1 | 6782Obj0798479546 | Objekt |  |  | 170 | NEMSOK - K_POSITION: L.50; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.2 m; Výška: 0.2 m
501052x160351x2x160160170-20-20- | Půdorys 1.NP | m2 | 0.17 | 501052x160351x2x160160170-20-20- | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/200.0000/200.0000/200.0000/1/169.6000/0/0/0/0/0/0/160.0000/160.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/160.00/35.00/100.00/200.00/160.00/160.00/169.60/-20.00/-20.00/-20.00/-20.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x200 | 160 | 160 | 200 | 0.000 | 0 | 1.000 m2 | TA.03.30103 | A1 | 6782Obj0798479622 | Objekt |  |  | 170 | NEMSOK - K_POSITION: L.81; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.2 m; Výška: 0.2 m
501052x160351x2x160160170-20-20- | Půdorys 1.NP | m2 | 0.17 | 501052x160351x2x160160170-20-20- | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/200.0000/200.0000/200.0000/1/169.6000/0/0/0/0/0/0/160.0000/160.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/160.00/35.00/100.00/200.00/160.00/160.00/169.60/-20.00/-20.00/-20.00/-20.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x200 | 160 | 160 | 200 | 0.000 | 0 | 1.000 m2 | TA.03.30151 | A1 | 6782Obj0798479832 | Objekt |  |  | 170 | NEMSOK - K_POSITION: L.35; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.2 m; Výška: 0.2 m
501052x160351x2x160160170-20-20- | Půdorys 1.NP | m2 | 0.17 | 501052x160351x2x160160170-20-20- | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/200.0000/200.0000/200.0000/1/169.6000/0/0/0/0/0/0/160.0000/160.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/160.00/35.00/100.00/200.00/160.00/160.00/169.60/-20.00/-20.00/-20.00/-20.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x200 | 160 | 160 | 200 | 0.000 | 0 | 1.000 m2 | TA.03.30228 | A1 | 6782Obj0798487862 | Objekt |  |  | 170 | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.2 m; Výška: 0.2 m
701042x2x2x2xxx2xx4x01x1x90 | Půdorys 1.NP | m2 | 0.4 | 701042x2x2x2xxx2xx4x01x1x90 | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/180.0/200.0000/200.0000/200.0000/1/400.0000/0/0/0/0/180.0/200.0000/200.0000/200.0000/1/200.0000/200.0000/0/90.0/0/180.0/200.0000/200.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/200.00/200.00/0/0/0/0/200.00/0/0/180.00/400.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x200 | 200 | 200 | 200 | 0.000 | 0 | 1.000 m2 | TA.03.30037 | A1 | 6782Obj0798479371 | Objekt |  |  | 400 | NEMSOK - K_POSITION: L.10; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.2 m; Výška: 0.2 m
701042x2x125125xx2xx32501x1x90 | Půdorys 1.NP | m2 | 0.325 | 701042x2x125125xx2xx32501x1x90 | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/0/200.0000/200.0000/200.0000/1/325.0000/0/0/0/0/0/160.0000/200.0000/200.0000/1/162.5000/200.0000/0/90.0/0/0/125.0000/125.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/125.00/125.00/0/0/0/0/200.00/0/0/0/325.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x200 | 200 | 200 | 200 | 0.000 | 0 | 1.000 m2 | TA.03.30052 | A1 | 6782Obj0798479431 | Objekt |  |  | 325 | NEMSOK - K_POSITION: L.40; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.2 m; Výška: 0.2 m
701042x2x2x2xxx2xx4x01x1x90 | Půdorys 1.NP | m2 | 0.4 | 701042x2x2x2xxx2xx4x01x1x90 | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/0/200.0000/200.0000/200.0000/1/400.0000/0/0/0/0/0/1.0000/200.0000/200.0000/1/200.0000/200.0000/0/90.0/0/0/200.0000/200.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/200.00/200.00/0/0/0/0/200.00/0/0/0/400.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x200 | 200 | 200 | 200 | 0.000 | 0 | 1.000 m2 | TA.03.30077 | A1 | 6782Obj0798479527 | Objekt |  |  | 400 | NEMSOK - K_POSITION: L.24; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.2 m; Výška: 0.2 m
701042x2x2x2xxx2xx4x01x1x90 | Půdorys 1.NP | m2 | 0.4 | 701042x2x2x2xxx2xx4x01x1x90 | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/180.0/200.0000/200.0000/200.0000/1/400.0000/0/0/0/0/180.0/125.0000/200.0000/200.0000/1/200.0000/200.0000/0/90.0/0/180.0/200.0000/200.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/200.00/200.00/0/0/0/0/200.00/0/0/180.00/400.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x200 | 200 | 200 | 200 | 0.000 | 0 | 1.000 m2 | TA.03.30264 | A1 | 6782Obj0798490232 | Objekt |  |  | 400 | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.2 m; Výška: 0.2 m
701042x2502x2x05x02xx4x01x1x90 | Půdorys 1.NP | m2 | 0.4 | 701042x2502x2x05x02xx4x01x1x90 | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/180.0/200.0000/200.0000/200.0000/1/400.0000/25.0000/0/0/0/180.0/200.0000/250.0000/200.0000/1/200.0000/250.0000/0/90.0/0/180.0/200.0000/200.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/250.00/200.00/200.00/0/50.00/0/0/200.00/0/0/180.00/400.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x200 | 250 | 200 | 200 | 0.000 | 0 | 1.000 m2 | TA.03.30038 | A1 | 6782Obj0798479374 | Objekt |  |  | 400 | NEMSOK - K_POSITION: L.13; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.2 m; Výška: 0.2 m
701042x25013513505x02xx33501x1x9 | Půdorys 1.NP | m2 | 0.335 | 701042x25013513505x02xx33501x1x9 | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/0/200.0000/200.0000/200.0000/1/325.0000/25.0000/0/0/0/0/1.0000/250.0000/200.0000/1/162.5000/250.0000/0/90.0/0/0/125.0000/125.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/250.00/125.00/125.00/0/50.00/0/0/200.00/0/0/0/325.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x200 | 250 | 200 | 200 | 0.000 | 0 | 1.000 m2 | TA.03.30071 | A1 | 6782Obj0798479456 | Objekt | 335.000/250.000/120.000/0.000/-120.000/-120.000/0.000/0.000/0.000/1.000 |  | 325 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.2 m; Výška: 0.2 m
701042x3152x2x0115x2xx4x01x1x90 | Půdorys 1.NP | m2 | 0.4 | 701042x3152x2x0115x2xx4x01x1x90 | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/0/200.0000/200.0000/200.0000/1/400.0000/57.5000/0/0/0/0/200.0000/315.0000/200.0000/1/200.0000/315.0000/0/90.0/0/0/200.0000/200.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/315.00/200.00/200.00/0/115.00/0/0/200.00/0/0/0/400.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x200 | 315 | 200 | 200 | 0.000 | 0 | 1.000 m2 | TA.03.30090 | A1 | 6782Obj0798479573 | Objekt |  |  | 400 | NEMSOK - K_POSITION: L.38; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.2 m; Výška: 0.2 m
501052x160351x201160160171-20-20 | Půdorys 1.NP | m2 | 0.171 | 501052x160351x201160160171-20-20 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/200.0000/200.0000/201.0000/1/170.5000/0/0/0/0/0/0/160.0000/160.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/160.00/35.00/100.00/201.00/160.00/160.00/170.50/-20.00/-20.00/-20.50/-20.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x201 | 160 | 160 | 200 | 0.000 | 0 | 1.000 m2 | TA.03.30085 | A1 | 6782Obj0798479542 | Objekt |  |  | 171 | NEMSOK - K_POSITION: L.5; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 201; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.2 m; Výška: 0.2 m
501052x2x351x2012x2x136x-1-129x0 | Půdorys 1.NP | m2 | 0.136 | 501052x2x351x2012x2x136x-1-129x0 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/200.0000/200.0000/201.0000/1/135.9000/0/0/0/0/0/0/200.0000/200.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/35.00/100.00/201.00/200.00/200.00/135.90/0/0/-0.50/-0.50/29.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x201 | 200 | 200 | 200 | 0.000 | 0 | 1.000 m2 | TA.03.30035 | A1 | 6782Obj0798479369 | Objekt |  |  | 136 | NEMSOK - K_POSITION: L.27; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 201; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.2 m; Výška: 0.2 m
501052x2x351x2012x2x136x-1-129x0 | Půdorys 1.NP | m2 | 0.136 | 501052x2x351x2012x2x136x-1-129x0 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/200.0000/200.0000/201.0000/1/135.9000/0/0/0/0/0/0/200.0000/200.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/35.00/100.00/201.00/200.00/200.00/135.90/0/0/-0.50/-0.50/29.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x201 | 200 | 200 | 200 | 0.000 | 0 | 1.000 m2 | TA.03.30036 | A1 | 6782Obj0798479370 | Objekt |  |  | 136 | NEMSOK - K_POSITION: L.6; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 201; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.2 m; Výška: 0.2 m
501052x2x351x2012x2x136x-1-129x0 | Půdorys 1.NP | m2 | 0.136 | 501052x2x351x2012x2x136x-1-129x0 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/1.0000/200.0000/201.0000/1/135.9000/0/0/0/0/0/0/200.0000/200.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/35.00/100.00/201.00/200.00/200.00/135.90/0/0/-0.50/-0.50/29.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x201 | 200 | 200 | 200 | 0.000 | 0 | 1.000 m2 | TA.03.30086 | A1 | 6782Obj0798479545 | Objekt |  |  | 136 | NEMSOK - K_POSITION: L.42; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 201; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.2 m; Výška: 0.2 m
501052x2x351x2012x2x136x-1-129x0 | Půdorys 1.NP | m2 | 0.136 | 501052x2x351x2012x2x136x-1-129x0 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/1.0000/200.0000/201.0000/1/135.9000/0/0/0/0/0/0/200.0000/200.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/35.00/100.00/201.00/200.00/200.00/135.90/0/0/-0.50/-0.50/29.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x201 | 200 | 200 | 200 | 0.000 | 0 | 1.000 m2 | TA.03.30099 | A1 | 6782Obj0798479614 | Objekt |  |  | 136 | NEMSOK - K_POSITION: L.76; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 201; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.2 m; Výška: 0.2 m
501052x2x351x2012x2x136x-1-129x0 | Půdorys 1.NP | m2 | 0.136 | 501052x2x351x2012x2x136x-1-129x0 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/1.0000/200.0000/201.0000/1/135.9000/0/0/0/0/0/0/200.0000/200.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/35.00/100.00/201.00/200.00/200.00/135.90/0/0/-0.50/-0.50/29.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x201 | 200 | 200 | 200 | 0.000 | 0 | 1.000 m2 | TA.03.30107 | A1 | 6782Obj0798479638 | Objekt |  |  | 136 | NEMSOK - K_POSITION: L.86; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 201; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.2 m; Výška: 0.2 m
501052x2x351x2012x2x136x-1-129x0 | Půdorys 1.NP | m2 | 0.136 | 501052x2x351x2012x2x136x-1-129x0 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/1.0000/200.0000/201.0000/1/135.9000/0/0/0/0/0/0/200.0000/200.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/35.00/100.00/201.00/200.00/200.00/135.90/0/0/-0.50/-0.50/29.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x201 | 200 | 200 | 200 | 0.000 | 0 | 1.000 m2 | TA.03.30183 | A1 | 6782Obj0798485626 | Objekt |  |  | 136 | NEMSOK - K_POSITION: L.13; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 201; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.2 m; Výška: 0.2 m
501052x2x351x2012x2x136x-1-129x0 | Půdorys 1.NP | m2 | 0.136 | 501052x2x351x2012x2x136x-1-129x0 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/1.0000/200.0000/201.0000/1/135.9000/0/0/0/0/0/0/200.0000/200.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/35.00/100.00/201.00/200.00/200.00/135.90/0/0/-0.50/-0.50/29.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x201 | 200 | 200 | 200 | 0.000 | 0 | 1.000 m2 | TA.03.30184 | A1 | 6782Obj0798485632 | Objekt |  |  | 136 | NEMSOK - K_POSITION: L.14; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 201; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.2 m; Výška: 0.2 m
501052x2x351x2012x2x136x-1-129x0 | Půdorys 1.NP | m2 | 0.136 | 501052x2x351x2012x2x136x-1-129x0 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/1.0000/200.0000/201.0000/1/135.9000/0/0/0/0/0/0/200.0000/200.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/35.00/100.00/201.00/200.00/200.00/135.90/0/0/-0.50/-0.50/29.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x201 | 200 | 200 | 200 | 0.000 | 0 | 1.000 m2 | TA.03.30213 | A1 | 6782Obj0798487287 | Objekt |  |  | 136 | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 201; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.2 m; Výška: 0.2 m
701042x2x125125xx28x032501x1x90 | Půdorys 1.NP | m2 | 0.325 | 701042x2x125125xx28x032501x1x90 | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/90.0/200.0000/200.0000/280.0000/1/225.0000/0/0/0/0/90.0/1.0000/200.0000/280.0000/1/112.5000/190.0000/0/90.0/0/90.0/200.0000/200.0000/125.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/280.00/125.00/125.00/0/0/0/0/200.00/0/0/90.00/225.00/0/50.00/50.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x280 | 200 | 280 | 200 | 0.000 | 0 | 1.000 m2 | TA.03.30198 | A1 | 6782Obj0798486998 | Objekt | 225.000/150.000/160.000/0.000/-120.000/-160.000/0.000/0.000/0.000/1.000 |  | 225 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 280; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.2 m; Výška: 0.28 m
701042x2x125125xx315x32501x1x90 | Půdorys 1.NP | m2 | 0.325 | 701042x2x125125xx315x32501x1x90 | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/90.0/200.0000/200.0000/315.0000/1/325.0000/0/0/0/0/90.0/1.0000/200.0000/315.0000/1/162.5000/257.5000/0/90.0/0/90.0/200.0000/200.0000/125.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/125.00/125.00/0/0/0/0/200.00/0/0/90.00/325.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x315 | 200 | 315 | 200 | 0.000 | 0 | 1.000 m2 | TA.03.30190 | A1 | 6782Obj0798486558 | Objekt | 325.000/200.000/177.500/0.000/-120.000/-177.500/0.000/0.000/0.000/1.000 |  | 325 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 315; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.2 m; Výška: 0.315 m
701042x2x2x2x50505050355x4x05050 | Půdorys 1.NP | m2 | 0.4 | 701042x2x2x2x50505050355x4x05050 | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/90.0/200.0000/200.0000/355.0000/1/300.0000/0/0/0/0/90.0/1.0000/200.0000/355.0000/1/150.0000/227.5000/0/90.0/0/90.0/200.0000/200.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/355.00/355.00/200.00/200.00/0/0/0/0/200.00/0/0/90.00/300.00/0/50.00/50.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x355 | 200 | 355 | 200 | 0.000 | 0 | 1.000 m2 | TA.03.30197 | A1 | 6782Obj0798486928 | Objekt | 300.000/150.000/197.500/0.000/-120.000/-197.500/0.000/0.000/0.000/1.000 |  | 300 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.2 m; Výška: 0.355 m
70104250125315315x12502xx51501x1 | Půdorys 1.NP | m2 | 0.515 | 70104250125315315x12502xx51501x1 | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/0/250.0000/250.0000/200.0000/1/480.0000/-62.5000/0/0/0/0/1.0000/125.0000/200.0000/1/240.0000/225.0000/0/90.0/0/0/280.0000/280.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/125.00/280.00/280.00/0/0/125.00/0/200.00/0/0/0/480.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x200 | 125 | 200 | 250 | 0.000 | 0 | 1.000 m2 | TA.03.30015 | A1 | 6782Obj0798479269 | Objekt | 515.000/225.000/120.000/0.000/-145.000/-120.000/0.000/0.000/0.000/1.000 |  | 480 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.25 m; Výška: 0.2 m
501052502x351x2x2x2x178-25-25x3x | Půdorys 1.NP | m2 | 0.178 | 501052502x351x2x2x2x178-25-25x3x | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/250.0000/250.0000/200.0000/1/178.3000/0/0/0/0/0/0/200.0000/200.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/200.00/35.00/100.00/200.00/200.00/200.00/178.30/-25.00/-25.00/0/0/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x200 | 200 | 200 | 250 | 0.000 | 0 | 1.000 m2 | TA.03.30237 | A1 | 6782Obj0798488031 | Objekt |  |  | 178 | NEMSOK - K_POSITION: L.20; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.25 m; Výška: 0.2 m
501052502x351x2x2x2x178-25-25x3x | Půdorys 1.NP | m2 | 0.178 | 501052502x351x2x2x2x178-25-25x3x | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/250.0000/250.0000/200.0000/1/178.3000/0/0/0/0/0/0/200.0000/200.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/200.00/35.00/100.00/200.00/200.00/200.00/178.30/-25.00/-25.00/0/0/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x200 | 200 | 200 | 250 | 0.000 | 0 | 1.000 m2 | TA.03.30238 | A1 | 6782Obj0798488040 | Objekt |  |  | 178 | NEMSOK - K_POSITION: L.20; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.25 m; Výška: 0.2 m
2010425025x50502x1x902xxxx0 | Půdorys 1.NP | m2 | 0 | 2010425025x50502x1x902xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/180.0/250.0000/250.0000/200.0000/1/275.0000/275.0000/0/90.0/0/180.0/200.0000/250.0000/200.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/0/50.00/50.00/200.00/100.00/90.00/180.00/0/200.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x200 | 250 | 200 | 250 | 0.000 | 0 | 1.000 m2 | TA.03.30039 | A1 | 6782Obj0798479376 | Objekt | NEMSOK - K_POSITION: L.15; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.25 m; Výška: 0.2 m
70104250250125125xx2xx32501x1x90 | Půdorys 1.NP | m2 | 0.325 | 70104250250125125xx2xx32501x1x90 | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/0/250.0000/250.0000/200.0000/1/325.0000/0/0/0/0/0/160.0000/250.0000/200.0000/1/162.5000/225.0000/0/90.0/0/0/125.0000/125.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/125.00/125.00/0/0/0/0/200.00/0/0/0/325.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x200 | 250 | 200 | 250 | 0.000 | 0 | 1.000 m2 | TA.03.30064 | A1 | 6782Obj0798479449 | Objekt |  |  | 325 | NEMSOK - K_POSITION: L.48; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.25 m; Výška: 0.2 m
701042502502x2xxx2xx4x01x1x90 | Půdorys 1.NP | m2 | 0.4 | 701042502502x2xxx2xx4x01x1x90 | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/0/250.0000/250.0000/200.0000/1/400.0000/0/0/0/0/0/1.0000/250.0000/200.0000/1/200.0000/225.0000/0/90.0/0/0/200.0000/200.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/200.00/200.00/0/0/0/0/200.00/0/0/0/400.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x200 | 250 | 200 | 250 | 0.000 | 0 | 1.000 m2 | TA.03.30098 | A1 | 6782Obj0798479613 | Objekt |  |  | 400 | NEMSOK - K_POSITION: L.75; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.25 m; Výška: 0.2 m
2010525025x50502x1x902xxxx0 | Půdorys 1.NP | m2 | 0 | 2010525025x50502x1x902xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/180.0/250.0000/250.0000/200.0000/1/275.0000/275.0000/0/90.0/0/180.0/125.0000/250.0000/200.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/0/50.00/50.00/200.00/100.00/90.00/180.00/0/200.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x200 | 250 | 200 | 250 | 0.000 | 0 | 1.000 m2 | TA.03.30234 | A1 | 6782Obj0798488017 | Objekt | NEMSOK - K_POSITION: L.13; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.25 m; Výška: 0.2 m
2010525025x50502x1x902xxxx0 | Půdorys 1.NP | m2 | 0 | 2010525025x50502x1x902xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/0/250.0000/250.0000/200.0000/1/275.0000/275.0000/0/90.0/0/0/125.0000/250.0000/200.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/0/50.00/50.00/200.00/100.00/90.00/0/0/200.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x200 | 250 | 200 | 250 | 0.000 | 0 | 1.000 m2 | TA.03.30235 | A1 | 6782Obj0798488023 | Objekt | NEMSOK - K_POSITION: L.16; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.25 m; Výška: 0.2 m
70106250250250250505050502xx55x1 | Půdorys 1.NP | m2 | 0.55 | 70106250250250250505050502xx55x1 | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/0/250.0000/250.0000/200.0000/1/275.0000/-275.0000/0/270.0/0/0/125.0000/250.0000/200.0000/1/275.0000/275.0000/0/90.0/0/0/250.0000/250.0000/200.0000/1/ | 70/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/250.00/250.00/50.00/50.00/50.00/50.00/200.00/0/0/0/550.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x200 | 250 | 200 | 250 | 0.000 | 0 | 1.000 m2 | TA.03.30236 | A1 | 6782Obj0798488029 | Objekt |  |  | 550 | NEMSOK - K_POSITION: L.19; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.25 m; Výška: 0.2 m
201052x2x050502501x302xxxx0 | Půdorys 1.NP | m2 | 0 | 201052x2x050502501x302xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/270.0/250.0000/250.0000/200.0000/1/193.3013/51.7949/0/30.0/0/270.0/1.0000/250.0000/200.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/0/50.00/50.00/250.00/100.00/30.00/270.00/0/200.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x200 | 250 | 200 | 250 | 0.000 | 0 | 1.000 m2 | TA.03.30241 | A1 | 6782Obj0798489056 | Objekt | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.25 m; Výška: 0.2 m
201052x2x050502501x302xxxx0 | Půdorys 1.NP | m2 | 0 | 201052x2x050502501x302xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/270.0/250.0000/250.0000/200.0000/1/193.3013/51.7949/0/30.0/0/270.0/1.0000/250.0000/200.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/0/50.00/50.00/250.00/100.00/30.00/270.00/0/200.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x200 | 250 | 200 | 250 | 0.000 | 0 | 1.000 m2 | TA.03.30242 | A1 | 6782Obj0798489086 | Objekt | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.25 m; Výška: 0.2 m
4010425028050502x2x01261515x3xx | Půdorys 1.NP | m2 | 0.126 | 4010425028050502x2x01261515x3xx | UEBERGANG SYM. | 20 | 40 | 2/0/0/0/180.0/0/0/250.0000/250.0000/200.0000/1/126.0000/0/-0/0/0/0/0/280.0000/200.0000/1/ | 40/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/280.00/50.00/50.00/200.00/200.00/0/126.00/15.00/15.00/0/0/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x200 | 280 | 200 | 250 | 0.000 | 0 | 1.000 m2 | TA.03.30003 | A1 | 6782Obj0798479199 | Objekt |  |  | 126 | NEMSOK - K_POSITION: L.18; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.25 m; Výška: 0.2 m
7010425028012512503x02xx32501x1x | Půdorys 1.NP | m2 | 0.325 | 7010425028012512503x02xx32501x1x | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/0/250.0000/250.0000/200.0000/1/325.0000/15.0000/0/0/0/0/160.0000/280.0000/200.0000/1/162.5000/255.0000/0/90.0/0/0/125.0000/125.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/280.00/125.00/125.00/0/30.00/0/0/200.00/0/0/0/325.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x200 | 280 | 200 | 250 | 0.000 | 0 | 1.000 m2 | TA.03.30065 | A1 | 6782Obj0798479450 | Objekt |  |  | 325 | NEMSOK - K_POSITION: L.52; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.25 m; Výška: 0.2 m
701042503152x2x065x2xx4x01x1x90 | Půdorys 1.NP | m2 | 0.4 | 701042503152x2x065x2xx4x01x1x90 | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/180.0/250.0000/250.0000/200.0000/1/400.0000/32.5000/0/0/0/180.0/200.0000/315.0000/200.0000/1/200.0000/290.0000/0/90.0/0/180.0/200.0000/200.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/315.00/200.00/200.00/0/65.00/0/0/200.00/0/0/180.00/400.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x200 | 315 | 200 | 250 | 0.000 | 0 | 1.000 m2 | TA.03.30102 | A1 | 6782Obj0798479621 | Objekt |  |  | 400 | NEMSOK - K_POSITION: L.80; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.25 m; Výška: 0.2 m
21104280125050501255090125xxx0 | Půdorys 1.NP | m2 | 0 | 21104280125050501255090125xxx0 | BOGEN ASY. | 20 | 21 | 2/0/0/0/180.0/0/0/280.0000/280.0000/125.0000/1/112.5000/190.0000/0/90.0/0/270.0/1.0000/125.0000/125.0000/1/ | 21/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/125.00/0/50.00/50.00/125.00/0/90.00/0/0/125.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 280x125 | 125 | 125 | 280 | 0.000 | 0 | 1.000 m2 | TA.03.30005 | A1 | 6782Obj0798479202 | Objekt | 245.000/240.000/82.500/0.000/-160.000/-82.500/0.000/0.000/0.000/1.000 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 125; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.28 m; Výška: 0.125 m
70104280160315315x12x2xx51501x1x | Půdorys 1.NP | m2 | 0.515 | 70104280160315315x12x2xx51501x1x | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/180.0/280.0000/280.0000/200.0000/1/515.0000/-60.0000/0/0/0/180.0/1.0000/160.0000/200.0000/1/257.5000/240.0000/0/90.0/0/180.0/315.0000/315.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/160.00/315.00/315.00/0/0/120.00/0/200.00/0/0/180.00/515.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 280x200 | 160 | 200 | 280 | 0.000 | 0 | 1.000 m2 | TA.03.30001 | A1 | 6782Obj0798479187 | Objekt |  |  | 515 | NEMSOK - K_POSITION: L.11; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.28 m; Výška: 0.2 m
701042802x2x2xx8x2xx4x01x1x90 | Půdorys 1.NP | m2 | 0.4 | 701042802x2x2xx8x2xx4x01x1x90 | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/0/280.0000/280.0000/200.0000/1/400.0000/-40.0000/0/0/0/0/1.0000/200.0000/200.0000/1/200.0000/240.0000/0/90.0/0/0/200.0000/200.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/200.00/200.00/200.00/0/0/80.00/0/200.00/0/0/0/400.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 280x200 | 200 | 200 | 280 | 0.000 | 0 | 1.000 m2 | TA.03.30182 | A1 | 6782Obj0798485620 | Objekt |  |  | 400 | NEMSOK - K_POSITION: L.12; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.28 m; Výška: 0.2 m
701042x2x125125xx28x032501x1x90 | Půdorys 1.NP | m2 | 0.325 | 701042x2x125125xx28x032501x1x90 | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/270.0/280.0000/280.0000/200.0000/1/325.0000/0/0/0/0/90.0/1.0000/280.0000/200.0000/1/162.5000/200.0000/0/90.0/0/270.0/280.0000/280.0000/125.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/125.00/125.00/0/0/0/0/280.00/0/0/270.00/325.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 280x200 | 280 | 200 | 280 | 0.000 | 0 | 1.000 m2 | TA.03.30004 | A1 | 6782Obj0798479200 | Objekt |  |  | 325 | NEMSOK - K_POSITION: L.19; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.28 m; Výška: 0.2 m
70104280280125125xx2xx32501x1x90 | Půdorys 1.NP | m2 | 0.325 | 70104280280125125xx2xx32501x1x90 | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/0/280.0000/280.0000/200.0000/1/325.0000/0/0/0/0/0/160.0000/280.0000/200.0000/1/162.5000/240.0000/0/90.0/0/0/125.0000/125.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/280.00/125.00/125.00/0/0/0/0/200.00/0/0/0/325.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 280x200 | 280 | 200 | 280 | 0.000 | 0 | 1.000 m2 | TA.03.30066 | A1 | 6782Obj0798479451 | Objekt |  |  | 325 | NEMSOK - K_POSITION: L.56; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.28 m; Výška: 0.2 m
2010428028x50502x1x3xxxx0 | Půdorys 1.NP | m2 | 0 | 2010428028x50502x1x3xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/180.0/280.0000/280.0000/200.0000/1/213.3013/57.1539/0/30.0/0/180.0/1.0000/280.0000/200.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/280.00/0/50.00/50.00/200.00/100.00/30.00/180.00/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 280x200 | 280 | 200 | 280 | 0.000 | 0 | 1.000 m2 | TA.03.30194 | A1 | 6782Obj0798486644 | Objekt | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.28 m; Výška: 0.2 m
2010428028x50502x1x3xxxx0 | Půdorys 1.NP | m2 | 0 | 2010428028x50502x1x3xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/0/280.0000/280.0000/200.0000/1/213.3013/57.1539/0/30.0/0/0/1.0000/280.0000/200.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/280.00/0/50.00/50.00/200.00/100.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 280x200 | 280 | 200 | 280 | 0.000 | 0 | 1.000 m2 | TA.03.30195 | A1 | 6782Obj0798486704 | Objekt | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.28 m; Výška: 0.2 m
4010428031550502x2x01301818x3xx | Půdorys 1.NP | m2 | 0.13 | 4010428031550502x2x01301818x3xx | UEBERGANG SYM. | 20 | 40 | 2/0/0/0/180.0/0/0/280.0000/280.0000/200.0000/1/130.3000/0/-0/0/0/0/0/315.0000/200.0000/1/ | 40/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/315.00/50.00/50.00/200.00/200.00/0/130.30/17.50/17.50/0/0/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 280x200 | 315 | 200 | 280 | 0.000 | 0 | 1.000 m2 | TA.03.30017 | A1 | 6782Obj0798479274 | Objekt |  |  | 130 | NEMSOK - K_POSITION: L.11; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.28 m; Výška: 0.2 m
4010428035550502x2x01653838x3xx | Půdorys 1.NP | m2 | 0.165 | 4010428035550502x2x01653838x3xx | UEBERGANG SYM. | 20 | 40 | 2/0/0/0/180.0/0/0/280.0000/280.0000/200.0000/1/165.0000/0/-0/0/0/0/0/355.0000/200.0000/1/ | 40/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/355.00/50.00/50.00/200.00/200.00/0/165.00/37.50/37.50/0/0/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 280x200 | 355 | 200 | 280 | 0.000 | 0 | 1.000 m2 | TA.03.30007 | A1 | 6782Obj0798479211 | Objekt |  |  | 165 | NEMSOK - K_POSITION: L.8; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.28 m; Výška: 0.2 m
701043152x355355x11502xx55501x1x | Půdorys 1.NP | m2 | 0.555 | 701043152x355355x11502xx55501x1x | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/0/315.0000/315.0000/200.0000/1/555.0000/-57.5000/0/0/0/0/1.0000/200.0000/200.0000/1/277.5000/257.5000/0/90.0/0/0/355.0000/355.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/200.00/355.00/355.00/0/0/115.00/0/200.00/0/0/0/555.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x200 | 200 | 200 | 315 | 0.000 | 0 | 1.000 m2 | TA.03.30123 | A1 | 6782Obj0798479694 | Objekt |  |  | 555 | NEMSOK - K_POSITION: L.5; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.060 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.315 m; Výška: 0.2 m
70104315280125125x3502xx32501x1x | Půdorys 1.NP | m2 | 0.325 | 70104315280125125x3502xx32501x1x | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/180.0/315.0000/315.0000/200.0000/1/325.0000/-17.5000/0/0/0/180.0/1.0000/280.0000/200.0000/1/162.5000/257.5000/0/90.0/0/180.0/125.0000/125.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/280.00/125.00/125.00/0/0/35.00/0/200.00/0/0/180.00/325.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x200 | 280 | 200 | 315 | 0.000 | 0 | 1.000 m2 | TA.03.30181 | A1 | 6782Obj0798485585 | Objekt |  |  | 325 | NEMSOK - K_POSITION: L.10; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.315 m; Výška: 0.2 m
201052x2x050503151x3xxxx0 | Půdorys 1.NP | m2 | 0 | 201052x2x050503151x3xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/90.0/315.0000/315.0000/200.0000/1/193.3013/51.7949/0/30.0/0/90.0/1.0000/315.0000/200.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/0/50.00/50.00/315.00/100.00/30.00/90.00/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x200 | 315 | 200 | 315 | 0.000 | 0 | 1.000 m2 | TA.03.30030 | A1 | 6782Obj0798479338 | Objekt | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.315 m; Výška: 0.2 m
201052x2x050503151x3xxxx0 | Půdorys 1.NP | m2 | 0 | 201052x2x050503151x3xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/90.0/315.0000/315.0000/200.0000/1/193.3013/51.7949/0/30.0/0/90.0/1.0000/315.0000/200.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/0/50.00/50.00/315.00/100.00/30.00/90.00/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x200 | 315 | 200 | 315 | 0.000 | 0 | 1.000 m2 | TA.03.30031 | A1 | 6782Obj0798479340 | Objekt | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.315 m; Výška: 0.2 m
6110431531550502x3550488x-115270 | Půdorys 1.NP | m2 | 0.488 | 6110431531550502x3550488x-115270 | UEBERGANGSETAGE | 20 | 61 | 2/0/0/0/180.0/0/0/1.0000/315.0000/200.0000/1/487.5000/0/-192.5000/0/0/0/0/315.0000/355.0000/1/ | 61/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/50.00/50.00/200.00/355.00/0/487.50/0/0/-115.00/270.00/19.35/0/61.00/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x200 | 315 | 355 | 315 | 0.000 | 0 | 1.000 m2 | TA.03.30124 | A1 | 6782Obj0798479701 | Objekt |  |  | 488 | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.315 m; Výška: 0.2 m
70104315315125125xx2xx32501x1x90 | Půdorys 1.NP | m2 | 0.325 | 70104315315125125xx2xx32501x1x90 | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/180.0/315.0000/315.0000/200.0000/1/325.0000/0/0/0/0/180.0/1.0000/315.0000/200.0000/1/162.5000/257.5000/0/90.0/0/180.0/125.0000/125.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/125.00/125.00/0/0/0/0/200.00/0/0/180.00/325.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x200 | 315 | 200 | 315 | 0.000 | 0 | 1.000 m2 | TA.03.30180 | A1 | 6782Obj0798485520 | Objekt |  |  | 325 | NEMSOK - K_POSITION: L.6; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.315 m; Výška: 0.2 m
7010431535512512504x02xx32501x1x | Půdorys 1.NP | m2 | 0.325 | 7010431535512512504x02xx32501x1x | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/0/315.0000/315.0000/200.0000/1/325.0000/20.0000/0/0/0/0/160.0000/355.0000/200.0000/1/162.5000/297.5000/0/90.0/0/0/125.0000/125.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/355.00/125.00/125.00/0/40.00/0/0/200.00/0/0/0/325.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x200 | 355 | 200 | 315 | 0.000 | 0 | 1.000 m2 | TA.03.30171 | A1 | 6782Obj0798485083 | Objekt |  |  | 325 | NEMSOK - K_POSITION: L.17; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.315 m; Výška: 0.2 m
701043154x2x2x085x2xx4x01x1x90 | Půdorys 1.NP | m2 | 0.4 | 701043154x2x2x085x2xx4x01x1x90 | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/180.0/315.0000/315.0000/200.0000/1/400.0000/42.5000/0/0/0/180.0/200.0000/400.0000/200.0000/1/200.0000/342.5000/0/90.0/0/180.0/200.0000/200.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/400.00/200.00/200.00/0/85.00/0/0/200.00/0/0/180.00/400.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x200 | 400 | 200 | 315 | 0.000 | 0 | 1.000 m2 | TA.03.30091 | A1 | 6782Obj0798479574 | Objekt |  |  | 400 | NEMSOK - K_POSITION: L.39; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.315 m; Výška: 0.2 m
701043154x2x2x085x2xx4x01x1x90 | Půdorys 1.NP | m2 | 0.4 | 701043154x2x2x085x2xx4x01x1x90 | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/0/315.0000/315.0000/200.0000/1/400.0000/42.5000/0/0/0/0/160.0000/400.0000/200.0000/1/200.0000/342.5000/0/90.0/0/0/200.0000/200.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/400.00/200.00/200.00/0/85.00/0/0/200.00/0/0/0/400.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x200 | 400 | 200 | 315 | 0.000 | 0 | 1.000 m2 | TA.03.30106 | A1 | 6782Obj0798479637 | Objekt |  |  | 400 | NEMSOK - K_POSITION: L.85; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.315 m; Výška: 0.2 m
7010431531545045xx0355x65x1x1x90 | Půdorys 1.NP | m2 | 0.65 | 7010431531545045xx0355x65x1x1x90 | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/0/315.0000/315.0000/355.0000/1/700.0000/67.5000/0/0/0/0/1.0000/450.0000/355.0000/1/350.0000/392.5000/0/90.0/0/0/500.0000/500.0000/355.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/450.00/500.00/500.00/0/135.00/0/0/355.00/0/0/0/700.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x355 | 450 | 355 | 315 | 0.000 | 0 | 1.530 m2 | TA.03.30125 | A1 | 6782Obj0798479706 | Objekt | 700.000/257.500/197.500/0.000/-177.500/-197.500/0.000/0.000/0.000/1.000 |  | 700 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355; K_LISTVALUE_ISO: 1.830 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.315 m; Výška: 0.355 m
70104355355125125xx2xx32501x1x90 | Půdorys 1.NP | m2 | 0.325 | 70104355355125125xx2xx32501x1x90 | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/0/355.0000/355.0000/200.0000/1/325.0000/0/0/0/0/0/160.0000/355.0000/200.0000/1/162.5000/277.5000/0/90.0/0/0/125.0000/125.0000/200.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/355.00/355.00/125.00/125.00/0/0/0/0/200.00/0/0/0/325.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 355x200 | 355 | 200 | 355 | 0.000 | 0 | 1.000 m2 | TA.03.30172 | A1 | 6782Obj0798485148 | Objekt |  |  | 325 | NEMSOK - K_POSITION: L.21; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: -; Šířka: 0.355 m; Výška: 0.2 m
