Properties of the parts of a building model (IFC2X3), part 9 of 51

# IfcFlowFitting (2887)
Name | In | Jednotka | Délka (m) | Označení | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_DIM | L_BES_DIM_A2 | L_BES_DIM_B2 | L_BES_DIM_A | K_VOLSTROM | K_MLH_GOST = K_MLD_GOST | K_LISTVALUE | Kód prvku | Třída reakce na oheň | Allright_Stavebni_dil_ID | Název_objektu | K_EBT_BOX_WC | Plocha | L_BES_LAENGE | K_INTERNAL_ISO | Tloušťka (m) | Součinitel tepelné vodivost
10106160160141xxxxxx0 | Půdorys 1.PP | Kus | 0.05 | 10106160160141xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/450.0000/710.0000/1/50.0000/0/0/0/0/0/1.0000/450.0000/710.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/710.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x710 | 450 | 710 | 450 | 0.000 | 0 | 1.000 m2 | IT.02.30005 | B | 6774Obj0000026599 | Objekt | 50.000/245.000/375.000/0.000/-245.000/-375.000/0.000/0.000/0.000/1.000 | 1 | 50 | __ISO | 0.05 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 710; K_LISTVALUE_ISO: 1.000 m2
101044507105xxxxxxx | Půdorys 1.PP | Kus | 0 | 101044507105xxxxxxx | BOGEN ASY. | 20 | 1016 | 2/0/0/0/180.0/0/90.0/450.0000/450.0000/710.0000/1/307.5000/505.0000/0/90.0/0/90.0/1.0000/450.0000/315.0000/1/ | 21/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/710.00/315.00/0/50.00/50.00/450.00/100.00/90.00/90.00/1.00/450.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x710 | 450 | 315 | 450 | 0.000 | 0 | 3.180 m2 | IT.02.30006 | B | 6774Obj0000026681 | Objekt | 485.000/505.000/245.000/0.000/-375.000/-245.000/0.000/0.000/0.000/1.000 | 3.18 |  | __ISO | 0.05 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 710; K_LISTVALUE_ISO: 3.950 m2
21104710315050504501x9045xxxx | Půdorys 1.PP | Kus | 1.5 | 21104710315050504501x9045xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/160.0000/1/1500.0000/0/0/0/0/0/1.0000/560.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/160.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 560 | 160 | 560 | 0.000 | 0 | 2.160 m2 | IT.02.30007 | B | 6774Obj0000026695 | Objekt | 1500.000/300.000/100.000/0.000/-300.000/-100.000/0.000/0.000/0.000/1.000 | 2.16 | 1500 | __ISO | 0.05 | 0,041 W/m.K | NEMSOK - K_POSITION: L.32; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 2.760 m2
1010456016015xxxxxxx0 | Půdorys 1.PP | Kus | 1.5 | 1010456016015xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/160.0000/1/1500.0000/0/0/0/0/0/1.0000/560.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/160.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 560 | 160 | 560 | 0.000 | 0 | 2.160 m2 | IT.02.30008 | B | 6774Obj0000026709 | Objekt | 1500.000/300.000/100.000/0.000/-300.000/-100.000/0.000/0.000/0.000/1.000 | 2.16 | 1500 | __ISO | 0.05 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 2.760 m2
1010456016015xxxxxxx0 | Půdorys 1.PP | Kus | 1.28 | 1010456016015xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/160.0000/1/1280.0000/0/0/0/0/0/1.0000/560.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/160.00/1280.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 560 | 160 | 560 | 0.000 | 0 | 1.840 m2 | IT.02.30009 | B | 6774Obj0000026723 | Objekt | 1280.000/300.000/100.000/0.000/-300.000/-100.000/0.000/0.000/0.000/1.000 | 1.84 | 1280 | __ISO | 0.05 | 0,041 W/m.K | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 2.360 m2
10104560160128xxxxxxx | Půdorys 1.PP | Kus | 1.2 | 10104560160128xxxxxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/160.0000/1/1200.0000/0/0/0/0/0/1.0000/560.0000/160.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/160.00/1200.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 560 | 160 | 560 | 0.000 | 0 | 1.730 m2 | IT.02.30010 | B | 6774Obj0000026737 | Objekt | 1200.000/300.000/100.000/0.000/-300.000/-100.000/0.000/0.000/0.000/1.000 | 1.73 | 1200 | __ISO | 0.05 | 0,041 W/m.K | NEMSOK - K_POSITION: L.8; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 2.210 m2
1010556016012xxxxxxx0 | Půdorys 1.PP | Kus | 0 | 1010556016012xxxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/180.0/560.0000/560.0000/160.0000/1/430.0000/430.0000/0/90.0/0/180.0/1.0000/560.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/0/50.00/50.00/160.00/100.00/90.00/180.00/1.00/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 560 | 160 | 560 | 0.000 | 0 | 1.640 m2 | IT.02.30011 | B | 6774Obj0000026819 | Objekt | 730.000/430.000/100.000/0.000/-300.000/-100.000/0.000/0.000/0.000/1.000 | 1.64 |  | __ISO | 0.05 | 0,041 W/m.K | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 2.240 m2
1010456016015xxxxxxx0 | Půdorys 1.PP | Kus | 0 | 1010456016015xxxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/180.0/560.0000/560.0000/160.0000/1/430.0000/430.0000/0/90.0/0/180.0/1.0000/560.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/0/50.00/50.00/160.00/100.00/90.00/180.00/1.00/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 560 | 160 | 560 | 0.000 | 0 | 1.640 m2 | IT.02.30012 | B | 6774Obj0000026915 | Objekt | 730.000/430.000/100.000/0.000/-300.000/-100.000/0.000/0.000/0.000/1.000 | 1.64 |  | __ISO | 0.05 | 0,041 W/m.K | NEMSOK - K_POSITION: L.7; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 2.240 m2
2010456056x50501601x9016xxxx | Půdorys 1.PP | Kus | 0.718 | 2010456056x50501601x9016xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/160.0000/1/717.9000/0/0/0/0/0/1.0000/560.0000/160.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/160.00/717.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 560 | 160 | 560 | 0.000 | 0 | 1.030 m2 | IT.02.30013 | B | 6774Obj0000026929 | Objekt | 717.900/300.000/100.000/0.000/-300.000/-100.000/0.000/0.000/0.000/1.000 | 1.03 | 718 | __ISO | 0.05 | 0,041 W/m.K | NEMSOK - K_POSITION: L.6; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.320 m2
10105560160718xxxxxx0 | Půdorys 1.PP | Kus | 0 | 10105560160718xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/270.0/560.0000/560.0000/160.0000/1/230.0000/230.0000/0/90.0/0/270.0/1.0000/560.0000/160.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/560.00/100.00/90.00/270.00/0/560.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 560 | 160 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30014 | B | 6774Obj0000027011 | Objekt | 330.000/230.000/300.000/0.000/-100.000/-300.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.05 | 0,041 W/m.K | NEMSOK - K_POSITION: L.7; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.080 m2
2010516016x50505601x9056xxxx | Půdorys 1.PP | Kus | 0.299 | 2010516016x50505601x9056xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/160.0000/1/299.3000/0/0/0/0/0/1.0000/560.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/160.00/299.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 560 | 160 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30015 | B | 6774Obj0000027025 | Objekt | 299.300/300.000/100.000/0.000/-300.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 299 | __ISO | 0.05 | 0,041 W/m.K | NEMSOK - K_POSITION: L.5; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
10104560160299xxxxxx0 | Půdorys 1.PP | Kus | 0.369 | 10104560160299xxxxxx0 | UEBERGANG ASYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/450.0000/315.0000/1/368.5000/0/77.5000/0/0/0/0/560.0000/160.0000/1/ | 41/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/560.00/50.00/50.00/315.00/160.00/0/368.50/55.00/55.00/0/-155.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x315 | 560 | 160 | 450 | 0.000 | 0 | 1.000 m2 | IT.02.30016 | B | 6774Obj0000027047 | Objekt | 368.500/300.000/177.500/0.000/-300.000/-177.500/0.000/0.000/0.000/1.000 | 1 | 369 | __ISO | 0.05 | 0,041 W/m.K | NEMSOK - K_POSITION: L.11; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 315; K_LISTVALUE_ISO: 1.000 m2
41104450560505031516x36955550-15 | Půdorys 1.PP | Kus | 0.369 | 41104450560505031516x36955550-15 | UEBERGANG ASYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/160.0000/1/368.5000/0/-77.5000/0/0/0/0/560.0000/315.0000/1/ | 41/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/50.00/50.00/160.00/315.00/0/368.50/0/0/0/155.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 560 | 315 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30017 | B | 6774Obj0000027069 | Objekt | 368.500/300.000/100.000/0.000/-300.000/-255.000/0.000/0.000/0.000/1.000 | 1 | 369 | __ISO | 0.05 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
4110556056050501603150369x01553x | Půdorys 1.PP | Kus | 0 | 4110556056050501603150369x01553x | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/560.0000/560.0000/160.0000/1/238.1272/46.0716/0/21.9/0/0/1.0000/560.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/0/50.00/50.00/160.00/100.00/21.90/0/1.00/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 560 | 160 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30018 | B | 6774Obj0000027151 | Objekt | 350.024/324.422/100.000/0.000/-300.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.05 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
2010456056x50501601x2216xxxx | Půdorys 1.PP | Kus | 0.785 | 2010456056x50501601x2216xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/160.0000/1/785.4504/0/0/0/0/0/1.0000/560.0000/160.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/160.00/785.45/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 560 | 160 | 560 | 0.000 | 0 | 1.130 m2 | IT.02.30019 | B | 6774Obj0000027165 | Objekt | 785.450/300.000/100.000/0.000/-300.000/-100.000/0.000/0.000/0.000/1.000 | 1.13 | 785 | __ISO | 0.05 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.440 m2
10105560160785xxxxxx0 | Půdorys 1.PP | Kus | 0 | 10105560160785xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/180.0/560.0000/560.0000/160.0000/1/238.1272/46.0716/0/21.9/0/180.0/1.0000/560.0000/160.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/0/50.00/50.00/160.00/100.00/21.90/180.00/1.00/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 560 | 160 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30020 | B | 6774Obj0000027247 | Objekt | 350.024/324.422/100.000/0.000/-300.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.05 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
2010556056x50501601x2216xxxx | Půdorys 1.PP | Kus | 0.019 | 2010556056x50501601x2216xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/160.0000/1/19.1025/0/0/0/0/0/1.0000/560.0000/160.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/160.00/19.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 560 | 160 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30021 | B | 6774Obj0000027261 | Objekt | 20.000/300.000/100.000/-0.898/-300.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 19 | __ISO | 0.05 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
 | Půdorys 1.PP | Kus | 0 |  | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/560.0000/560.0000/160.0000/1/430.0000/430.0000/0/90.0/0/0/1.0000/560.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/0/50.00/50.00/160.00/100.00/90.00/0/1.00/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 560 | 160 | 560 | 0.000 | 0 | 1.640 m2 | IT.02.30022 | B | 6774Obj0000027371 | Objekt | 730.000/430.000/100.000/0.000/-300.000/-100.000/0.000/0.000/0.000/1.000 | 1.64 |  | __ISO | 0.05 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 2.240 m2
2010456056x50501601x9016xxxx | Půdorys 1.PP | Kus | 0 | 2010456056x50501601x9016xxxx | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/560.0000/560.0000/160.0000/1/430.0000/430.0000/0/90.0/0/0/1.0000/560.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/0/50.00/50.00/160.00/100.00/90.00/0/1.00/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 560 | 160 | 560 | 0.000 | 0 | 1.640 m2 | IT.02.30023 | B | 6774Obj0000027453 | Objekt | 730.000/430.000/100.000/0.000/-300.000/-100.000/0.000/0.000/0.000/1.000 | 1.64 |  | __ISO | 0.05 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 2.240 m2
2010456056x50501601x9016xxxx | Půdorys 1.PP | Kus | 0.186 | 2010456056x50501601x9016xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/160.0000/1/186.0000/0/0/0/0/0/1.0000/560.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/160.00/186.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 560 | 160 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30024 | B | 6774Obj0000027467 | Objekt | 186.000/300.000/100.000/0.000/-300.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 186 | __ISO | 0.05 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
10104560160186xxxxxx0 | Půdorys 1.PP | Kus | 0 | 10104560160186xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/180.0/560.0000/560.0000/160.0000/1/430.0000/430.0000/0/90.0/0/180.0/1.0000/560.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/0/50.00/50.00/160.00/100.00/90.00/180.00/1.00/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 560 | 160 | 560 | 0.000 | 0 | 1.640 m2 | IT.02.30025 | B | 6774Obj0000027549 | Objekt | 730.000/430.000/100.000/0.000/-300.000/-100.000/0.000/0.000/0.000/1.000 | 1.64 |  | __ISO | 0.05 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 2.240 m2
2010456056x50501601x9016xxxx | Půdorys 1.PP | Kus | 0.34 | 2010456056x50501601x9016xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/160.0000/1/340.0000/0/0/0/0/0/1.0000/560.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/160.00/340.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 560 | 160 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30026 | B | 6774Obj0000027563 | Objekt | 340.000/300.000/100.000/0.000/-300.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 340 | __ISO | 0.05 | 0,041 W/m.K | NEMSOK - K_POSITION: L.12; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
1010456016034xxxxxxx | Půdorys 1.PP | Kus | 0.304 | 1010456016034xxxxxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/450.0000/315.0000/1/303.5000/0/0/0/0/0/1.0000/450.0000/315.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/315.00/303.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x315 | 450 | 315 | 450 | 0.000 | 0 | 1.000 m2 | IT.02.30027 | B | 6774Obj0000027577 | Objekt | 303.500/245.000/177.500/0.000/-245.000/-177.500/0.000/0.000/0.000/1.000 | 1 | 304 | __ISO | 0.05 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 315
macro | Půdorys 1.PP | Kus | 1.25 | macro | Schalldämpfer | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/-1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/710.00/200.00/1250.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 |  | 710x200 | 1 | 1 | 1 | 0.000 | 0 |  | IT.02.30028 | B | 6774Obj0000050102 | Objekt | 22414.000/12504.971/-408.000/21704.000/11254.971/-608.000/0.000/0.000/0.000/1.000 | 0 | 1250 | __ISO | 0.05 | 0,041 W/m.K | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1; K_DWGNAME: ${PROD}l\einbauteile\schalldaempfer\; K_DP_EBT: 0.00; K_DATE: 2023/01/17; N_FREI_68: Blech ST37 verzinkt
1x01047102x125xxxxxxx | Půdorys 1.PP | Kus | 0.36 | 1x01047102x125xxxxxxx | UEBERGANG ASYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/710.0000/200.0000/1/359.8000/75.0000/20.0000/0/0/0/0/560.0000/160.0000/1/ | 41/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/710.00/560.00/50.00/50.00/200.00/160.00/0/359.80/-150.00/0/0/-40.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 710x200 | 560 | 160 | 710 | 0.000 | 0 | 1.000 m2 | IT.02.30029 | B | 6774Obj0000050124 | Objekt | 359.800/375.000/120.000/0.000/-375.000/-120.000/0.000/0.000/0.000/1.000 | 1 | 360 | __ISO | 0.05 | 0,041 W/m.K | NEMSOK - K_POSITION: L.9; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200
4110471056050502x16x360-15x0-403 | Půdorys 1.PP | Kus | 0.712 | 4110471056050502x16x360-15x0-403 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/160.0000/1/712.3000/0/0/0/0/0/1.0000/560.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/160.00/712.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 560 | 160 | 560 | 0.000 | 0 | 1.030 m2 | IT.02.30030 | B | 6774Obj0000050138 | Objekt | 712.300/300.000/100.000/0.000/-300.000/-100.000/0.000/0.000/0.000/1.000 | 1.03 | 712 | __ISO | 0.05 | 0,041 W/m.K | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160
10104560160712xxxxxx0 | Půdorys 1.PP | Kus | 0.36 | 10104560160712xxxxxx0 | UEBERGANG ASYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/560.0000/560.0000/160.0000/1/359.8000/-75.0000/-20.0000/0/0/0/0/710.0000/200.0000/1/ | 41/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/710.00/50.00/50.00/160.00/200.00/0/359.80/150.00/0/0/40.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 710 | 200 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30031 | B | 6774Obj0000050160 | Objekt | 359.800/300.000/100.000/0.000/-450.000/-140.000/0.000/0.000/0.000/1.000 | 1 | 360 | __ISO | 0.05 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160
4110456071050501602x036015x0403x | Půdorys 1.PP | Kus | 0.11 | 4110456071050501602x036015x0403x | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/560.0000/160.0000/1/110.2000/0/0/0/0/0/1.0000/560.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/160.00/110.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 560 | 160 | 560 | 0.000 | 0 | 1.000 m2 | IT.02.30032 | B | 6774Obj0000050174 | Objekt | 110.200/300.000/100.000/0.000/-300.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 110 | __ISO | 0.05 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160
macro | Půdorys 1.PP | Kus | 1.25 | macro | Schalldämpfer | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/-1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/710.00/250.00/1250.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 710x250 | 1 | 1 | 1 | 0.000 | 0 |  | IT.02.30033 | B | 6774Obj0000050242 | Objekt | 30364.294/8940.000/-408.000/29654.294/7690.000/-658.000/0.000/0.000/0.000/1.000 | 0 | 1250 | __ISO | 0.05 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1; K_LISTVALUE_ISO: 2.400 m2; K_DWGNAME: ${PROD}l\einbauteile\schalldaempfer\; K_DP_EBT: 0.00; K_DATE: 2023/01/17; N_FREI_68: Blech ST37 verzinkt
 | Půdorys 1.PP | Kus | 0.125 |  | UEBERGANG ASYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/710.0000/250.0000/1/125.0000/0/45.0000/0/0/0/0/560.0000/160.0000/1/ | 41/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/710.00/560.00/50.00/50.00/250.00/160.00/0/125.00/-75.00/-75.00/0/-90.00/74.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 710x250 | 560 | 160 | 710 | 0.000 | 0 | 1.000 m2 | IT.02.30034 | B | 6774Obj0000050264 | Objekt | 125.000/375.000/145.000/0.000/-375.000/-145.000/0.000/0.000/0.000/1.000 | 1 | 125 | __ISO | 0.05 | 0,041 W/m.K | NEMSOK - K_POSITION: L.7; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 250
41104710560505025016x125-75-750- | Půdorys 1.PP | Kus | 0.125 | 41104710560505025016x125-75-750- | UEBERGANG ASYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/710.0000/250.0000/1/125.0000/0/45.0000/0/0/0/0/560.0000/160.0000/1/ | 41/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/710.00/560.00/50.00/50.00/250.00/160.00/0/125.00/-75.00/-75.00/0/-90.00/74.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 710x250 | 560 | 160 | 710 | 0.000 | 0 | 1.000 m2 | IT.02.30035 | B | 6774Obj0000050286 | Objekt | 125.000/375.000/145.000/0.000/-375.000/-145.000/0.000/0.000/0.000/1.000 | 1 | 125 | __ISO | 0.05 | 0,041 W/m.K | NEMSOK - K_POSITION: L.10; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 250
252x125012513xxxxxx | Půdorys 1.PP | Kus | 0.012 | 252x125012513xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/11.5124/125.0000/125.0000/2/11.5124/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/11.51/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.011 m | IT.02.30036 | A1 | 6774Obj0000040628 | Objekt | 11.512/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 0.011 | 12 | __ISO | 0.04 | 0,041 W/m.K
 | Půdorys 1.PP | Kus | 0 |  | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.3/125.0000/125.0000/125.0000/2/108.2532/62.5000/0/60.0/0/180.3/125.0000/125.0000/125.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.30/0/125.00/1.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | IT.02.30037 | A1 | 6774Obj0000040634 | Objekt | 162.380/93.750/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x125012516xxxxxx | Půdorys 1.PP | Kus | 2.526 | 252x125012516xxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/2526.0000/125.0000/125.0000/2/2526.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/2526.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 2.526 m | IT.02.30038 | A1 | 6774Obj0000040637 | Objekt | 2526.000/62.500/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | 2.526 | 2526 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_LISTVALUE_ISO: 1.627 m2
macro | Půdorys 1.PP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.02.30039 | A1 | 6774Obj0000040651 | Objekt | 13524.798/3636.049/-410.500/13193.830/3372.796/-535.500/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2022/11/04; N_FREI_68: SPIRO POTRUBÍ
 | Půdorys 1.PP | Kus | 0.74 |  | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/200.0000/160.0000/1/740.0000/0/0/0/0/0/1.0000/200.0000/160.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/160.00/740.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x160 | 200 | 160 | 200 | 0.000 | 0 | 1.000 m2 | IT.02.30040 | A1 | 6774Obj0000040679 | Objekt | 740.000/120.000/100.000/0.000/-120.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 740 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
macro | Půdorys 1.PP | Kus | 0.26 | macro | ABL Regler konst. EN mit Antrieb | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/0/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/200.00/160.00/260.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 |  | 200x160 | 1 | 1 | 1 | 0.000 | 0 |  | IT.02.30041 | A1 | 6774Obj0000040693 | Objekt | 14992.450/13192.674/-400.000/14792.450/12932.674/-560.000/0.000/0.000/0.000/1.000 | 0 | 260 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1; K_LISTVALUE_ISO: 0.270 m2; K_DWGNAME: ${PROD}l\einbauteile\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2022/11/04; N_FREI_68: Blech ST37 verzinkt
252x125012519xxxxxx | Půdorys 1.PP | Kus | 0.05 | 252x125012519xxxxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/450.0000/710.0000/1/50.0000/0/0/0/0/0/1.0000/450.0000/710.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/710.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x710 | 450 | 710 | 450 | 0.000 | 0 | 1.000 m2 | IT.02.30042 | A1 | 6774Obj0000040710 | Objekt | 50.000/245.000/375.000/0.000/-245.000/-375.000/0.000/0.000/0.000/1.000 | 1 | 50 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 710; K_LISTVALUE_ISO: 1.000 m2
101044507105xxxxxxx | Půdorys 1.PP | Kus | 0.14 | 101044507105xxxxxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/450.0000/710.0000/1/140.2000/0/0/0/0/0/1.0000/450.0000/710.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/710.00/140.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x710 | 450 | 710 | 450 | 0.000 | 0 | 1.000 m2 | IT.02.30043 | A1 | 6774Obj0000040724 | Objekt | 140.200/245.000/375.000/0.000/-245.000/-375.000/0.000/0.000/0.000/1.000 | 1 | 140 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 710; K_LISTVALUE_ISO: 1.000 m2
1010531516035xxxxxxx | Půdorys 1.PP | Kus | 1.5 | 1010531516035xxxxxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/1500.0000/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.420 m2 | IT.02.30044 | A1 | 6774Obj0000040752 | Objekt | 1500.000/177.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1.42 | 1500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.24; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.910 m2
1010431516015xxxxxxx0 | Půdorys 1.PP | Kus | 0.46 | 1010431516015xxxxxxx0 | T-STCK. SCHRÄG | 20 | 1016 | 3/0/0/0/180.0/0/0/250.0000/250.0000/160.0000/1/460.0000/-32.5000/0/0/0/0/1.0000/315.0000/160.0000/1/230.0000/275.0000/0/90.0/0/0/160.0000/160.0000/160.0000/1/ | 71/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/315.00/160.00/160.00/50.00/50.00/50.00/50.00/160.00/0/0/0/460.00/-65.00/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x160 | 315 | 160 | 250 | 0.000 | 0 | 1.000 m2 | IT.02.30045 | A1 | 6774Obj0000040836 | Objekt | 460.000/275.000/100.000/0.000/-210.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 460 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.17; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
711042503151601605050505016x0460 | Půdorys 1.PP | Kus | 0.165 | 711042503151601605050505016x0460 | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/165.3000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/35.00/100.00/160.00/125.00/125.00/165.30/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 125 | 125 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30046 | A1 | 6774Obj0000040858 | Objekt | 165.300/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 165 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.7; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
50105160125351x160125125165-18-1 | Půdorys 1.PP | Kus | 0 | 50105160125351x160125125165-18-1 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/180.0/315.0000/315.0000/160.0000/1/307.5000/307.5000/0/90.0/0/180.0/1.0000/315.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/0/50.00/50.00/160.00/100.00/90.00/180.00/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.02.30047 | A1 | 6774Obj0000040940 | Objekt | 485.000/307.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.19; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.030 m2
20104315315050501601x9016xxxx | Půdorys 1.PP | Kus | 0.486 | 20104315315050501601x9016xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/250.0000/160.0000/1/486.4000/0/0/0/0/0/1.0000/250.0000/160.0000/1/ | 10/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/160.00/486.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x160 | 250 | 160 | 250 | 0.000 | 0 | 1.000 m2 | IT.02.30048 | A1 | 6774Obj0000040954 | Objekt | 486.400/145.000/100.000/0.000/-145.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 486 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.26; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
10106250160486xxxxxx0 | Půdorys 1.PP | Kus | 0 | 10106250160486xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/180.0/315.0000/315.0000/160.0000/1/307.5000/307.5000/0/90.0/0/180.0/0/315.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/0/50.00/50.00/160.00/100.00/90.00/180.00/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.02.30049 | A1 | 6774Obj0000041036 | Objekt | 485.000/307.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.28; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.030 m2
20104315315050501601x9016xxxx | Půdorys 1.PP | Kus | 0 | 20104315315050501601x9016xxxx | BOGEN ASY. | 20 | 1016 | 2/0/0/0/180.0/0/90.0/450.0000/450.0000/710.0000/1/307.5000/505.0000/0/90.0/0/90.0/0/450.0000/315.0000/1/ | 21/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/710.00/315.00/0/50.00/50.00/450.00/100.00/90.00/90.00/1.00/450.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x710 | 450 | 315 | 450 | 0.000 | 0 | 3.180 m2 | IT.02.30050 | A1 | 6774Obj0000041118 | Objekt | 485.000/505.000/245.000/0.000/-375.000/-245.000/0.000/0.000/0.000/1.000 | 3.18 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 710; K_LISTVALUE_ISO: 3.790 m2
21104710315050504501x9045xxxx | Půdorys 1.PP | Kus | 0.809 | 21104710315050504501x9045xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/450.0000/710.0000/1/809.1000/0/0/0/0/0/1.0000/450.0000/710.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/710.00/809.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x710 | 450 | 710 | 450 | 0.000 | 0 | 1.880 m2 | IT.02.30051 | A1 | 6774Obj0000041132 | Objekt | 809.100/245.000/375.000/0.000/-245.000/-375.000/0.000/0.000/0.000/1.000 | 1.88 | 809 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.5; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 710; K_LISTVALUE_ISO: 2.140 m2
10104450710809xxxxxx0 | Půdorys 1.PP | Kus | 0.464 | 10104450710809xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/464.3000/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/464.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.02.30052 | A1 | 6774Obj0000041146 | Objekt | 464.300/177.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1 | 464 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.9; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
10104315160219xxxxxx0 | Půdorys 1.PP | Kus | 0 | 10104315160219xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/180.0/200.0000/200.0000/160.0000/1/250.0000/250.0000/0/90.0/0/180.0/1.0000/200.0000/160.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/0/50.00/50.00/160.00/100.00/90.00/180.00/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x160 | 200 | 160 | 200 | 0.000 | 0 | 1.000 m2 | IT.02.30053 | A1 | 6774Obj0000041458 | Objekt | 370.000/250.000/100.000/0.000/-120.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
201052x2x050501601x9016xxxx | Půdorys 1.PP | Kus | 0.58 | 201052x2x050501601x9016xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/200.0000/160.0000/1/580.0000/0/0/0/0/0/1.0000/200.0000/160.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/160.00/580.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x160 | 200 | 160 | 200 | 0.000 | 0 | 1.000 m2 | IT.02.30054 | A1 | 6774Obj0000041472 | Objekt | 580.000/120.000/100.000/0.000/-120.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 580 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
101052x16058xxxxxxx | Půdorys 1.PP | Kus | 0.74 | 101052x16058xxxxxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/200.0000/160.0000/1/740.0000/0/0/0/0/0/1.0000/200.0000/160.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/160.00/740.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x160 | 200 | 160 | 200 | 0.000 | 0 | 1.000 m2 | IT.02.30055 | A1 | 6774Obj0000041486 | Objekt | 740.000/120.000/100.000/0.000/-120.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 740 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
macro | Půdorys 1.PP | Kus | 0.26 | macro | ABL Regler konst. EN mit Antrieb | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/0/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/200.00/160.00/260.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 |  | 200x160 | 1 | 1 | 1 | 0.000 | 0 |  | IT.02.30056 | A1 | 6774Obj0000041500 | Objekt | 16142.263/13192.674/-400.000/15942.263/12932.674/-560.000/0.000/0.000/0.000/1.000 | 0 | 260 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1; K_LISTVALUE_ISO: 0.270 m2; K_DWGNAME: ${PROD}l\einbauteile\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2022/11/04; N_FREI_68: Blech ST37 verzinkt
1x01052x16026xxxxxxx | Půdorys 1.PP | Kus | 0 | 1x01052x16026xxxxxxx | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/200.0000/200.0000/160.0000/1/250.0000/250.0000/0/90.0/0/0/1.0000/200.0000/160.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/0/50.00/50.00/160.00/100.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x160 | 200 | 160 | 200 | 0.000 | 0 | 1.000 m2 | IT.02.30057 | A1 | 6774Obj0000041582 | Objekt | 370.000/250.000/100.000/0.000/-120.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
macro | Půdorys 1.PP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.02.30058 | A1 | 6774Obj0000041596 | Objekt | 3132.467/2870.371/-417.500/3007.467/2560.371/-542.500/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2022/11/04; N_FREI_68: SPIRO POTRUBÍ
 | Půdorys 1.PP | Kus | 1.198 |  | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/1198.2754/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/1198.28/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 0.770 m2 | IT.02.30059 | A1 | 6774Obj0000041610 | Objekt | 1198.275/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.77 | 1198 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.150 m2
 | Půdorys 1.PP | Kus | 1.198 |  | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/1198.1659/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/1198.17/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 0.770 m2 | IT.02.30060 | A1 | 6774Obj0000041624 | Objekt | 1198.166/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.77 | 1198 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.150 m2
 | Půdorys 1.PP | Kus | 0.557 |  | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/556.7000/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/556.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30061 | A1 | 6774Obj0000041638 | Objekt | 556.700/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 557 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.8; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
10104160160557xxxxxx0 | Půdorys 1.PP | Kus | 0.5 | 10104160160557xxxxxx0 | T-STCK. SCHRÄG | 20 | 1016 | 3/0/0/0/180.0/0/0/315.0000/315.0000/160.0000/1/500.0000/32.5000/0/0/0/0/1.0000/250.0000/160.0000/1/250.0000/307.5000/0/90.0/0/0/200.0000/200.0000/160.0000/1/ | 71/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/250.00/200.00/200.00/50.00/50.00/50.00/50.00/160.00/0/0/0/500.00/65.00/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 250 | 160 | 315 | 0.000 | 0 | 1.000 m2 | IT.02.30062 | A1 | 6774Obj0000041694 | Objekt | 500.000/307.500/100.000/0.000/-177.500/-100.000/0.000/0.000/0.000/1.000 | 1 | 500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
711043152502x2x5050505016x05x651 | Půdorys 1.PP | Kus | 0.65 | 711043152502x2x5050505016x05x651 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/250.0000/160.0000/1/649.8000/0/0/0/0/0/1.0000/250.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/160.00/649.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x160 | 250 | 160 | 250 | 0.000 | 0 | 1.000 m2 | IT.02.30063 | A1 | 6774Obj0000041708 | Objekt | 649.800/145.000/100.000/0.000/-145.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 650 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
1010425016065xxxxxxx | Půdorys 1.PP | Kus | 0.5 | 1010425016065xxxxxxx | T-STCK. SCHRÄG | 20 | 1016 | 3/0/0/0/180.0/0/0/250.0000/250.0000/160.0000/1/500.0000/45.0000/0/0/0/0/1.0000/160.0000/160.0000/1/250.0000/275.0000/0/90.0/0/0/200.0000/200.0000/160.0000/1/ | 71/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/160.00/200.00/200.00/50.00/50.00/50.00/50.00/160.00/0/0/0/500.00/90.00/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x160 | 160 | 160 | 250 | 0.000 | 0 | 1.000 m2 | IT.02.30064 | A1 | 6774Obj0000041764 | Objekt | 500.000/275.000/100.000/0.000/-145.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 500 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
711042501602x2x5050505016x05x901 | Půdorys 1.PP | Kus | 0.165 | 711042501602x2x5050505016x05x901 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/200.0000/160.0000/1/164.7000/0/0/0/0/0/1.0000/200.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/160.00/164.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x160 | 200 | 160 | 200 | 0.000 | 0 | 1.000 m2 | IT.02.30065 | A1 | 6774Obj0000041778 | Objekt | 164.700/120.000/100.000/0.000/-120.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 165 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.15; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
101042x160165xxxxxx0 | Půdorys 1.PP | Kus | 0.165 | 101042x160165xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/200.0000/160.0000/1/164.7000/0/0/0/0/0/1.0000/200.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/160.00/164.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x160 | 200 | 160 | 200 | 0.000 | 0 | 1.000 m2 | IT.02.30066 | A1 | 6774Obj0000041792 | Objekt | 164.700/120.000/100.000/0.000/-120.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 165 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.16; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
101042x160165xxxxxx0 | Půdorys 1.PP | Kus | 0.204 | 101042x160165xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/203.8943/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/203.89/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30067 | A1 | 6774Obj0000041806 | Objekt | 203.894/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 204 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
10104160160204xxxxxx0 | Půdorys 1.PP | Kus | 0 | 10104160160204xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/180.0/160.0000/160.0000/160.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/180.00/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | IT.02.30068 | A1 | 6774Obj0000041809 | Objekt | 240.000/160.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x16x16019xxxxxx | Půdorys 1.PP | Kus | 0.46 | 252x16x16019xxxxxx | T-STCK. GERADE | 20 | 1016 | 3/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/1/460.0000/0/0/0/0/180.0/1.0000/160.0000/160.0000/1/230.0000/230.0000/0/90.0/0/180.0/160.0000/160.0000/160.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/160.00/160.00/50.00/50.00/50.00/50.00/160.00/0/0/180.00/460.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30069 | A1 | 6774Obj0000041865 | Objekt | 460.000/230.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 460 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
701041601601601605050505016x046x | Půdorys 1.PP | Kus | 0.165 | 701041601601601605050505016x046x | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/1/165.3000/0/0/0/0/0/0/125.0000/125.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/35.00/100.00/160.00/125.00/125.00/165.30/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 125 | 125 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30070 | A1 | 6774Obj0000041887 | Objekt | 165.300/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 165 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
macro | Půdorys 1.PP | Kus | 0.31 | macro | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/0/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/125.00/125.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 |  | DN125 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.02.30071 | A1 | 6774Obj0000041901 | Objekt | 9304.740/12028.243/-418.564/9179.738/11718.240/-543.571/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2022/11/07; N_FREI_68: SPIRO POTRUBÍ
 | Půdorys 1.PP | Kus | 0.135 |  | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/135.0000/0/0/0/0/0/0/160.0000/120.0000/1/ | 50/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/160.00/160.00/35.00/100.00/160.00/120.00/160.00/135.00/0/0/-20.00/-20.00/53.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 120 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30072 | A1 | 6774Obj0000041923 | Objekt | 135.000/80.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | 1 | 135 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.23; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); K_LISTVALUE_ISO: 1.000 m2
50216160160351x160120160135x-20- | Půdorys 1.PP | Kus | 0.327 | 50216160160351x160120160135x-20- | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/327.3654/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/327.37/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30073 | A1 | 6774Obj0000041937 | Objekt | 327.365/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 327 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
10104160160327xxxxxx0 | Půdorys 1.PP | Kus | 0 | 10104160160327xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/1/212.6346/88.0761/0/45.0/0/180.0/1.0000/160.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/160.00/100.00/45.00/180.00/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30074 | A1 | 6774Obj0000042019 | Objekt | 283.345/158.787/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
2010416016x50501601x4516xxxx | Půdorys 1.PP | Kus | 0 | 2010416016x50501601x4516xxxx | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/1/212.6346/88.0761/0/45.0/0/0/1.0000/160.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/160.00/100.00/45.00/0/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30075 | A1 | 6774Obj0000042101 | Objekt | 283.345/158.787/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
2010416016x50501601x4516xxxx | Půdorys 1.PP | Kus | 0.767 | 2010416016x50501601x4516xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/766.6870/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/766.69/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30076 | A1 | 6774Obj0000042115 | Objekt | 766.687/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 767 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
10104160160767xxxxxx0 | Půdorys 1.PP | Kus | 0 | 10104160160767xxxxxx0 | BOGEN SYM. | 20 | 1016 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/1/212.6346/88.0761/0/45.0/0/0/1.0000/160.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/160.00/100.00/45.00/0/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30077 | A1 | 6774Obj0000042197 | Objekt | 283.345/158.787/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
2010416016x50501601x4516xxxx | Půdorys 1.PP | Kus | 0.579 | 2010416016x50501601x4516xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/578.5961/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/578.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | IT.02.30078 | A1 | 6774Obj0000042211 | Objekt | 578.596/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 | 579 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2
