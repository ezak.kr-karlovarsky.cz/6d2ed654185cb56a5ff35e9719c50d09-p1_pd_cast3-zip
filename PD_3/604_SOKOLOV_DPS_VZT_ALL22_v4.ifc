Properties of the parts of a building model (IFC2X3), part 50 of 51

# IfcFlowSegment (1090)
Name | In | Jednotka | Délka (m) | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_LAENGE | L_BES_DIM | L_BES_DIM_A2 = L_BES_DIM_A | L_BES_DIM_B2 | K_VOLSTROM | K_LISTVALUE | Kód prvku | Podlaží | Průměr | Teplonosná látka | Allright_Stavebni_dil_ID | Název_objektu | Označení | K_LISTVALUE_ISO
152042502501xxxxxxx0 | Půdorys střechy | m | 0.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 100 | DN250 | 250 | 250 | 0.000 | 0.100 m | PO.08.30001 | Nadzemní podlaží 6.NP | 250 mm | - | 6882Obj0000000065 | Objekt | 152042502501xxxxxxx0 | 0.141 m2
152042502501xxxxxxx0 | Půdorys střechy | m | 0.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 100 | DN250 | 250 | 250 | 0.000 | 0.100 m | PO.08.30002 | Nadzemní podlaží 6.NP | 250 mm | - | 6882Obj0000000066 | Objekt | 152042502501xxxxxxx0 | 0.141 m2
152042502501xxxxxxx0 | Půdorys střechy | m | 0.1 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 100 | DN250 | 250 | 250 | 0.000 | 0.100 m | PO.08.30003 | Nadzemní podlaží 6.NP | 250 mm | - | 6882Obj0000000067 | Objekt | 152042502501xxxxxxx0 | 0.141 m2
1520425025094xxxxxxx | Půdorys střechy | m | 0.94 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/940.0000/250.0000/250.0000/2/940.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/940.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 940 | DN250 | 250 | 250 | 0.000 | 0.940 m | PO.08.30004 | Nadzemní podlaží 6.NP | 250 mm | - | 6882Obj0000000069 | Objekt | 1520425025094xxxxxxx | 1.329 m2
1520425025094xxxxxxx | Půdorys střechy | m | 0.94 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/940.0000/250.0000/250.0000/2/940.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/940.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 940 | DN250 | 250 | 250 | 0.000 | 0.940 m | PO.08.30005 | Nadzemní podlaží 6.NP | 250 mm | - | 6882Obj0000000070 | Objekt | 1520425025094xxxxxxx | 1.329 m2
1520425025094xxxxxxx | Půdorys střechy | m | 0.94 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/940.0000/250.0000/250.0000/2/940.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/940.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 940 | DN250 | 250 | 250 | 0.000 | 0.940 m | PO.08.30006 | Nadzemní podlaží 6.NP | 250 mm | - | 6882Obj0000000071 | Objekt | 1520425025094xxxxxxx | 1.329 m2

# IfcFlowTerminal (86)
NEMSOK - V6: 0 m; V7: 0 m; V8: 0 m; V9: 0; K_GEWERK: 1
Name | In | Délka (m) | Název_objektu | Označení = K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_POSITION | K_DWGNAME | K_MATERIAL | K_ISOLATION | L_BES_DIM_A = L_BES_DIM_B | K_DP_EBT | K_VOLSTROM | K_DATE | N_FREI_68 | Kód prvku | Podlaží | Číslo místnosti | Šířka (m) | Výška (m) | Průměr | Jmenovitá velikost vstupu | Třída reakce na oheň | Průtok | Rychlost | Allright_Stavebni_dil_ID | Jednotka | K_NORM | K_PROFIL | L_BES_LAENGE | L_BES_DIM | L_BES_DIM_A2 = L_BES_DIM_B2 | K_MLH_GOST = K_MLD_GOST
Ablufttellerventil LVS | Půdorys 1.PP | 0 | Talířový ventil | Ablufttellerventil LVS | 120 | 1001 | 1/0/0/0/180.0/0/0/0/0/0/-1/ | 1001/30/-1/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/28.00/100.00/100.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/ | - | \\machn\allplan\v2018\std\prod\ess\l\auslaesse\lüftungsventile\ | Mat_12 | Blech ummantelt/40.00 | 100 | 0.000 | 120.00 | ? | Mat_12 | VV.02.30009 | Podzemní podlaží 1.PP | 1.01 | 0.114 | 0.05 | 114 mm | 100 mm | A1 | 200 m3/hod | 1,3 m/s | 6772BP_0000000589 | Kus | NEMSOK - Index kóty: 0; K_LVZNR: K_LVZNR; K_Z_KOORD: M.2; A_ZETA_EBT: 0.00; L_LP_AIR_TYPE: 1; L_FREI_24: 0|0|0|0|0||; K_SYSTEMTYPE: 1; K_VD_TYPE: LP; K_MAXDELTAP: 0.000; K_DELTAP: 0.000; K_ZETA: 0.000; K_RWERT: 0.000; K_VD_DG: 0.000; K_VD_DN: 0.000; K_VD_DI: 0.000; K_VD_DA: 0.000; K_VD_A: 0.000; K_VD_B: 0.000; K_VD_QFORM: -1|0|2||0|; K_VD_ADN: 0.000; K_VD_BDN: 0.000; K_VD_V: 0.000; K_VD_R: 0.000; E_FREI_39: 1|30.00|20.00|0.000000|0.000000|-1; K_LISTVALUE: 1.0; N_FREI_62: 0; N_FREI_75: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;"""; N_FREI_76: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""; N_FREI_77: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""
Ablufttellerventil LVS | Půdorys 1.PP | 0 | Talířový ventil | Ablufttellerventil LVS | 120 | 1001 | 1/0/0/0/180.0/0/0/125.0000/0/125.0000/-1/ | 1001/30/-1/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/28.00/125.00/125.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/ | - | \\machn\allplan\v2018\std\prod\ess\l\auslaesse\lüftungsventile\ | Mat_12 |  | 125 | 0.000 | 120.00 | ? | Mat_12 | VV.02.30010 | Podzemní podlaží 1.PP | 1.01 | 0.164 | 0.05 | 164 mm | 125 mm | A1 | 200 m3/hod | 1,3 m/s | 6772BP_0000000590 | Kus | NEMSOK - Index kóty: 0; K_LVZNR: K_LVZNR; K_Z_KOORD: M.2; A_ZETA_EBT: 0.00; L_LP_AIR_TYPE: 1; L_FREI_24: 0|0|0|0|0||; K_SYSTEMTYPE: 1; K_VD_TYPE: LP; K_MAXDELTAP: 0.000; K_DELTAP: 0.000; K_ZETA: 0.000; K_RWERT: 0.000; K_VD_DG: 0.000; K_VD_DN: 0.000; K_VD_DI: 0.000; K_VD_DA: 0.000; K_VD_A: 0.000; K_VD_B: 0.000; K_VD_QFORM: -1|0|2||0|; K_VD_ADN: 125.000; K_VD_BDN: 0.000; K_VD_V: 0.000; K_VD_R: 0.000; E_FREI_39: 1|30.00|20.00|0.000000|0.000000|-1; K_LISTVALUE: 1.0; N_FREI_62: 0; N_FREI_75: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;"""; N_FREI_76: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""; N_FREI_77: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""
Ablufttellerventil LVS | Půdorys 1.PP | 0 | Talířový ventil | Ablufttellerventil LVS | 120 | 1001 | 1/0/0/0/180.0/0/0/125.0000/0/125.0000/-1/ | 1001/30/-1/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/28.00/125.00/125.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/ | - | \\machn\allplan\v2018\std\prod\ess\l\auslaesse\lüftungsventile\ | Mat_12 |  | 125 | 0.000 | 120.00 | ? | Mat_12 | VV.02.30011 | Podzemní podlaží 1.PP | 1.01 | 0.164 | 0.05 | 164 mm | 125 mm | A1 | 200 m3/hod | 1,3 m/s | 6772BP_0000000592 | Kus | NEMSOK - Index kóty: 0; K_LVZNR: K_LVZNR; K_Z_KOORD: M.2; A_ZETA_EBT: 0.00; L_LP_AIR_TYPE: 1; L_FREI_24: 0|0|0|0|0||; K_SYSTEMTYPE: 1; K_VD_TYPE: LP; K_MAXDELTAP: 0.000; K_DELTAP: 0.000; K_ZETA: 0.000; K_RWERT: 0.000; K_VD_DG: 0.000; K_VD_DN: 0.000; K_VD_DI: 0.000; K_VD_DA: 0.000; K_VD_A: 0.000; K_VD_B: 0.000; K_VD_QFORM: -1|0|2||0|; K_VD_ADN: 125.000; K_VD_BDN: 0.000; K_VD_V: 0.000; K_VD_R: 0.000; E_FREI_39: 1|30.00|20.00|0.000000|0.000000|-1; K_LISTVALUE: 1.0; N_FREI_62: 0; N_FREI_75: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;"""; N_FREI_76: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""; N_FREI_77: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""
Ablufttellerventil LVS | Půdorys 1.PP | 0 | Talířový ventil | Ablufttellerventil LVS | 120 | 1001 | 1/0/0/0/180.0/0/0/125.0000/0/125.0000/-1/ | 1001/30/-1/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/28.00/125.00/125.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/ | - | \\machn\allplan\v2018\std\prod\ess\l\auslaesse\lüftungsventile\ | Mat_12 |  | 125 | 0.000 | 120.00 | ? | Mat_12 | VV.02.30012 | Podzemní podlaží 1.PP | 1.01 | 0.164 | 0.05 | 164 mm | 125 mm | A1 | 200 m3/hod | 1,3 m/s | 6772BP_0000000593 | Kus | NEMSOK - Index kóty: 0; K_LVZNR: K_LVZNR; K_Z_KOORD: M.2; A_ZETA_EBT: 0.00; L_LP_AIR_TYPE: 1; L_FREI_24: 0|0|0|0|0||; K_SYSTEMTYPE: 1; K_VD_TYPE: LP; K_MAXDELTAP: 0.000; K_DELTAP: 0.000; K_ZETA: 0.000; K_RWERT: 0.000; K_VD_DG: 0.000; K_VD_DN: 0.000; K_VD_DI: 0.000; K_VD_DA: 0.000; K_VD_A: 0.000; K_VD_B: 0.000; K_VD_QFORM: -1|0|2||0|; K_VD_ADN: 125.000; K_VD_BDN: 0.000; K_VD_V: 0.000; K_VD_R: 0.000; E_FREI_39: 1|30.00|20.00|0.000000|0.000000|-1; K_LISTVALUE: 1.0; N_FREI_62: 0; N_FREI_75: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;"""; N_FREI_76: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""; N_FREI_77: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""
Ablufttellerventil LVS | Půdorys 1.PP | 0 | Talířový ventil | Ablufttellerventil LVS | 120 | 1001 | 1/0/0/0/180.0/0/0/0/0/0/-1/ | 1001/30/-1/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/28.00/100.00/100.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/ | - | \\machn\allplan\v2018\std\prod\ess\l\auslaesse\lüftungsventile\ | Mat_12 |  | 100 | 0.000 | 120.00 | ? | Mat_12 | VV.02.30013 | Podzemní podlaží 1.PP | 1.01 | 0.114 | 0.05 | 114 mm | 100 mm | A1 | 200 m3/hod | 1,3 m/s | 6772BP_0000000594 | Kus | NEMSOK - Index kóty: 0; K_LVZNR: K_LVZNR; K_Z_KOORD: M.2; A_ZETA_EBT: 0.00; L_LP_AIR_TYPE: 1; L_FREI_24: 0|0|0|0|0||; K_SYSTEMTYPE: 1; K_VD_TYPE: LP; K_MAXDELTAP: 0.000; K_DELTAP: 0.000; K_ZETA: 0.000; K_RWERT: 0.000; K_VD_DG: 0.000; K_VD_DN: 0.000; K_VD_DI: 0.000; K_VD_DA: 0.000; K_VD_A: 0.000; K_VD_B: 0.000; K_VD_QFORM: -1|0|2||0|; K_VD_ADN: 0.000; K_VD_BDN: 0.000; K_VD_V: 0.000; K_VD_R: 0.000; E_FREI_39: 1|30.00|20.00|0.000000|0.000000|-1; K_LISTVALUE: 1.0; N_FREI_62: 0; N_FREI_75: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;"""; N_FREI_76: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""; N_FREI_77: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""
Ablufttellerventil LVS | Půdorys 1.PP | 0 | Talířový ventil | Ablufttellerventil LVS | 120 | 1001 | 1/0/0/0/180.0/0/0/125.0000/0/125.0000/-1/ | 1001/30/-1/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/28.00/125.00/125.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/ | - | \\machn\allplan\v2018\std\prod\ess\l\auslaesse\lüftungsventile\ | Mat_12 |  | 125 | 0.000 | 120.00 | ? | Mat_12 | VV.02.30014 | Podzemní podlaží 1.PP | 1.01 | 0.164 | 0.05 | 164 mm | 125 mm | A1 | 200 m3/hod | 1,3 m/s | 6772BP_0000000595 | Kus | NEMSOK - Index kóty: 0; K_LVZNR: K_LVZNR; K_Z_KOORD: M.2; A_ZETA_EBT: 0.00; L_LP_AIR_TYPE: 1; L_FREI_24: 0|0|0|0|0||; K_SYSTEMTYPE: 1; K_VD_TYPE: LP; K_MAXDELTAP: 0.000; K_DELTAP: 0.000; K_ZETA: 0.000; K_RWERT: 0.000; K_VD_DG: 0.000; K_VD_DN: 0.000; K_VD_DI: 0.000; K_VD_DA: 0.000; K_VD_A: 0.000; K_VD_B: 0.000; K_VD_QFORM: -1|0|2||0|; K_VD_ADN: 125.000; K_VD_BDN: 0.000; K_VD_V: 0.000; K_VD_R: 0.000; E_FREI_39: 1|30.00|20.00|0.000000|0.000000|-1; K_LISTVALUE: 1.0; N_FREI_62: 0; N_FREI_75: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;"""; N_FREI_76: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""; N_FREI_77: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""
Ablufttellerventil LVS | Půdorys 1.PP | 0 | Talířový ventil | Ablufttellerventil LVS | 120 | 1001 | 1/0/0/0/180.0/0/0/0/0/0/-1/ | 1001/30/-1/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/28.00/100.00/100.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/ | - | \\machn\allplan\v2018\std\prod\ess\l\auslaesse\lüftungsventile\ | Mat_12 |  | 100 | 0.000 | 120.00 | ? | Mat_12 | VV.02.30015 | Podzemní podlaží 1.PP | 1.01 | 0.114 | 0.05 | 114 mm | 100 mm | A1 | 200 m3/hod | 1,3 m/s | 6772BP_0000000654 | Kus | NEMSOK - Index kóty: 0; K_LVZNR: K_LVZNR; K_Z_KOORD: M.2; A_ZETA_EBT: 0.00; L_LP_AIR_TYPE: 1; L_FREI_24: 0|0|0|0|0||; K_SYSTEMTYPE: 1; K_VD_TYPE: LP; K_MAXDELTAP: 0.000; K_DELTAP: 0.000; K_ZETA: 0.000; K_RWERT: 0.000; K_VD_DG: 0.000; K_VD_DN: 0.000; K_VD_DI: 0.000; K_VD_DA: 0.000; K_VD_A: 0.000; K_VD_B: 0.000; K_VD_QFORM: -1|0|2||0|; K_VD_ADN: 0.000; K_VD_BDN: 0.000; K_VD_V: 0.000; K_VD_R: 0.000; E_FREI_39: 1|30.00|20.00|0.000000|0.000000|-1; K_LISTVALUE: 1.0; N_FREI_62: 0; N_FREI_75: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;"""; N_FREI_76: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""; N_FREI_77: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""
Ablufttellerventil LVS | Půdorys 1.PP | 0 | Talířový ventil | Ablufttellerventil LVS | 120 | 1001 | 1/0/0/0/180.0/0/0/125.0000/0/125.0000/-1/ | 1001/30/-1/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/28.00/125.00/125.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/ | - | \\machn\allplan\v2018\std\prod\ess\l\auslaesse\lüftungsventile\ | Mat_12 |  | 125 | 0.000 | 120.00 | ? | Mat_12 | VV.02.30016 | Podzemní podlaží 1.PP | 1.01 | 0.164 | 0.05 | 164 mm | 125 mm | A1 | 200 m3/hod | 1,3 m/s | 6772BP_0000000656 | Kus | NEMSOK - Index kóty: 0; K_LVZNR: K_LVZNR; K_Z_KOORD: M.2; A_ZETA_EBT: 0.00; L_LP_AIR_TYPE: 1; L_FREI_24: 0|0|0|0|0||; K_SYSTEMTYPE: 1; K_VD_TYPE: LP; K_MAXDELTAP: 0.000; K_DELTAP: 0.000; K_ZETA: 0.000; K_RWERT: 0.000; K_VD_DG: 0.000; K_VD_DN: 0.000; K_VD_DI: 0.000; K_VD_DA: 0.000; K_VD_A: 0.000; K_VD_B: 0.000; K_VD_QFORM: -1|0|2||0|; K_VD_ADN: 125.000; K_VD_BDN: 0.000; K_VD_V: 0.000; K_VD_R: 0.000; E_FREI_39: 1|30.00|20.00|0.000000|0.000000|-1; K_LISTVALUE: 1.0; N_FREI_62: 0; N_FREI_75: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;"""; N_FREI_76: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""; N_FREI_77: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""
Ablufttellerventil LVS | Půdorys 1.PP | 0 | Talířový ventil | Ablufttellerventil LVS | 120 | 1001 | 1/0/0/0/180.0/0/0/125.0000/0/125.0000/-1/ | 1001/30/-1/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/28.00/125.00/125.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/ | - | \\machn\allplan\v2018\std\prod\ess\l\auslaesse\lüftungsventile\ | Mat_12 |  | 125 | 0.000 | 120.00 | ? | Mat_12 | VV.02.30017 | Podzemní podlaží 1.PP | 1.01 | 0.164 | 0.05 | 164 mm | 125 mm | A1 | 200 m3/hod | 1,3 m/s | 6772BP_0000000792 | Kus | NEMSOK - Index kóty: 0; K_LVZNR: K_LVZNR; K_Z_KOORD: M.2; A_ZETA_EBT: 0.00; L_LP_AIR_TYPE: 1; L_FREI_24: 0|0|0|0|0||; K_SYSTEMTYPE: 1; K_VD_TYPE: LP; K_MAXDELTAP: 0.000; K_DELTAP: 0.000; K_ZETA: 0.000; K_RWERT: 0.000; K_VD_DG: 0.000; K_VD_DN: 0.000; K_VD_DI: 0.000; K_VD_DA: 0.000; K_VD_A: 0.000; K_VD_B: 0.000; K_VD_QFORM: -1|0|2||0|; K_VD_ADN: 125.000; K_VD_BDN: 0.000; K_VD_V: 0.000; K_VD_R: 0.000; E_FREI_39: 1|30.00|20.00|0.000000|0.000000|-1; K_LISTVALUE: 1.0; N_FREI_62: 0; N_FREI_75: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;"""; N_FREI_76: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""; N_FREI_77: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""
Ablufttellerventil LVS | Půdorys 1.PP | 0 | Talířový ventil | Ablufttellerventil LVS | 120 | 1001 | 1/0/0/0/180.0/0/0/125.0000/0/125.0000/-1/ | 1001/30/-1/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/28.00/125.00/125.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/ | - | \\machn\allplan\v2018\std\prod\ess\l\auslaesse\lüftungsventile\ | Mat_12 |  | 125 | 0.000 | 120.00 | ? | Mat_12 | VV.02.30018 | Podzemní podlaží 1.PP | 1.01 | 0.164 | 0.05 | 164 mm | 125 mm | A1 | 200 m3/hod | 1,3 m/s | 6772BP_0000001113 | Kus | NEMSOK - Index kóty: 0; K_LVZNR: K_LVZNR; K_Z_KOORD: M.2; A_ZETA_EBT: 0.00; L_LP_AIR_TYPE: 1; L_FREI_24: 0|0|0|0|0||; K_SYSTEMTYPE: 1; K_VD_TYPE: LP; K_MAXDELTAP: 0.000; K_DELTAP: 0.000; K_ZETA: 0.000; K_RWERT: 0.000; K_VD_DG: 0.000; K_VD_DN: 0.000; K_VD_DI: 0.000; K_VD_DA: 0.000; K_VD_A: 0.000; K_VD_B: 0.000; K_VD_QFORM: -1|0|2||0|; K_VD_ADN: 125.000; K_VD_BDN: 0.000; K_VD_V: 0.000; K_VD_R: 0.000; E_FREI_39: 1|30.00|20.00|0.000000|0.000000|-1; K_LISTVALUE: 1.0; N_FREI_62: 0; N_FREI_75: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;"""; N_FREI_76: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""; N_FREI_77: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""
Ablufttellerventil LVS | Půdorys 1.PP | 0 | Talířový ventil | Ablufttellerventil LVS | 120 | 1001 | 1/0/0/0/180.0/0/0/0/0/0/-1/ | 1001/30/-1/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/28.00/100.00/100.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/ | - | \\machn\allplan\v2018\std\prod\ess\l\auslaesse\lüftungsventile\ | Mat_12 |  | 100 | 0.000 | 120.00 | ? | Mat_12 | VV.02.30019 | Podzemní podlaží 1.PP | 1.01 | 0.114 | 0.05 | 114 mm | 100 mm | A1 | 200 m3/hod | 1,3 m/s | 6772BP_0000001127 | Kus | NEMSOK - Index kóty: 0; K_LVZNR: K_LVZNR; K_Z_KOORD: M.2; A_ZETA_EBT: 0.00; L_LP_AIR_TYPE: 1; L_FREI_24: 0|0|0|0|0||; K_SYSTEMTYPE: 1; K_VD_TYPE: LP; K_MAXDELTAP: 0.000; K_DELTAP: 0.000; K_ZETA: 0.000; K_RWERT: 0.000; K_VD_DG: 0.000; K_VD_DN: 0.000; K_VD_DI: 0.000; K_VD_DA: 0.000; K_VD_A: 0.000; K_VD_B: 0.000; K_VD_QFORM: -1|0|2||0|; K_VD_ADN: 0.000; K_VD_BDN: 0.000; K_VD_V: 0.000; K_VD_R: 0.000; E_FREI_39: 1|30.00|20.00|0.000000|0.000000|-1; K_LISTVALUE: 1.0; N_FREI_62: 0; N_FREI_75: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;"""; N_FREI_76: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""; N_FREI_77: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""
Ablufttellerventil LVS | Půdorys 1.PP | 0 | Talířový ventil | Ablufttellerventil LVS | 120 | 1001 | 1/0/0/0/180.0/0/0/125.0000/0/125.0000/-1/ | 1001/30/-1/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/28.00/125.00/125.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/ | - | \\machn\allplan\v2018\std\prod\ess\l\auslaesse\lüftungsventile\ | Mat_12 |  | 125 | 0.000 | 120.00 | ? | Mat_12 | VV.02.30020 | Podzemní podlaží 1.PP | 1.01 | 0.164 | 0.05 | 164 mm | 125 mm | A1 | 200 m3/hod | 1,3 m/s | 6772BP_0000059671 | Kus | NEMSOK - Index kóty: 0; K_LVZNR: K_LVZNR; K_Z_KOORD: M.2; A_ZETA_EBT: 0.00; L_LP_AIR_TYPE: 1; L_FREI_24: 0|0|0|0|0||; K_SYSTEMTYPE: 1; K_VD_TYPE: LP; K_MAXDELTAP: 0.000; K_DELTAP: 0.000; K_ZETA: 0.000; K_RWERT: 0.000; K_VD_DG: 0.000; K_VD_DN: 0.000; K_VD_DI: 0.000; K_VD_DA: 0.000; K_VD_A: 0.000; K_VD_B: 0.000; K_VD_QFORM: -1|0|2||0|; K_VD_ADN: 125.000; K_VD_BDN: 0.000; K_VD_V: 0.000; K_VD_R: 0.000; E_FREI_39: 1|30.00|20.00|0.000000|0.000000|-1; K_LISTVALUE: 1.0; N_FREI_62: 0; N_FREI_75: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;"""; N_FREI_76: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""; N_FREI_77: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""
Ablufttellerventil LVS | Půdorys 1.PP | 0 | Talířový ventil | Ablufttellerventil LVS | 120 | 1001 | 1/0/0/0/180.0/0/0/0/0/0/-1/ | 1001/30/-1/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/28.00/100.00/100.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/ | - | \\machn\allplan\v2018\std\prod\ess\l\auslaesse\lüftungsventile\ | Mat_12 |  | 100 | 0.000 | 120.00 | ? | Mat_12 | VV.02.30021 | Podzemní podlaží 1.PP | 1.01 | 0.114 | 0.05 | 114 mm | 100 mm | A1 | 200 m3/hod | 1,3 m/s | 6772BP_0000142266 | Kus | NEMSOK - Index kóty: 0; K_LVZNR: K_LVZNR; K_Z_KOORD: M.2; A_ZETA_EBT: 0.00; L_LP_AIR_TYPE: 1; L_FREI_24: 0|0|0|0|0||; K_SYSTEMTYPE: 1; K_VD_TYPE: LP; K_MAXDELTAP: 0.000; K_DELTAP: 0.000; K_ZETA: 0.000; K_RWERT: 0.000; K_VD_DG: 0.000; K_VD_DN: 0.000; K_VD_DI: 0.000; K_VD_DA: 0.000; K_VD_A: 0.000; K_VD_B: 0.000; K_VD_QFORM: -1|0|2||0|; K_VD_ADN: 0.000; K_VD_BDN: 0.000; K_VD_V: 0.000; K_VD_R: 0.000; E_FREI_39: 1|30.00|20.00|0.000000|0.000000|-1; K_LISTVALUE: 1.0; N_FREI_62: 0; N_FREI_75: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;"""; N_FREI_76: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""; N_FREI_77: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""
Ablufttellerventil LVS | Půdorys 1.PP | 0 | Talířový ventil | Ablufttellerventil LVS | 120 | 1001 | 1/0/0/0/180.0/0/0/0/0/0/-1/ | 1001/30/-1/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/28.00/100.00/100.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/ | - | \\machn\allplan\v2018\std\prod\ess\l\auslaesse\lüftungsventile\ | Mat_12 |  | 100 | 0.000 | 120.00 | ? | Mat_12 | VV.02.30022 | Podzemní podlaží 1.PP | 1.01 | 0.114 | 0.05 | 114 mm | 100 mm | A1 | 200 m3/hod | 1,3 m/s | 6772BP_0000142268 | Kus | NEMSOK - Index kóty: 0; K_LVZNR: K_LVZNR; K_Z_KOORD: M.2; A_ZETA_EBT: 0.00; L_LP_AIR_TYPE: 1; L_FREI_24: 0|0|0|0|0||; K_SYSTEMTYPE: 1; K_VD_TYPE: LP; K_MAXDELTAP: 0.000; K_DELTAP: 0.000; K_ZETA: 0.000; K_RWERT: 0.000; K_VD_DG: 0.000; K_VD_DN: 0.000; K_VD_DI: 0.000; K_VD_DA: 0.000; K_VD_A: 0.000; K_VD_B: 0.000; K_VD_QFORM: -1|0|2||0|; K_VD_ADN: 0.000; K_VD_BDN: 0.000; K_VD_V: 0.000; K_VD_R: 0.000; E_FREI_39: 1|30.00|20.00|0.000000|0.000000|-1; K_LISTVALUE: 1.0; N_FREI_62: 0; N_FREI_75: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;"""; N_FREI_76: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""; N_FREI_77: """0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""
Zuluftgitter hor. einst. mit AK | Půdorys 1.PP | 0.1 | Protidešťová mřížka | Zuluftgitter hor. einst. mit AK | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/0/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/560.00/315.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.3 | ${PROD}l\auslässe\gitter zuluft\ | Blech ST37 verzinkt/0.80 |  | 1 | 0.00 | 0.000 | 2022/11/04 | Blech ST37 verzinkt | VV.02.30046 | Podzemní podlaží 1.PP | 1.01 | 0.388 | 0.25 | 160 mm | 160 mm | A1 | 200 m3/hod | 1,3 m/s | 6772Obj0000001256 | Stk | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa) | SB 20/SB 20/// | 100 | 560x315 | 1 | 0
ZG Klappe | Půdorys 1.PP | 0.35 | Objekt | ZG Klappe | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/0/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/560.00/400.00/350.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.2 | ${PROD}l\zentralgeräte\zg klappen\ | Blech ST37 verzinkt/0.80 | Mineralwolle/0.00 | 1 | 0.00 | 0.000 | 2023/01/19 | Blech ST37 verzinkt | KA.02.30006 | Podzemní podlaží 1.PP | -1.63 |  |  |  | 560x400 | - | 4555 m3/h |  | 6772Obj0000160406 | Stk | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa) | SB 20/SB 20/// | 350 | 560x400 | 1 | 0 | NEMSOK - Dolní_hrana: 0 m; Horní_hrana: 0 m; Plocha: 0; K_LISTVALUE_ISO: 0.670 m2; Jmenovitá velikost výstupu: 560x400; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
Schalldämpfer | Půdorys 1.PP | 1.5 | Objekt | Schalldämpfer | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/0/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/560.00/400.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.6 | ${PROD}l\einbauteile\schalldaempfer\ | Blech ST37 verzinkt/0.80 | Mineralwolle/40.00 | 1 | 0.00 | 0.000 | 2023/01/12 | Blech ST37 verzinkt | KA.02.30049 | Podzemní podlaží 1.PP | -1.63 |  |  |  | 560x400 | - | 4555 m3/h |  | 6772Obj0000135607 | Stk | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa) | SB 20/SB 20/// | 1500 | 560x400 | 1 | 0 | NEMSOK - Dolní_hrana: 0 m; Horní_hrana: 0 m; Jmenovitá velikost výstupu: 560x400; Provozní tlak: -; Tlaková třída: -; Typ ovladání: žádné
Schalldämpfer | Půdorys 1.PP | 1.05 | Objekt | Schalldämpfer | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/-1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/560.00/400.00/1050.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.2 | ${PROD}l\einbauteile\schalldaempfer\ | Blech ST37 verzinkt/0.80 | Alu kaschiert/100.00 | 1 | 0.00 | 0.000 | 2023/01/18 | Blech ST37 verzinkt | KA.02.30050 | Podzemní podlaží 1.PP | -1.60 |  |  |  | 560x400 | - | 4555 m3/h |  | 6772Obj0000144979 | Stk | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa) | SB 20/SB 20/// | 1050 | 560x400 | 1 | 0 | NEMSOK - Dolní_hrana: 0 m; Horní_hrana: 0 m; Plocha: 0; Jmenovitá velikost výstupu: 560x400; Provozní tlak: -; Tlaková třída: -; Typ ovladání: žádné
Schalldämpfer | Půdorys 1.PP | 1.5 | Objekt | Schalldämpfer | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/0/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/560.00/400.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.1 | ${PROD}l\einbauteile\schalldaempfer\ | Blech ST37 verzinkt/0.80 | Alu kaschiert/100.00 | 1 | 0.00 | 0.000 | 2023/01/13 | Blech ST37 verzinkt | KA.02.30051 | Podzemní podlaží 1.PP | -1.63 |  |  |  | 560x400 | - | 4555 m3/h |  | 6772Obj0000139576 | Stk | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa) | SB 20/SB 20/// | 1500 | 560x400 | 1 | 0 | NEMSOK - Dolní_hrana: 0 m; Horní_hrana: 0 m; Jmenovitá velikost výstupu: 560x400; Provozní tlak: -; Tlaková třída: -; Typ ovladání: žádné; K_ETAGE: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)|Blech ST37 verzinkt|SPIRO POTRUBÍ|OVALROHR; K_EBT_BOX_WC: 1463.600|300.000|220.000|0.000|-300.000|-220.000|0.000|0.000|0.000|1.000
Schalldämpfer | Půdorys 1.PP | 1.55 | Objekt | Schalldämpfer | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/-1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/560.00/400.00/1550.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.1 | ${PROD}l\einbauteile\schalldaempfer\ | Blech ST37 verzinkt/0.80 | Mineralwolle/40.00 | 1 | 0.00 | 0.000 | 2023/01/18 | Blech ST37 verzinkt | KA.02.30052 | Podzemní podlaží 1.PP | -1.63 |  |  |  | 560x400 | - | 4555 m3/h |  | 6772Obj0000144785 | Stk | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa) | SB 20/SB 20/// | 1550 | 560x400 | 1 | 0 | NEMSOK - Dolní_hrana: 0 m; Horní_hrana: 0 m; Plocha: 0; K_LISTVALUE_ISO: 2.980 m2; Jmenovitá velikost výstupu: 560x400; Provozní tlak: -; Tlaková třída: -; Typ ovladání: žádné; K_EBT_BOX_WC: 55221.977|5147.635|-1305.000|54661.977|3897.635|-1705.000|0.000|0.000|0.000|1.000
Schalldämpfer | Půdorys 1.PP | 1.5 | Objekt | Schalldämpfer | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/-1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/560.00/400.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.1 | ${PROD}l\einbauteile\schalldaempfer\ | Blech ST37 verzinkt/0.80 | Mineralwolle/40.00 | 1 | 0.00 | 0.000 | 2023/01/13 | Blech ST37 verzinkt | KA.02.30053 | Podzemní podlaží 1.PP | -1.63 |  |  |  | 560x400 | - | 4555 m3/h |  | 6772Obj0000137476 | Stk | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa) | SB 20/SB 20/// | 1500 | 560x400 | 1 | 0 | NEMSOK - Jmenovitá velikost výstupu: 560x400; Provozní tlak: -; Tlaková třída: -; Typ ovladání: žádné; K_ETAGE: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)|Blech ST37 verzinkt|SPIRO POTRUBÍ|OVALROHR; K_EBT_BOX_WC: 1408.800|300.000|220.000|0.000|-300.000|-220.000|0.000|0.000|0.000|1.000
Schalldämpfer | Půdorys 1.PP | 1.5 | Objekt | Schalldämpfer | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/-1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/400.00/560.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.6 | ${PROD}l\einbauteile\schalldaempfer\ | Blech ST37 verzinkt/0.80 | Mineralwolle/40.00 | 1 | 0.00 | 0.000 | 2023/01/13 | Blech ST37 verzinkt | KA.02.30054 | Podzemní podlaží 1.PP | -1.63 |  |  |  | 400x560 | - | 4555 m3/h |  | 6772Obj0000137553 | Stk | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa) | SB 20/SB 20/// | 1500 | 400x560 | 1 | 0 | NEMSOK - Dolní_hrana: 0 m; Horní_hrana: 0 m; Jmenovitá velikost výstupu: 400x560; Provozní tlak: -; Tlaková třída: -; Typ ovladání: žádné
Abluft Auslass ADLQ-1-AK-B | Půdorys 1.PP | 0.3 | Konstrukce v aktuální hladině | Abluft Auslass ADLQ-1-AK-B | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/-1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/100.00/50.00/300.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.3 | ${PROD}l\auslässe\abluft auslass adlq\ | Blech ST37 verzinkt/0.80 | Mineralwolle/40.00 | 1 | 0.00 | 0.000 | 2023/01/13 | Blech ST37 verzinkt | VV.02.30003 | Podzemní podlaží 1.PP | -1.64 | 0.02 | 0.1 | 160 mm | 200 mm x 100 mm | A1 | 100 m3/hod | 2,4 m/s | 6772Obj0000137668 | Stk | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa) | SB 20/SB 20/// | 300 | 100x50 | 1 | 0
Zuluft Auslass ADLQ-1-AK-B | Půdorys 1.PP | 0.3 | Konstrukce v aktuální hladině | Zuluft Auslass ADLQ-1-AK-B | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/-1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/100.00/50.00/300.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.1 | ${PROD}l\auslässe\zuluft auslass adlq\ | Blech ST37 verzinkt/0.60 | Mineralwolle/40.00 | 1 | 0.00 | 0.000 | 2023/01/13 | Blech ST37 verzinkt | VV.02.30004 | Podzemní podlaží 1.PP | -1.63 | 0.02 | 0.1 | 160 mm | 200 mm x 100 mm | A1 | 100 m3/hod | 2,4 m/s | 6772Obj0000137678 | Stk | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa) | SB 20/SB 20/// | 300 | 100x50 | 1 | 0 | NEMSOK - K_EBT_BOX_WC: 53891.431|8058.000|-964.000|53591.431|7892.593|-1046.704|0.000|0.000|0.000|1.000
Abluftgitter horizontal | Půdorys 1.PP | 0.04 | Konstrukce v aktuální hladině | Abluftgitter horizontal | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/200.00/150.00/40.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.1 | ${PROD}l\auslässe\gitter abluft\ | Blech ST37 verzinkt/0.60 | Mineralwolle/0.00 | 1 | 0.00 | 0.000 | 2023/01/17 | Blech ST37 verzinkt | VV.02.30005 | Podzemní podlaží 1.PP | -1.62 | 0.02 | 0.15 | 160 mm | 200 mm x 150 mm | A1 | 225 m3/hod | 3,1 m/s | 6772Obj0000143773 | Stk | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa) | SB 20/SB 20/// | 40 | 200x150 | 1 | 0 | NEMSOK - Plocha: 0; K_LISTVALUE_ISO: 0.030 m2; K_EBT_BOX_WC: 57255.849|10322.000|-639.000|57109.849|10080.000|-760.000|0.000|0.000|0.000|1.000
Zuluftgitter horizontal | Půdorys 1.PP | 0.04 | Konstrukce v aktuální hladině | Zuluftgitter horizontal | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/200.00/150.00/40.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.1 | ${PROD}l\auslässe\gitter zuluft\ | Blech ST37 verzinkt/0.60 | Mineralwolle/0.00 | 1 | 0.00 | 0.000 | 2023/01/17 | Blech ST37 verzinkt | VV.02.30006 | Podzemní podlaží 1.PP | -1.62 | 0.02 | 0.15 | 160 mm | 200 mm x 150 mm | A1 | 225 m3/hod | 3,1 m/s | 6772Obj0000143748 | Stk | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa) | SB 20/SB 20/// | 40 | 200x150 | 1 | 0 | NEMSOK - Plocha: 0; K_LISTVALUE_ISO: 0.030 m2; K_EBT_BOX_WC: 61763.604|8106.000|-639.000|61521.604|7960.000|-760.000|0.000|0.000|0.000|1.000
Abluftgitter horizontal | Půdorys 1.PP | 0.04 | Konstrukce v aktuální hladině | Abluftgitter horizontal | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/200.00/100.00/40.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.11 | ${PROD}l\auslässe\gitter abluft\ | Blech ST37 verzinkt/0.60 | Mineralwolle/40.00 | 1 | 0.00 | 0.000 | 2023/01/13 | Blech ST37 verzinkt | VV.02.30007 | Podzemní podlaží 1.PP | -1.61 | 0.02 | 0.1 | 160 mm | 200 mm x 100 mm | A1 | 100 m3/hod | 2,4 m/s | 6772Obj0000136601 | Stk | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa) | SB 20/SB 20/// | 40 | 200x100 | 1 | 0
Zuluftgitter horizontal | Půdorys 1.PP | 0.04 | Konstrukce v aktuální hladině | Zuluftgitter horizontal | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/200.00/100.00/40.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.1 | ${PROD}l\auslässe\gitter zuluft\ | Blech ST37 verzinkt/0.60 | Mineralwolle/40.00 | 1 | 0.00 | 0.000 | 2023/01/13 | Blech ST37 verzinkt | VV.02.30008 | Podzemní podlaží 1.PP | -1.61 | 0.02 | 0.1 | 160 mm | 200 mm x 100 mm | A1 | 100 m3/hod | 2,4 m/s | 6772Obj0000137701 | Stk | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa) | SB 20/SB 20/// | 40 | 200x100 | 1 | 0 | NEMSOK - K_EBT_BOX_WC: 62651.026|15940.000|-639.000|62409.026|15794.000|-760.000|0.000|0.000|0.000|1.000
Abluftgitter hor. einst. mit AK | Půdorys 1.PP | 0.2 | Konstrukce v aktuální hladině | Abluftgitter hor. einst. mit AK | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/0/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/800.00/500.00/200.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.1 | ${PROD}l\auslässe\gitter abluft\ | Blech ST37 verzinkt/0.80 | Alu kaschiert/0.00 | 1 | 0.00 | 0.000 | 2023/01/18 | Blech ST37 verzinkt | VV.02.30051 | Podzemní podlaží 1.PP | - | 0.05 | 0.5 | 160 mm | 800 mm x 500 mm | A1 | 4555 m3/hod | 4,4 m/s | 6772Obj0000145012 | Stk | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa) | SB 20/SB 20/// | 200 | 800x500 | 1 | 0 | NEMSOK - K_LISTVALUE_ISO: 0.520 m2; K_EBT_BOX_WC: 64550.000|7738.000|-445.000|63820.000|6770.000|-1050.000|0.000|0.000|0.000|1.000
Zuluftgitter hor. einst. mit AK | Půdorys 1.PP | 0.2 | Konstrukce v aktuální hladině | Zuluftgitter hor. einst. mit AK | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/0/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/800.00/500.00/200.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.3 | ${PROD}l\auslässe\gitter zuluft\ | Blech ST37 verzinkt/0.80 | Alu kaschiert/100.00 | 1 | 0.00 | 0.000 | 2022/09/29 | Blech ST37 verzinkt | VV.02.30052 | Podzemní podlaží 1.PP | - | 0.05 | 0.5 | 160 mm | 800 mm x 500 mm | A1 | 4555 m3/hod | 4,4 m/s | 6772Obj0000000559 | Stk | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa) | SB 20/SB 20/// | 200 | 800x500 | 1 | 0
ABL Regler konst. EN mit Antrieb | Půdorys 1.PP | 0.26 | Konstrukce v aktuální hladině | ABL Regler konst. EN mit Antrieb | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/0/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/200.00/160.00/260.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.1 | ${PROD}l\einbauteile\volumenstromregler konstant\ | Blech ST37 verzinkt/0.60 | Blech ummantelt/40.00 | 1 | 0.00 | 0.000 | 2022/11/04 | Blech ST37 verzinkt | KA.02.30023 | Podzení podlaží 1.PP | -1.38 |  |  |  | 200x160 | A1 | 1,002 m3/s |  | 6772Obj0000000986 | Stk | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa) | SB 20/SB 20/// | 260 | 200x160 | 1 | 0 | NEMSOK - K_LISTVALUE_ISO: 0.270 m2; Jmenovitá velikost výstupu: 200x160; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální; K_EBT_BOX_WC: 14992.450|13192.674|-400.000|14792.450|12192.674|-560.000|0.000|0.000|0.000|1.000
ABL Regler konst. EN mit Antrieb | Půdorys 1.PP | 0.26 | Konstrukce v aktuální hladině | ABL Regler konst. EN mit Antrieb | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/0/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/200.00/160.00/260.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.1 | ${PROD}l\einbauteile\volumenstromregler konstant\ | Blech ST37 verzinkt/0.60 | Blech ummantelt/40.00 | 1 | 0.00 | 0.000 | 2022/11/04 | Blech ST37 verzinkt | KA.02.30039 | Podzení podlaží 1.PP | -1.38 |  |  |  | 200x160 | A1 | 1,002 m3/s |  | 6772Obj0000001705 | Stk | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa) | SB 20/SB 20/// | 260 | 200x160 | 1 | 0 | NEMSOK - K_LISTVALUE_ISO: 0.270 m2; Jmenovitá velikost výstupu: 200x160; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální; K_EBT_BOX_WC: 14992.450|13192.674|-400.000|14792.450|12192.674|-560.000|0.000|0.000|0.000|1.000
Schalldämpfer | Půdorys 1.PP | 1.25 | Konstrukce v aktuální hladině | Schalldämpfer | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/-1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/710.00/200.00/1250.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.3 | ${PROD}l\einbauteile\schalldaempfer\ | Blech ST37 verzinkt/0.80 | Blech ummantelt/50.00 | 1 | 0.00 | 0.000 | 2023/01/17 | Blech ST37 verzinkt | KA.02.30042 | Podzení podlaží 1.PP | -1.40 |  |  |  | 710x200 | A1 | 1,002 m3/s |  | 6772Obj0000144037 | Stk | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa) | SB 20/SB 20/// | 1250 | 710x200 | 1 | 0 | NEMSOK - Plocha: 0; Jmenovitá velikost výstupu: 710x200; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: žádné
Schalldämpfer | Půdorys 1.PP | 0.95 | Konstrukce v aktuální hladině | Schalldämpfer | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/-1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/800.00/150.00/950.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.2 | ${PROD}l\einbauteile\schalldaempfer\ | Blech ST37 verzinkt/0.80 | Blech ummantelt/40.00 | 1 | 0.00 | 0.000 | 2023/01/17 | Blech ST37 verzinkt | KA.02.30045 | Podzení podlaží 1.PP | -1.34 |  |  |  | 800x150 | A1 | 1,002 m3/s |  | 6772Obj0000144162 | Stk | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa) | SB 20/SB 20/// | 950 | 800x150 | 1 | 0 | NEMSOK - Plocha: 0; Jmenovitá velikost výstupu: 800x150; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: žádné
ABL Regler konst. EN mit Antrieb | Půdorys 1.PP | 0.26 | Konstrukce v aktuální hladině | ABL Regler konst. EN mit Antrieb | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/0/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/160.00/160.00/260.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.3 | ${PROD}l\einbauteile\volumenstromregler konstant\ | Blech ST37 verzinkt/0.60 | Blech ummantelt/40.00 | 1 | 0.00 | 0.000 | 2022/11/04 | Blech ST37 verzinkt | KA.02.30038 | Podzení podlaží 1.PP | -1.34 |  |  |  | 160x160 | A1 | 1,002 m3/s |  | 6772Obj0000001680 | Stk | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa) | SB 20/SB 20/// | 260 | 160x160 | 1 | 0 | NEMSOK - K_LISTVALUE_ISO: 0.250 m2; Jmenovitá velikost výstupu: 160x160; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
ABL Regler konst. EN mit Antrieb | Půdorys 1.PP | 0.26 | Konstrukce v aktuální hladině | ABL Regler konst. EN mit Antrieb | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/160.00/160.00/260.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.2 | ${PROD}l\einbauteile\volumenstromregler konstant\ | Blech ST37 verzinkt/0.60 | Blech ummantelt/40.00 | 1 | 0.00 | 0.000 | 2022/11/04 | Blech ST37 verzinkt | KA.02.30027 | Podzení podlaží 1.PP | -1.53 |  |  |  | 160x160 | A1 | 1,002 m3/s |  | 6772Obj0000001207 | Stk | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa) | SB 20/SB 20/// | 260 | 160x160 | 1 | 0 | NEMSOK - K_LISTVALUE_ISO: 0.250 m2; Jmenovitá velikost výstupu: 160x160; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
Schalldämpfer | Půdorys 1.PP | 0.95 | Konstrukce v aktuální hladině | Schalldämpfer | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/-1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/315.00/400.00/950.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.6 | ${PROD}l\einbauteile\schalldaempfer\ | Blech ST37 verzinkt/0.60 | Blech ummantelt/40.00 | 1 | 0.00 | 0.000 | 2023/01/17 | Blech ST37 verzinkt | KA.02.30046 | Podzení podlaží 1.PP | -1.05 |  |  |  | 315x400 | A1 | 1,002 m3/s |  | 6772Obj0000144219 | Stk | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa) | SB 20/SB 20/// | 950 | 315x400 | 1 | 0 | NEMSOK - Plocha: 0; Jmenovitá velikost výstupu: 315x400; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: žádné
Schalldämpfer | Půdorys 1.PP | 1.25 | Konstrukce v aktuální hladině | Schalldämpfer | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/400.00/300.00/1250.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.2 | ${PROD}l\einbauteile\schalldaempfer\ | Blech ST37 verzinkt/0.60 | Blech ummantelt/0.00 | 1 | 0.00 | 0.000 | 2023/01/17 | Blech ST37 verzinkt | KA.02.30047 | Podzení podlaží 1.PP | -1.05 |  |  |  | 400x300 | A1 | 1,002 m3/s |  | 6772Obj0000144254 | Stk | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa) | SB 20/SB 20/// | 1250 | 400x300 | 1 | 0 | NEMSOK - Plocha: 0; K_LISTVALUE_ISO: 1.750 m2; Jmenovitá velikost výstupu: 400x300; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: žádné
Schalldämpfer | Půdorys 1.PP | 0.8 | Konstrukce v aktuální hladině | Schalldämpfer | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/-1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/400.00/710.00/800.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.2 | ${PROD}l\einbauteile\schalldaempfer\ | Blech ST37 verzinkt/0.80 | Blech ummantelt/0.00 | 1 | 0.00 | 0.000 | 2023/01/17 | Blech ST37 verzinkt | KA.02.30044 | Podzení podlaží 1.PP | -1.05 |  |  |  | 400x710 | A1 | 1,002 m3/s |  | 6772Obj0000144129 | Stk | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa) | SB 20/SB 20/// | 800 | 400x710 | 1 | 0 | NEMSOK - K_LISTVALUE_ISO: 1.780 m2; Jmenovitá velikost výstupu: 400x710; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: žádné
Schalldämpfer | Půdorys 1.PP | 1.25 | Konstrukce v aktuální hladině | Schalldämpfer | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/-1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/710.00/250.00/1250.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.1 | ${PROD}l\einbauteile\schalldaempfer\ | Blech ST37 verzinkt/0.80 | Blech ummantelt/50.00 | 1 | 0.00 | 0.000 | 2023/01/17 | Blech ST37 verzinkt | KA.02.30043 | Podzení podlaží 1.PP | -1.34 |  |  |  | 710x250 | A1 | 1,002 m3/s |  | 6772Obj0000144124 | Stk | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa) | SB 20/SB 20/// | 1250 | 710x250 | 1 | 0 | NEMSOK - K_LISTVALUE_ISO: 2.400 m2; Jmenovitá velikost výstupu: 710x250; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: žádné; K_ETAGE: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)|Blech ST37 verzinkt|SPIRO POTRUBÍ|OVALROHR; K_EBT_BOX_WC: 1500.000|300.000|100.000|0.000|-300.000|-100.000|0.000|0.000|0.000|1.000
Ablufttellerventil LVS | Půdorys 1.NP | 0 | Bodový prvek | Ablufttellerventil LVS | 120 | 1001 | 1/0/0/0/180.0/0/0/0/0/0/-1/ | 1001/30/-1/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/28.00/100.00/100.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/ | - | \\machn\allplan\v2018\std\prod\ess\l\auslaesse\lüftungsventile\ | Mat_12 | Alu_kaschiert/100.00 | 100 | 0.000 | 120.00 | ? | Mat_12 | VV.03.3060 | Nadzemní podlaží 1.NP | K1.12 | 0.114 | 0.05 | 114 mm | 100 mm | A1 | 50 m3/hod | 1,3 m/s | 6782BP_0798478931 | Kus | NEMSOK - Index kóty: 0; K_LVZNR: K_LVZNR; K_Z_KOORD: M.2; A_ZETA_EBT: 0.00; L_LP_AIR_TYPE: 1; L_FREI_24: 0|0|0|0|0||; K_SYSTEMTYPE: 1; K_VD_TYPE: LP; K_MAXDELTAP: 0.000; K_DELTAP: 0.000; K_ZETA: 0.000; K_RWERT: 0.000; K_VD_DG: 0.000; K_VD_DN: 0.000; K_VD_DI: 0.000; K_VD_DA: 0.000; K_VD_A: 0.000; K_VD_B: 0.000; K_VD_QFORM: -1|0|2||0|; K_VD_ADN: 0.000; K_VD_BDN: 0.000; K_VD_V: 0.000; K_VD_R: 0.000; E_FREI_39: 1|30.00|20.00|0.000000|0.000000|-1; K_LISTVALUE: 1.0; N_FREI_62: 0; N_FREI_75: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;"""""""; N_FREI_76: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""; N_FREI_77: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""
Ablufttellerventil LVS | Půdorys 1.NP | 0 | Bodový prvek | Ablufttellerventil LVS | 120 | 1001 | 1/0/0/0/180.0/0/0/0/0/0/-1/ | 1001/30/-1/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/28.00/100.00/100.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/ | - | \\machn\allplan\v2018\std\prod\ess\l\auslaesse\lüftungsventile\ | Mat_12 | Alu_kaschiert/100.00 | 100 | 0.000 | 120.00 | ? | Mat_12 | VV.03.3061 | Nadzemní podlaží 1.NP | K1.10 | 0.114 | 0.05 | 114 mm | 100 mm | A1 | 50 m3/hod | 1,3 m/s | 6782BP_0798478932 | Kus | NEMSOK - Index kóty: 0; K_LVZNR: K_LVZNR; K_Z_KOORD: M.2; A_ZETA_EBT: 0.00; L_LP_AIR_TYPE: 1; L_FREI_24: 0|0|0|0|0||; K_SYSTEMTYPE: 1; K_VD_TYPE: LP; K_MAXDELTAP: 0.000; K_DELTAP: 0.000; K_ZETA: 0.000; K_RWERT: 0.000; K_VD_DG: 0.000; K_VD_DN: 0.000; K_VD_DI: 0.000; K_VD_DA: 0.000; K_VD_A: 0.000; K_VD_B: 0.000; K_VD_QFORM: -1|0|2||0|; K_VD_ADN: 0.000; K_VD_BDN: 0.000; K_VD_V: 0.000; K_VD_R: 0.000; E_FREI_39: 1|30.00|20.00|0.000000|0.000000|-1; K_LISTVALUE: 1.0; N_FREI_62: 0; N_FREI_75: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;"""""""; N_FREI_76: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""; N_FREI_77: """""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""
Abluftgitter hor. einst. mit AK | Půdorys 1.NP | 0.07 | Objekt | Abluftgitter hor. einst. mit AK | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/1/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/500.00/250.00/70.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.1 | ${PROD}l\auslässe\gitter abluft\ | Blech ST37 verzinkt/0.60 |  | 1 | 0.00 | 0.000 | 2022/05/09 | Blech ST37 verzinkt | VV.03.3070 | Nadzemní podlaží 1.NP | 1.01 | 0.164 | 0.05 | 160 mm | 160 mm | A1 | 50 m3/hod | 1,3 m/s | 6782Obj0798478901 | Stk | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa) | SB 20/SB 20/// | 70 | 500x250 | 1 | 0 | NEMSOK - Dolní_hrana: 0 m; Horní_hrana: 0 m; K_EBT_BOX_WC: 3699.282|5901.664|3866.500|3094.282|5783.355|3564.000|0.000|0.000|0.000|1.000
Ablufttellerventil LVS | Půdorys 1.NP | 0 | Bodový prvek | Ablufttellerventil LVS | 120 | 1001 | 1/0/0/0/180.0/0/0/125.0000/0/125.0000/-1/ | 1001/30/-1/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/28.00/125.00/125.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/ | - | \\machn\allplan\v2018\std\prod\ess\l\auslaesse\lüftungsventile\ | Mat_12 |  | 125 | 0.000 | 120.00 | ? | Mat_12 | VV.03.3062 | Nadzemní podlaží 1.NP | K1.14A | 0.164 | 0.05 | 164 mm | 125 mm | A1 | 50 m3/hod | 1,3 m/s | 6782BP_0798478934 | Kus | NEMSOK - Index kóty: 0; K_LVZNR: K_LVZNR; K_Z_KOORD: M.2; A_ZETA_EBT: 0.00; L_LP_AIR_TYPE: 1; L_FREI_24: 0|0|0|0|0||; K_SYSTEMTYPE: 1; K_VD_TYPE: LP; K_MAXDELTAP: 0.000; K_DELTAP: 0.000; K_ZETA: 0.000; K_RWERT: 0.000; K_VD_DG: 0.000; K_VD_DN: 0.000; K_VD_DI: 0.000; K_VD_DA: 0.000; K_VD_A: 0.000; K_VD_B: 0.000; K_VD_QFORM: -1|0|2||0|; K_VD_ADN: 125.000; K_VD_BDN: 0.000; K_VD_V: 0.000; K_VD_R: 0.000; E_FREI_39: 1|30.00|20.00|0.000000|0.000000|-1; K_LISTVALUE: 1.0; N_FREI_62: 0; N_FREI_75: """""""""""""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;"""""""""""""""; N_FREI_76: """""""""""""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""""""""""; N_FREI_77: """""""""""""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""""""""""
Ablufttellerventil LVS | Půdorys 1.NP | 0 | Bodový prvek | Ablufttellerventil LVS | 120 | 1001 | 1/0/0/0/180.0/0/0/125.0000/0/125.0000/-1/ | 1001/30/-1/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/28.00/125.00/125.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/ | - | \\machn\allplan\v2018\std\prod\ess\l\auslaesse\lüftungsventile\ | Mat_12 | Mineralwolle/100.00 | 125 | 0.000 | 120.00 | ? | Mat_12 | VV.03.3065 | Nadzemní podlaží 1.NP | K1.05 | 0.164 | 0.05 | 164 mm | 125 mm | A1 | 30 m3/hod | 0,9 m/s | 6782BP_0798478973 | Kus | NEMSOK - Index kóty: 0; K_LVZNR: K_LVZNR; K_Z_KOORD: M.2; A_ZETA_EBT: 0.00; L_LP_AIR_TYPE: 1; L_FREI_24: 0|0|0|0|0||; K_SYSTEMTYPE: 1; K_VD_TYPE: LP; K_MAXDELTAP: 0.000; K_DELTAP: 0.000; K_ZETA: 0.000; K_RWERT: 0.000; K_VD_DG: 0.000; K_VD_DN: 0.000; K_VD_DI: 0.000; K_VD_DA: 0.000; K_VD_A: 0.000; K_VD_B: 0.000; K_VD_QFORM: -1|0|2||0|; K_VD_ADN: 125.000; K_VD_BDN: 0.000; K_VD_V: 0.000; K_VD_R: 0.000; E_FREI_39: 1|30.00|20.00|0.000000|0.000000|-1; K_LISTVALUE: 1.0; N_FREI_62: 0; N_FREI_75: """""""""""""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;"""""""""""""""; N_FREI_76: """""""""""""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""""""""""; N_FREI_77: """""""""""""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""""""""""
Ablufttellerventil LVS | Půdorys 1.NP | 0 | Bodový prvek | Ablufttellerventil LVS | 120 | 1001 | 1/0/0/0/180.0/0/0/125.0000/0/125.0000/-1/ | 1001/30/-1/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/28.00/125.00/125.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/ | - | \\machn\allplan\v2018\std\prod\ess\l\auslaesse\lüftungsventile\ | Mat_12 |  | 125 | 0.000 | 120.00 | ? | Mat_12 | VV.03.3066 | Nadzemní podlaží 1.NP | K1.04A | 0.164 | 0.05 | 164 mm | 125 mm | A1 | 50 m3/hod | 1,3 m/s | 6782BP_0798479013 | Kus | NEMSOK - Index kóty: 0; K_LVZNR: K_LVZNR; K_Z_KOORD: M.2; A_ZETA_EBT: 0.00; L_LP_AIR_TYPE: 1; L_FREI_24: 0|0|0|0|0||; K_SYSTEMTYPE: 1; K_VD_TYPE: LP; K_MAXDELTAP: 0.000; K_DELTAP: 0.000; K_ZETA: 0.000; K_RWERT: 0.000; K_VD_DG: 0.000; K_VD_DN: 0.000; K_VD_DI: 0.000; K_VD_DA: 0.000; K_VD_A: 0.000; K_VD_B: 0.000; K_VD_QFORM: -1|0|2||0|; K_VD_ADN: 125.000; K_VD_BDN: 0.000; K_VD_V: 0.000; K_VD_R: 0.000; E_FREI_39: 1|30.00|20.00|0.000000|0.000000|-1; K_LISTVALUE: 1.0; N_FREI_62: 0; N_FREI_75: """""""""""""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;"""""""""""""""; N_FREI_76: """""""""""""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""""""""""; N_FREI_77: """""""""""""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""""""""""
Ablufttellerventil LVS | Půdorys 1.NP | 0 | Bodový prvek | Ablufttellerventil LVS | 120 | 1001 | 1/0/0/0/180.0/0/0/125.0000/0/125.0000/-1/ | 1001/30/-1/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/28.00/125.00/125.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/ | - | \\machn\allplan\v2018\std\prod\ess\l\auslaesse\lüftungsventile\ | Mat_12 |  | 125 | 0.000 | 120.00 | ? | Mat_12 | VV.03.3067 | Nadzemní podlaží 1.NP | K1.05 | 0.164 | 0.05 | 164 mm | 125 mm | A1 | 50 m3/hod | 1,3 m/s | 6782BP_0798479014 | Kus | NEMSOK - Index kóty: 0; K_LVZNR: K_LVZNR; K_Z_KOORD: M.2; A_ZETA_EBT: 0.00; L_LP_AIR_TYPE: 1; L_FREI_24: 0|0|0|0|0||; K_SYSTEMTYPE: 1; K_VD_TYPE: LP; K_MAXDELTAP: 0.000; K_DELTAP: 0.000; K_ZETA: 0.000; K_RWERT: 0.000; K_VD_DG: 0.000; K_VD_DN: 0.000; K_VD_DI: 0.000; K_VD_DA: 0.000; K_VD_A: 0.000; K_VD_B: 0.000; K_VD_QFORM: -1|0|2||0|; K_VD_ADN: 125.000; K_VD_BDN: 0.000; K_VD_V: 0.000; K_VD_R: 0.000; E_FREI_39: 1|30.00|20.00|0.000000|0.000000|-1; K_LISTVALUE: 1.0; N_FREI_62: 0; N_FREI_75: """""""""""""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;"""""""""""""""; N_FREI_76: """""""""""""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""""""""""; N_FREI_77: """""""""""""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""""""""""
Ablufttellerventil LVS | Půdorys 1.NP | 0 | Bodový prvek | Ablufttellerventil LVS | 120 | 1001 | 1/0/0/0/180.0/0/0/125.0000/0/125.0000/-1/ | 1001/30/-1/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/28.00/125.00/125.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/ | - | \\machn\allplan\v2018\std\prod\ess\l\auslaesse\lüftungsventile\ | Mat_12 | Mineralwolle/100.00 | 125 | 0.000 | 120.00 | ? | Mat_12 | VV.03.3068 | Nadzemní podlaží 1.NP | K1.02 | 0.164 | 0.05 | 164 mm | 125 mm | A1 | 50 m3/hod | 1,3 m/s | 6782BP_0798486167 | Kus | NEMSOK - Index kóty: 0; K_LVZNR: K_LVZNR; K_Z_KOORD: M.2; A_ZETA_EBT: 0.00; L_LP_AIR_TYPE: 1; L_FREI_24: 0|0|0|0|0||; K_SYSTEMTYPE: 1; K_VD_TYPE: LP; K_MAXDELTAP: 0.000; K_DELTAP: 0.000; K_ZETA: 0.000; K_RWERT: 0.000; K_VD_DG: 0.000; K_VD_DN: 0.000; K_VD_DI: 0.000; K_VD_DA: 0.000; K_VD_A: 0.000; K_VD_B: 0.000; K_VD_QFORM: -1|0|2||0|; K_VD_ADN: 125.000; K_VD_BDN: 0.000; K_VD_V: 0.000; K_VD_R: 0.000; E_FREI_39: 1|30.00|20.00|0.000000|0.000000|-1; K_LISTVALUE: 1.0; N_FREI_62: 0; N_FREI_75: """""""""""""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;"""""""""""""""; N_FREI_76: """""""""""""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""""""""""; N_FREI_77: """""""""""""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""""""""""
Ablufttellerventil LVS | Půdorys 1.NP | 0.028 | Konstrukce v aktuální hladině | Ablufttellerventil LVS | 30 | 1000 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/1/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/1/ | 1000/30/1/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/160.00/160.00/28.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | L.1 | ${PROD}l\auslässe\lüftungsventile\ | Plech ST37 pozink/0.70 |  | 1 | 0.00 | 120.000 | 2023/01/11 | Plech ST37 pozink | VV.03.3080 | Nadzemní podlaží 1.NP | K1.14B | 0.19 | 0.05 | 190 mm | 160 mm | A1 | 50 m3/hod | 1,3 m/s | 6782Obj0798486232 | Stk | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa) | SB 20/SB 20/// | 28 | 160x160 | 1 | 0 | NEMSOK - A_ZETA_EBT: 0.00; L_LP_AIR_TYPE: 1; L_FREI_24: 0|0|0|0|0||; K_SYSTEMTYPE: 1; K_VD_TYPE: LP; K_MAXDELTAP: 0.000; K_DELTAP: 0.000; K_ZETA: 0.000; K_RWERT: 0.000; K_VD_DG: 0.000; K_VD_DN: 0.000; K_VD_DI: 0.000; K_VD_DA: 0.000; K_VD_A: 0.000; K_VD_B: 0.000; K_VD_QFORM: -1|0|2||0|; K_VD_ADN: 125.000; K_VD_BDN: 0.000; K_VD_V: 0.000; K_VD_R: 0.000; E_FREI_39: 1|30.00|20.00|0.000000|0.000000|-1; N_FREI_62: 0; N_FREI_75: """""""""""""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;"""""""""""""""; N_FREI_76: """""""""""""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""""""""""; N_FREI_77: """""""""""""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""""""""""; K_EBT_BOX_WC: 40301.021|-5506.482|2644.129|39723.985|-6083.518|2521.371|0.000|0.000|0.000|1.000
Ablufttellerventil LVS | Půdorys 1.NP | 0 | Bodový prvek | Ablufttellerventil LVS | 120 | 1001 | 1/0/0/0/180.0/0/0/125.0000/0/125.0000/-1/ | 1001/30/-1/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/28.00/125.00/125.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/ | - | \\machn\allplan\v2018\std\prod\ess\l\auslaesse\lüftungsventile\ | Mat_12 |  | 125 | 0.000 | 120.00 | ? | Mat_12 | VV.03.3069 | Nadzemní podlaží 1.NP | K1.14 | 0.164 | 0.05 | 164 mm | 125 mm | A1 | 30 m3/hod | 0,9 m/s | 6782BP_0798486174 | Kus | NEMSOK - Index kóty: 0; K_LVZNR: K_LVZNR; K_Z_KOORD: M.2; A_ZETA_EBT: 0.00; L_LP_AIR_TYPE: 1; L_FREI_24: 0|0|0|0|0||; K_SYSTEMTYPE: 1; K_VD_TYPE: LP; K_MAXDELTAP: 0.000; K_DELTAP: 0.000; K_ZETA: 0.000; K_RWERT: 0.000; K_VD_DG: 0.000; K_VD_DN: 0.000; K_VD_DI: 0.000; K_VD_DA: 0.000; K_VD_A: 0.000; K_VD_B: 0.000; K_VD_QFORM: -1|0|2||0|; K_VD_ADN: 125.000; K_VD_BDN: 0.000; K_VD_V: 0.000; K_VD_R: 0.000; E_FREI_39: 1|30.00|20.00|0.000000|0.000000|-1; K_LISTVALUE: 1.0; N_FREI_62: 0; N_FREI_75: """""""""""""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;"""""""""""""""; N_FREI_76: """""""""""""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""""""""""; N_FREI_77: """""""""""""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""""""""""
Ablufttellerventil LVS | Půdorys 1.NP | 0 | Bodový prvek | Ablufttellerventil LVS | 120 | 1001 | 1/0/0/0/180.0/0/0/125.0000/0/125.0000/-1/ | 1001/30/-1/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/28.00/125.00/125.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/0.00/ | - | \\machn\allplan\v2018\std\prod\ess\l\auslaesse\lüftungsventile\ | Mat_12 | Mineralwolle/100.00 | 125 | 0.000 | 120.00 | ? | Mat_12 | VV.03.3063 | Nadzemní podlaží 1.NP | 1.01 | 0.164 | 0.05 | 164 mm | 125 mm | A1 | 50 m3/hod | 1,3 m/s | 6782BP_0798478971 | Kus | NEMSOK - Index kóty: 0; K_LVZNR: K_LVZNR; K_Z_KOORD: M.2; A_ZETA_EBT: 0.00; L_LP_AIR_TYPE: 1; L_FREI_24: 0|0|0|0|0||; K_SYSTEMTYPE: 1; K_VD_TYPE: LP; K_MAXDELTAP: 0.000; K_DELTAP: 0.000; K_ZETA: 0.000; K_RWERT: 0.000; K_VD_DG: 0.000; K_VD_DN: 0.000; K_VD_DI: 0.000; K_VD_DA: 0.000; K_VD_A: 0.000; K_VD_B: 0.000; K_VD_QFORM: -1|0|2||0|; K_VD_ADN: 125.000; K_VD_BDN: 0.000; K_VD_V: 0.000; K_VD_R: 0.000; E_FREI_39: 1|30.00|20.00|0.000000|0.000000|-1; K_LISTVALUE: 1.0; N_FREI_62: 0; N_FREI_75: """""""""""""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;"""""""""""""""; N_FREI_76: """""""""""""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""""""""""; N_FREI_77: """""""""""""""0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0;0.0"""""""""""""""
