Properties of the parts of a building model (IFC2X3), part 38 of 51

# IfcFlowFitting (2887)
Name | In | Jednotka | Délka (m) | Označení | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_DIM | L_BES_DIM_A2 | L_BES_DIM_B2 | L_BES_DIM_A | K_VOLSTROM | K_MLH_GOST = K_MLD_GOST | K_LISTVALUE | Kód prvku | Třída reakce na oheň | Allright_Stavebni_dil_ID | Název_objektu | K_EBT_BOX_WC | Plocha | L_BES_LAENGE | K_INTERNAL_ISO | Tloušťka (m) | Součinitel tepelné vodivost
152042x2x3xxxxxxx | Půdorys 1.NP | Kus | 0.136 | 152042x2x3xxxxxxx | UEBERGANG ECK/RU Z | 20 | 1016 | 2/0/0/0/180.0/0/0/1.0000/200.0000/201.0000/1/135.9000/0/0/0/0/0/0/200.0000/200.0000/2/ | 50/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/35.00/100.00/201.00/200.00/200.00/135.90/0/0/-0.50/-0.50/29.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x201 | 200 | 200 | 200 | 0.000 | 0 | 1.000 m2 | IT.03.31076 | A2 | 6784Obj0000444113 | Objekt | 135.900/100.000/100.500/0.000/-100.000/-100.500/0.000/0.000/0.000/1.000 | 1 | 136 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.86; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 201; K_LISTVALUE_ISO: 1.000 m2
macro | Půdorys 1.NP | Kus | 0.31 |  | ABL Regler RN | 30 | 1016 | 2/-0.5000/0/0/180.0/0/0/1.0000/1.0000/1.0000/2/0.5000/0/0/0/0/0/1.0000/1.0000/1.0000/2/ | 1015/-1/2/0/0/0/0/1000/0/-1/356/-1/0/0/0/0/0/0/0/0/200.00/200.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 |  | DN200 | 1 | 1 | 1 | 0.000 | 0 | 1.0 | IT.03.31077 | A2 | 6784Obj0000444127 | Objekt | 42596.251/20795.117/3210.325/42286.251/20595.117/3010.325/0.000/0.000/0.000/1.000 | 1 | 310 | __ISO | 0.04 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_DP_EBT: 0.00; K_DATE: 2023/01/15; N_FREI_68: SPIRO POTRUBÍ
10152042x2x31xxxxxxx | Půdorys 1.NP | Kus | 0 | 10152042x2x31xxxxxxx | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/270.0/200.0000/200.0000/200.0000/2/141.4214/58.5786/0/45.0/0/270.0/200.0000/200.0000/200.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/270.00/0/200.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | IT.03.31078 | A2 | 6784Obj0000444130 | Objekt | 212.132/129.289/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x2x02x145xxxxx0 | Půdorys 1.NP | Kus | 0.323 | 252x2x02x145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/322.6208/200.0000/200.0000/2/322.6208/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/322.62/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.323 m | IT.03.31079 | A2 | 6784Obj0000444133 | Objekt | 322.621/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 0.323 | 323 | __ISO | 0.04 | 0,041 W/m.K
152042x2x323xxxxxx0 | Půdorys 1.NP | Kus | 0 | 152042x2x323xxxxxx0 | BOGEN RUND | 20 | 1016 | 2/0/0/0/180.0/0/90.0/200.0000/200.0000/200.0000/2/141.4214/58.5786/0/45.0/0/90.0/200.0000/200.0000/200.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/90.00/0/200.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | IT.03.31080 | A2 | 6784Obj0000444136 | Objekt | 212.132/129.289/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1 |  | __ISO | 0.04 | 0,041 W/m.K
252x2x02x145xxxxx0 | Půdorys 1.NP | Kus | 1.344 | 252x2x02x145xxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1343.8000/200.0000/200.0000/2/1343.8000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/1343.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.344 m | IT.03.31081 | A2 | 6784Obj0000444139 | Objekt | 1343.800/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 | 1.344 | 1344 | __ISO | 0.04 | 0,041 W/m.K
211048x14x0505012501x90125xxxx | Půdorys 2.NP | m2 | 0 | 211048x14x0505012501x90125xxxx | BOGEN ASY. | 20 | 21 | 2/0/0/0/180.0/0/180.0/800.0000/800.0000/1250.0000/1/850.0000/550.0000/0/90.0/0/90.0/1.0000/1250.0000/1400.0000/1/ | 21/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/800.00/1400.00/0/50.00/50.00/1250.00/100.00/90.00/180.00/2.00/1250.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/1.00 | SB 30/SB 30/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 800x1250 | 1250 | 1400 | 800 | 0.000 | 0 | 13.020 m2 | TA.04.30001 | A1 | 6792Obj0000000005 | Objekt | NEMSOK - K_POSITION: L.14; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1250; Podlaží: Nadzemní podlaží 2.NP; Průměr: -; Šířka: 0.8 m; Výška: 1.25 m; Teplonosná látka: -
1x0104125014x5xxxxxxx | Půdorys 2.NP | Kus | 0 | 1x0104125014x5xxxxxxx | BOGEN ASY. | 20 | 1016 | 2/0/0/0/180.0/0/180.0/800.0000/800.0000/1250.0000/1/850.0000/550.0000/0/90.0/0/90.0/1.0000/1250.0000/1400.0000/1/ | 21/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/800.00/1400.00/0/50.00/50.00/1250.00/100.00/90.00/180.00/2.00/1250.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/1.00 | SB 30/SB 30/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 800x1250 | 1250 | 1400 | 800 | 0.000 | 0 | 13.020 m2 | IT.04.30002 | A2 | 6794Obj0000000202 | Objekt | 1570.000/550.000/645.000/0.000/-420.000/-645.000/0.000/0.000/0.000/1.000 | 13.02 |  | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.14; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1250
211048x14x0505012501x90125xxxx | Půdorys 2.NP | Kus | 0.54 | 211048x14x0505012501x90125xxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/800.0000/1250.0000/1/540.0000/0/0/0/0/0/1.0000/800.0000/1250.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/800.00/1250.00/540.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/1.00 | SB 30/SB 30/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 800x1250 | 800 | 1250 | 800 | 0.000 | 0 | 2.210 m2 | IT.04.30003 | A2 | 6794Obj0000000216 | Objekt | 540.000/420.000/645.000/0.000/-420.000/-645.000/0.000/0.000/0.000/1.000 | 2.21 | 540 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.15; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1250
101048x125054xxxxxxx | Půdorys 2.NP | Kus | 0.5 | 101048x125054xxxxxxx | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/1250.0000/1400.0000/1/500.0000/0/0/0/0/0/1.0000/1250.0000/1400.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/1250.00/1400.00/500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/1.00 | SB 30/SB 30/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1250x1400 | 1250 | 1400 | 1250 | 0.000 | 0 | 2.650 m2 | IT.04.30001 | A2 | 6794Obj0000000230 | Konstrukce v aktuální hladině | 500.000/645.000/720.000/0.000/-645.000/-720.000/0.000/0.000/0.000/1.000 | 2.65 | 500 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_POSITION: L.17; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1400
10104125014x5xxxxxxx0 | Půdorys 2.NP | Kus | 0.725 | 10104125014x5xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/725.0000/250.0000/250.0000/2/725.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/725.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | POZINK/0.00 | //// | Mineralwolle/100.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/POZINK/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.725 m | IT.04.30004 | B | 6794Obj0000000011 | Objekt | 725.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 725 | __ISO | 0.1 | 0,041 W/m.K
502162505x701x250250250352125125 | Půdorys 2.NP | Kus | 0.333 | 502162505x701x250250250352125125 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/333.0000/200.0000/200.0000/2/333.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/333.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.333 m | IT.04.30005 | B | 6794Obj0000000017 | Objekt | 333.000/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 |  | 333 | __ISO | 0.1 | 0,041 W/m.K
152042x2x333xxxxxx0 | Půdorys 2.NP | Kus | 0.517 | 152042x2x333xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/517.0000/200.0000/200.0000/2/517.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/517.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 0.517 m | IT.04.30006 | B | 6794Obj0000000019 | Objekt | 517.000/100.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 |  | 517 | __ISO | 0.1 | 0,041 W/m.K
1x010359508x5xxxxxxx | Půdorys střechy | Kus | 0.1 | 1x010359508x5xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.100 m | IT.05.30001 | A2 | 6884Obj0000000003 | Objekt | 100.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.141 m2
1015204250250315xxxxxx0 | Půdorys střechy | Kus | 0.1 | 1015204250250315xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.100 m | IT.05.30002 | A2 | 6884Obj0000000005 | Objekt | 100.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.141 m2
1015204250250315xxxxxx0 | Půdorys střechy | Kus | 0.1 | 1015204250250315xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.100 m | IT.05.30003 | A2 | 6884Obj0000000007 | Objekt | 100.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.141 m2
1015204250250315xxxxxx0 | Půdorys střechy | Kus | 0.1 | 1015204250250315xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.100 m | IT.05.30004 | A2 | 6884Obj0000000009 | Objekt | 100.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.141 m2
1015204250250315xxxxxx0 | Půdorys střechy | Kus | 0.1 | 1015204250250315xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.100 m | IT.05.30005 | A2 | 6884Obj0000000011 | Objekt | 100.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.141 m2
1015204250250315xxxxxx0 | Půdorys střechy | Kus | 0.1 | 1015204250250315xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.100 m | IT.05.30006 | A2 | 6884Obj0000000013 | Objekt | 100.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.141 m2
1015204250250315xxxxxx0 | Půdorys střechy | Kus | 1.1 | 1015204250250315xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1100.0000/250.0000/250.0000/2/1100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/1100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.100 m | IT.05.30007 | A2 | 6884Obj0000000015 | Konstrukce v aktuální hladině | 1100.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 1100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 1.555 m2
1520425025011xxxxxxx0 | Půdorys střechy | Kus | 1.1 | 1520425025011xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1100.0000/250.0000/250.0000/2/1100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/1100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.100 m | IT.05.30008 | A2 | 6884Obj0000000017 | Objekt | 1100.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 1100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 1.555 m2
1520425025011xxxxxxx0 | Půdorys střechy | Kus | 1.1 | 1520425025011xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1100.0000/250.0000/250.0000/2/1100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/1100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.100 m | IT.05.30009 | A2 | 6884Obj0000000019 | Objekt | 1100.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 1100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 1.555 m2
1520425025011xxxxxxx0 | Půdorys střechy | Kus | 1.1 | 1520425025011xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1100.0000/250.0000/250.0000/2/1100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/1100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.100 m | IT.05.30010 | A2 | 6884Obj0000000021 | Objekt | 1100.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 1100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 1.555 m2
1520425025011xxxxxxx0 | Půdorys střechy | Kus | 1.1 | 1520425025011xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1100.0000/250.0000/250.0000/2/1100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/1100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.100 m | IT.05.30011 | A2 | 6884Obj0000000023 | Objekt | 1100.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 1100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 1.555 m2
1520425025011xxxxxxx0 | Půdorys střechy | Kus | 1.1 | 1520425025011xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1100.0000/250.0000/250.0000/2/1100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/1100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.100 m | IT.05.30012 | A2 | 6884Obj0000000025 | Objekt | 1100.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 1100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 1.555 m2
1015204250250315xxxxxx0 | Půdorys střechy | Kus | 0.1 | 1015204250250315xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.100 m | IT.07.30001 | A2 | 6884Obj0000000027 | Objekt | 100.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.141 m2
1015204250250315xxxxxx0 | Půdorys střechy | Kus | 0.1 | 1015204250250315xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.100 m | IT.07.30002 | A2 | 6884Obj0000000029 | Objekt | 100.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.141 m2
1015204250250315xxxxxx0 | Půdorys střechy | Kus | 0.1 | 1015204250250315xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.100 m | IT.07.30003 | A2 | 6884Obj0000000031 | Objekt | 100.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.141 m2
1015204250250315xxxxxx0 | Půdorys střechy | Kus | 0.1 | 1015204250250315xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.100 m | IT.07.30004 | A2 | 6884Obj0000000033 | Objekt | 100.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.141 m2
1015204250250315xxxxxx0 | Půdorys střechy | Kus | 0.1 | 1015204250250315xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.100 m | IT.07.30005 | A2 | 6884Obj0000000035 | Objekt | 100.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.141 m2
1015204250250315xxxxxx0 | Půdorys střechy | Kus | 0.1 | 1015204250250315xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.100 m | IT.07.30006 | A2 | 6884Obj0000000037 | Objekt | 100.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.141 m2
1015204250250315xxxxxx0 | Půdorys střechy | Kus | 0.1 | 1015204250250315xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.100 m | IT.07.30007 | A2 | 6884Obj0000000039 | Objekt | 100.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.141 m2
1015204250250315xxxxxx0 | Půdorys střechy | Kus | 0.1 | 1015204250250315xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.100 m | IT.07.30008 | A2 | 6884Obj0000000041 | Objekt | 100.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.141 m2
1015204250250315xxxxxx0 | Půdorys střechy | Kus | 0.1 | 1015204250250315xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.100 m | IT.07.30009 | A2 | 6884Obj0000000043 | Objekt | 100.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.141 m2
1015204250250315xxxxxx0 | Půdorys střechy | Kus | 0.1 | 1015204250250315xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.100 m | IT.07.30010 | A2 | 6884Obj0000000045 | Objekt | 100.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.141 m2
1015204250250315xxxxxx0 | Půdorys střechy | Kus | 0.1 | 1015204250250315xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.100 m | IT.07.30011 | A2 | 6884Obj0000000047 | Objekt | 100.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.141 m2
1015204250250315xxxxxx0 | Půdorys střechy | Kus | 0.1 | 1015204250250315xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.100 m | IT.07.30012 | A2 | 6884Obj0000000049 | Objekt | 100.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.141 m2
1015204250250315xxxxxx0 | Půdorys střechy | Kus | 1.1 | 1015204250250315xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1100.0000/250.0000/250.0000/2/1100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/1100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.100 m | IT.07.30013 | A2 | 6884Obj0000000051 | Objekt | 1100.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 1100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 1.555 m2
1520425025011xxxxxxx0 | Půdorys střechy | Kus | 1.1 | 1520425025011xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1100.0000/250.0000/250.0000/2/1100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/1100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.100 m | IT.07.30014 | A2 | 6884Obj0000000053 | Objekt | 1100.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 1100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 1.555 m2
1520425025011xxxxxxx0 | Půdorys střechy | Kus | 1.1 | 1520425025011xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1100.0000/250.0000/250.0000/2/1100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/1100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.100 m | IT.07.30015 | A2 | 6884Obj0000000055 | Objekt | 1100.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 1100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 1.555 m2
1520425025011xxxxxxx0 | Půdorys střechy | Kus | 1.1 | 1520425025011xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1100.0000/250.0000/250.0000/2/1100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/1100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.100 m | IT.07.30016 | A2 | 6884Obj0000000057 | Objekt | 1100.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 1100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 1.555 m2
1520425025011xxxxxxx0 | Půdorys střechy | Kus | 1.1 | 1520425025011xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1100.0000/250.0000/250.0000/2/1100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/1100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.100 m | IT.07.30017 | A2 | 6884Obj0000000059 | Objekt | 1100.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 1100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 1.555 m2
1520425025011xxxxxxx0 | Půdorys střechy | Kus | 1.1 | 1520425025011xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1100.0000/250.0000/250.0000/2/1100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/1100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.100 m | IT.07.30018 | A2 | 6884Obj0000000061 | Objekt | 1100.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 1100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 1.555 m2
1520425025011xxxxxxx0 | Půdorys střechy | Kus | 1.1 | 1520425025011xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1100.0000/250.0000/250.0000/2/1100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/1100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.100 m | IT.07.30019 | A2 | 6884Obj0000000063 | Objekt | 1100.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 1100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 1.555 m2
1520425025011xxxxxxx0 | Půdorys střechy | Kus | 1.1 | 1520425025011xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1100.0000/250.0000/250.0000/2/1100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/1100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.100 m | IT.07.30020 | A2 | 6884Obj0000000065 | Objekt | 1100.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 1100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 1.555 m2
1520425025011xxxxxxx0 | Půdorys střechy | Kus | 1.1 | 1520425025011xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1100.0000/250.0000/250.0000/2/1100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/1100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.100 m | IT.07.30021 | A2 | 6884Obj0000000067 | Objekt | 1100.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 1100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 1.555 m2
1520425025011xxxxxxx0 | Půdorys střechy | Kus | 1.1 | 1520425025011xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1100.0000/250.0000/250.0000/2/1100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/1100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.100 m | IT.07.30022 | A2 | 6884Obj0000000069 | Objekt | 1100.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 1100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 1.555 m2
1520425025011xxxxxxx0 | Půdorys střechy | Kus | 1.1 | 1520425025011xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1100.0000/250.0000/250.0000/2/1100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/1100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.100 m | IT.07.30023 | A2 | 6884Obj0000000071 | Objekt | 1100.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 1100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 1.555 m2
1520425025011xxxxxxx0 | Půdorys střechy | Kus | 1.1 | 1520425025011xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/1100.0000/250.0000/250.0000/2/1100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/1100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 1.100 m | IT.07.30024 | A2 | 6884Obj0000000073 | Objekt | 1100.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 1100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 1.555 m2
1015204250250315xxxxxx0 | Půdorys střechy | Kus | 0.1 | 1015204250250315xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.100 m | IT.08.30001 | A2 | 6884Obj0000000075 | Objekt | 100.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.141 m2
1015204250250315xxxxxx0 | Půdorys střechy | Kus | 0.1 | 1015204250250315xxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.100 m | IT.08.30002 | A2 | 6884Obj0000000077 | Objekt | 100.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.141 m2
1520425025011xxxxxxx0 | Půdorys střechy | Kus | 0.1 | 1520425025011xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/100.0000/250.0000/250.0000/2/100.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.100 m | IT.08.30003 | A2 | 6884Obj0000000079 | Objekt | 100.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 100 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 0.141 m2
1520425025011xxxxxxx0 | Půdorys střechy | Kus | 0.94 | 1520425025011xxxxxxx0 | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/940.0000/250.0000/250.0000/2/940.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/940.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.940 m | IT.08.30004 | A2 | 6884Obj0000000081 | Objekt | 940.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 940 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 1.329 m2
1520425025094xxxxxxx | Půdorys střechy | Kus | 0.94 | 1520425025094xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/940.0000/250.0000/250.0000/2/940.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/940.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.940 m | IT.08.30005 | A2 | 6884Obj0000000083 | Objekt | 940.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 940 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 1.329 m2
1520425025094xxxxxxx | Půdorys střechy | Kus | 0.94 | 1520425025094xxxxxxx | ROHR | 20 | 1016 | 2/0/0/0/180.0/0/0/940.0000/250.0000/250.0000/2/940.0000/0/0/0/0/0/250.0000/250.0000/250.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/940.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN250 | 250 | 250 | 250 | 0.000 | 0 | 0.940 m | IT.08.30006 | A2 | 6884Obj0000000085 | Objekt | 940.000/125.000/125.000/0.000/-125.000/-125.000/0.000/0.000/0.000/1.000 |  | 940 | __ISO | 0.1 | 0,041 W/m.K | NEMSOK - K_LISTVALUE_ISO: 1.329 m2

# IfcFlowSegment (1090)
NEMSOK - V6: 0 m; V7: 0 m; V8: 0 m; V9: 0; K_GEWERK: 1; K_MLH_GOST: 0; K_MLD_GOST: 0; Třída reakce na oheň: A1
Name | In | Jednotka | Délka (m) | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_LAENGE | L_BES_DIM | L_BES_DIM_A2 = L_BES_DIM_A | L_BES_DIM_B2 | K_VOLSTROM | K_LISTVALUE | Kód prvku | Podlaží | Průměr | Teplonosná látka | Allright_Stavebni_dil_ID | Název_objektu | Označení | K_LISTVALUE_ISO
 | Půdorys 1.PP | m2 | 0.895 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/1250.0000/710.0000/1/895.0000/0/0/0/0/0/1.0000/1250.0000/710.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/1250.00/710.00/895.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/1.00 | SB 30/SB 30/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 895 | 1250x710 | 1250 | 710 | 0.000 | 3.510 m2 | PO.02.30001 | Podzemní podlaží 1.PP | - | - | 6772Obj0000000503 | Objekt | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 710; Šířka: 1.25 m; Výška: 0.71 m
101048x125019xxxxxxx | Půdorys 1.PP | m2 | 0.19 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/800.0000/1250.0000/1/190.0000/0/0/0/0/0/1.0000/800.0000/1250.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/800.00/1250.00/190.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/1.00 | SB 30/SB 30/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 190 | 800x1250 | 800 | 1250 | 0.000 | 1.000 m2 | PO.02.30002 | Podzemní podlaží 1.PP | - | - | 6772Obj0000000505 | Objekt | 101048x125019xxxxxxx | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1250; Šířka: 0.8 m; Výška: 1.25 m
101058x5x1xxxxxxx0 | Půdorys 1.PP | m2 | 0.1 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/800.0000/500.0000/1/100.0000/0/0/0/0/0/1.0000/800.0000/500.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/800.00/500.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 100 | 800x500 | 800 | 500 | 0.000 | 1.000 m2 | PO.02.30003 | Podzemní podlaží 1.PP | - | - | 6772Obj0000000562 | Objekt | 101058x5x1xxxxxxx0 | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 500; Šířka: 0.8 m; Výška: 0.5 m
101045603551xxxxxxx0 | Půdorys 1.PP | m2 | 0.1 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/355.0000/1/100.0000/0/0/0/0/0/1.0000/560.0000/355.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/355.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 100 | 560x355 | 560 | 355 | 0.000 | 1.000 m2 | PO.02.30004 | Podzemní podlaží 1.PP | - | - | 6772Obj0000000572 | Objekt | 101045603551xxxxxxx0 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355; Šířka: 0.56 m; Výška: 0.355 m
101045603551xxxxxxx0 | Půdorys 1.PP | m2 | 0.1 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/355.0000/1/100.0000/0/0/0/0/0/1.0000/560.0000/355.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/355.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 100 | 560x355 | 560 | 355 | 0.000 | 1.000 m2 | PO.02.30005 | Podzemní podlaží 1.PP | - | - | 6772Obj0000000573 | Objekt | 101045603551xxxxxxx0 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355; Šířka: 0.56 m; Výška: 0.355 m
1010556035519xxxxxxx | Půdorys 1.PP | m2 | 0.19 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/355.0000/1/190.0000/0/0/0/0/0/1.0000/560.0000/355.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/355.00/190.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 190 | 560x355 | 560 | 355 | 0.000 | 1.000 m2 | PO.02.30006 | Podzemní podlaží 1.PP | - | - | 6772Obj0000000575 | Objekt | 1010556035519xxxxxxx | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355; Šířka: 0.56 m; Výška: 0.355 m
10105560355705xxxxxx0 | Půdorys 1.PP | m2 | 0.705 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/355.0000/1/705.0000/0/0/0/0/0/1.0000/560.0000/355.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/355.00/705.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 705 | 560x355 | 560 | 355 | 0.000 | 1.290 m2 | PO.02.30007 | Podzemní podlaží 1.PP | - | - | 6772Obj0000000582 | Objekt | 10105560355705xxxxxx0 | NEMSOK - K_POSITION: L.15; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355; Šířka: 0.56 m; Výška: 0.355 m
10103556035525xxxxxxx | Půdorys 1.PP | m2 | 0.25 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/355.0000/1/250.0000/0/0/0/0/0/1.0000/560.0000/355.0000/1/ | 10/30/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/355.00/250.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 250 | 560x355 | 560 | 355 | 0.000 | 1.000 m2 | PO.02.30008 | Podzemní podlaží 1.PP | - | - | 6772Obj0000000740 | Objekt | 10103556035525xxxxxxx | NEMSOK - K_POSITION: L.6; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355; Šířka: 0.56 m; Výška: 0.355 m; K_DP_EBT: 1 mm
101058x5x1xxxxxxx0 | Půdorys 1.PP | m2 | 0.1 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/800.0000/500.0000/1/100.0000/0/0/0/0/0/1.0000/800.0000/500.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/800.00/500.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 100 | 800x500 | 800 | 500 | 0.000 | 1.000 m2 | PO.02.30009 | Podzemní podlaží 1.PP | - | - | 6772Obj0000000744 | Objekt | 101058x5x1xxxxxxx0 | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 500; Šířka: 0.8 m; Výška: 0.5 m
101055604x1xxxxxxx0 | Půdorys 1.PP | m2 | 0.1 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/100.0000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 100 | 560x400 | 560 | 400 | 0.000 | 1.000 m2 | PO.02.30010 | Podzemní podlaží 1.PP | - | - | 6772Obj0000135605 | Objekt | 101055604x1xxxxxxx0 | NEMSOK - K_POSITION: L.5; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Šířka: 0.56 m; Výška: 0.4 m
101058x5x1xxxxxxx0 | Půdorys 1.PP | m2 | 0.1 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/800.0000/500.0000/1/100.0000/0/0/0/0/0/1.0000/800.0000/500.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/800.00/500.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 100 | 800x500 | 800 | 500 | 0.000 | 1.000 m2 | PO.02.30011 | Podzemní podlaží 1.PP | - | - | 6772Obj0000135806 | Konstrukce v aktuální hladině | 101058x5x1xxxxxxx0 | NEMSOK - K_POSITION: L.12; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 500; Šířka: 0.8 m; Výška: 0.5 m
101055604x982xxxxxx0 | Půdorys 1.PP | m2 | 0.982 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/981.5000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/981.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 982 | 560x400 | 560 | 400 | 0.000 | 1.880 m2 | PO.02.30012 | Podzemní podlaží 1.PP | - | - | 6772Obj0000135828 | Objekt | 101055604x982xxxxxx0 | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Šířka: 0.56 m; Výška: 0.4 m
152041251253xxxxxxx | Půdorys 1.PP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.02.30013 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000135903 | Objekt | 152041251253xxxxxxx
152041251253xxxxxxx | Půdorys 1.PP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.02.30014 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000135905 | Objekt | 152041251253xxxxxxx
1520412512567xxxxxx0 | Půdorys 1.PP | m | 0.067 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/67.4175/125.0000/125.0000/2/67.4175/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/67.42/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 67 | DN125 | 125 | 125 | 0.000 | 0.067 m | PO.02.30015 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000136013 | Objekt | 1520412512567xxxxxx0
101044x56029xxxxxxx | Půdorys 1.PP | m2 | 0.29 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/400.0000/560.0000/1/290.0000/0/0/0/0/0/1.0000/400.0000/560.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/560.00/290.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 290 | 400x560 | 400 | 560 | 0.000 | 1.000 m2 | PO.02.30016 | Podzemní podlaží 1.PP | - | - | 6772Obj0000136217 | Objekt | 101044x56029xxxxxxx | NEMSOK - K_POSITION: L.27; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 560; Šířka: 0.4 m; Výška: 0.56 m
15206125125177xxxxxx0 | Půdorys 1.PP | m | 0.177 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/177.4175/125.0000/125.0000/2/177.4175/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/177.42/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 177 | DN125 | 125 | 125 | 0.000 | 0.177 m | PO.02.30017 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000136653 | Objekt | 15206125125177xxxxxx0
1520612512592xxxxxx0 | Půdorys 1.PP | m | 0.092 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/91.6117/125.0000/125.0000/2/91.6117/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/91.61/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 92 | DN125 | 125 | 125 | 0.000 | 0.092 m | PO.02.30018 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000136685 | Objekt | 1520612512592xxxxxx0
152041251253xxxxxxx | Půdorys 1.PP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.02.30019 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000136752 | Objekt | 152041251253xxxxxxx
1520412512564xxxxxxx | Půdorys 1.PP | m | 0.64 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/639.8000/125.0000/125.0000/2/639.8000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/639.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 640 | DN125 | 125 | 125 | 0.000 | 0.640 m | PO.02.30020 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000136762 | Objekt | 1520412512564xxxxxxx
101055604x266xxxxxx0 | Půdorys 1.PP | m2 | 0.266 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/265.9000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/265.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 266 | 560x400 | 560 | 400 | 0.000 | 1.000 m2 | PO.02.30021 | Podzemní podlaží 1.PP | - | - | 6772Obj0000136875 | Objekt | 101055604x266xxxxxx0 | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Šířka: 0.56 m; Výška: 0.4 m
15206160160181xxxxxx0 | Půdorys 1.PP | m | 0.181 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/180.7000/160.0000/160.0000/2/180.7000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/180.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 181 | DN160 | 160 | 160 | 0.000 | 0.181 m | PO.02.30022 | Podzemní podlaží 1.PP | 160 mm | - | 6772Obj0000136984 | Objekt | 15206160160181xxxxxx0
15206160160117xxxxxx0 | Půdorys 1.PP | m | 0.117 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/116.5000/160.0000/160.0000/2/116.5000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/116.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 117 | DN160 | 160 | 160 | 0.000 | 0.117 m | PO.02.30023 | Podzemní podlaží 1.PP | 160 mm | - | 6772Obj0000136999 | Objekt | 15206160160117xxxxxx0
1520622422418xxxxxxx | Půdorys 1.PP | m | 0.18 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/179.5000/224.0000/224.0000/2/179.5000/0/0/0/0/0/224.0000/224.0000/224.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/224.00/224.00/179.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 180 | DN224 | 224 | 224 | 0.000 | 0.179 m | PO.02.30024 | Podzemní podlaží 1.PP | 224 mm | - | 6772Obj0000137004 | Objekt | 1520622422418xxxxxxx
1520622422497xxxxxx0 | Půdorys 1.PP | m | 0.097 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/96.6000/224.0000/224.0000/2/96.6000/0/0/0/0/0/224.0000/224.0000/224.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/224.00/224.00/96.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 97 | DN224 | 224 | 224 | 0.000 | 0.097 m | PO.02.30025 | Podzemní podlaží 1.PP | 224 mm | - | 6772Obj0000137009 | Objekt | 1520622422497xxxxxx0
152051251255xxxxxxx0 | Půdorys 1.PP | m | 0.5 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/500.0000/125.0000/125.0000/2/500.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 500 | DN125 | 125 | 125 | 0.000 | 0.500 m | PO.02.30026 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000137024 | Objekt | 152051251255xxxxxxx0
152041601603xxxxxxx | Půdorys 1.PP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/160.0000/160.0000/2/30.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN160 | 160 | 160 | 0.000 | 0.030 m | PO.02.30027 | Podzemní podlaží 1.PP | 160 mm | - | 6772Obj0000137110 | Objekt | 152041601603xxxxxxx
15205125125116xxxxxx0 | Půdorys 1.PP | m | 0.116 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/116.1883/125.0000/125.0000/2/116.1883/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/116.19/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 116 | DN125 | 125 | 125 | 0.000 | 0.116 m | PO.02.30028 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000137127 | Objekt | 15205125125116xxxxxx0
15205125125133xxxxxx0 | Půdorys 1.PP | m | 0.133 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/132.9697/125.0000/125.0000/2/132.9697/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/132.97/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 133 | DN125 | 125 | 125 | 0.000 | 0.133 m | PO.02.30029 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000137137 | Objekt | 15205125125133xxxxxx0
15205125125116xxxxxx0 | Půdorys 1.PP | m | 0.116 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/116.1768/125.0000/125.0000/2/116.1768/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/116.18/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 116 | DN125 | 125 | 125 | 0.000 | 0.116 m | PO.02.30030 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000137147 | Objekt | 15205125125116xxxxxx0
15205125125133xxxxxx0 | Půdorys 1.PP | m | 0.133 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/132.9697/125.0000/125.0000/2/132.9697/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/132.97/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 133 | DN125 | 125 | 125 | 0.000 | 0.133 m | PO.02.30031 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000137149 | Objekt | 15205125125133xxxxxx0
1520516016013xxxxxxx | Půdorys 1.PP | m | 0.13 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/130.2944/160.0000/160.0000/2/130.2944/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/130.29/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 130 | DN160 | 160 | 160 | 0.000 | 0.130 m | PO.02.30032 | Podzemní podlaží 1.PP | 160 mm | - | 6772Obj0000137155 | Objekt | 1520516016013xxxxxxx
 | Půdorys 1.PP | m | 1.767 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1767.2000/160.0000/160.0000/2/1767.2000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/1767.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1767 | DN160 | 160 | 160 | 0.000 | 1.767 m | PO.02.30033 | Podzemní podlaží 1.PP | 160 mm | - | 6772Obj0000137181 | Objekt
15205224224941xxxxxx0 | Půdorys 1.PP | m | 0.941 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/940.6000/224.0000/224.0000/2/940.6000/0/0/0/0/0/224.0000/224.0000/224.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/224.00/224.00/940.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 941 | DN224 | 224 | 224 | 0.000 | 0.941 m | PO.02.30034 | Podzemní podlaží 1.PP | 224 mm | - | 6772Obj0000137201 | Objekt | 15205224224941xxxxxx0
