Properties of the parts of a building model (IFC2X3), part 4 of 51

# IfcFlowFitting (2887)
Name | In | Jednotka | Délka (m) | Označení | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_DIM | L_BES_DIM_A2 | L_BES_DIM_B2 | L_BES_DIM_A | K_VOLSTROM | K_MLH_GOST = K_MLD_GOST | K_LISTVALUE | Kód prvku | Třída reakce na oheň | Allright_Stavebni_dil_ID | Název_objektu | K_EBT_BOX_WC | Plocha | L_BES_LAENGE | K_INTERNAL_ISO | Tloušťka (m) | Součinitel tepelné vodivost
252041x01x19xxxxxx | Půdorys 1.PP | Kus | 0 | 252041x01x19xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/90.0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/0/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 |  | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 100 | 100 | 100 | 120.000 |  | 1.0 | TA.02.3002 | A1 | 6772Obj0000000597 | Objekt | NEMSOK - K_POSITION: L.1; L_BES_DIM_B: 100; Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
25204125012519xxxxxx | Půdorys 1.PP | Kus | 0 | 25204125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 |  | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 125 | 125 | 125 | 120.000 |  | 1.0 | TA.02.3003 | A1 | 6772Obj0000000612 | Objekt | NEMSOK - K_POSITION: L.1; L_BES_DIM_B: 125; Podlaží: Podzemní podlaží 1.PP; Průměr: DN100
252041x01x19xxxxxx | Půdorys 1.PP | Kus | 0 | 252041x01x19xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/90.0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/0/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 |  | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 100 | 100 | 100 | 120.000 |  | 1.0 | TA.02.3004 | A1 | 6772Obj0000000613 | Objekt | NEMSOK - K_POSITION: L.1; L_BES_DIM_B: 100; Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
25204125012519xxxxxx | Půdorys 1.PP | Kus | 0 | 25204125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 |  | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 125 | 125 | 125 | 120.000 |  | 1.0 | TA.02.3005 | A1 | 6772Obj0000000614 | Koleno | NEMSOK - K_POSITION: L.1; L_BES_DIM_B: 125; Podlaží: Podzemní podlaží 1.PP; Průměr: DN100
252x1x01x145xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1x01x145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/100.0000/100.0000/100.0000/2/70.7107/29.2893/0/45.0/0/0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/0/0/100.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 1.0 | TA.02.3010 | A1 | 6772Obj0000000626 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN100
252x1250125145xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | TA.02.3011 | A1 | 6772Obj0000000632 | Koleno | 132.583/80.806/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | NEMSOK - K_POSITION: L.1; Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125145xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | TA.02.3013 | A1 | 6772Obj0000000634 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252041x01x19xxxxxx | Půdorys 1.PP | Kus | 0 | 252041x01x19xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/90.0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/0/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 |  | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 100 | 100 | 100 | 120.000 |  | 1.0 | TA.02.3021 | A1 | 6772Obj0000000655 | Koleno | NEMSOK - K_POSITION: L.1; L_BES_DIM_B: 100; Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
25204125012519xxxxxx | Půdorys 1.PP | Kus | 0 | 25204125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 |  | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 125 | 125 | 125 | 120.000 |  | 1.0 | TA.02.3022 | A1 | 6772Obj0000000657 | Koleno | NEMSOK - K_POSITION: L.1; L_BES_DIM_B: 125; Podlaží: Podzemní podlaží 1.PP; Průměr: DN100
25204125012519xxxxxx | Půdorys 1.PP | Kus | 0 | 25204125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 |  | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 125 | 125 | 125 | 120.000 |  | 1.0 | TA.02.3025 | A1 | 6772Obj0000000793 | Koleno | NEMSOK - K_POSITION: L.1; L_BES_DIM_B: 125; Podlaží: Podzemní podlaží 1.PP; Průměr: DN100
252x125012516xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012516xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.3/125.0000/125.0000/125.0000/2/108.2532/62.5000/0/60.0/0/180.3/125.0000/125.0000/125.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.30/0/125.00/1.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3039 | A1 | 6772Obj0000000839 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x125012519xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3045 | A1 | 6772Obj0000000873 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x125012519xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3046 | A1 | 6772Obj0000000884 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x125012519xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3050 | A1 | 6772Obj0000000911 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x16x160145xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/178.3/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/178.3/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/178.30/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | TA.02.3091 | A1 | 6772Obj0000001070 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
252x16x160145xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/358.8/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/358.8/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/358.80/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | TA.02.3093 | A1 | 6772Obj0000001074 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
252x1250125145xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3100 | A1 | 6772Obj0000001094 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125145xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3102 | A1 | 6772Obj0000001098 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252041x01x19xxxxxx | Půdorys 1.PP | Kus | 0 | 252041x01x19xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/90.0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/0/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 |  | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 100 | 100 | 100 | 120.000 |  | 1.0 | TA.02.3110 | A1 | 6772Obj0000001128 | Koleno | NEMSOK - K_POSITION: L.1; L_BES_DIM_B: 100; Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
252x1x01x17xxxxxx | Půdorys 1.PP | Stk | 0 | 252x1x01x17xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/321.5/100.0000/100.0000/100.0000/2/94.1471/66.2905/0/70.3/0/321.5/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/321.50/0/100.00/1.00/70.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 1.0 | TA.02.3116 | A1 | 6772Obj0000001160 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN100
252x1x01x143xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1x01x143xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/52.0/100.0000/100.0000/100.0000/2/67.5590/26.2723/0/42.5/0/52.0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/52.00/0/100.00/1.00/42.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 1.0 | TA.02.3118 | A1 | 6772Obj0000001164 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN100
252x1250125138xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125138xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/352.0/125.0000/125.0000/125.0000/2/77.4724/26.9030/0/38.3/0/352.0/125.0000/125.0000/125.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/352.00/0/125.00/1.00/38.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | TA.02.3125 | A1 | 6772Obj0000001177 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125152xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125152xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/3.9/125.0000/125.0000/125.0000/2/98.6355/48.2143/0/52.1/0/3.9/125.0000/125.0000/125.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/3.90/0/125.00/1.00/52.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | TA.02.3127 | A1 | 6772Obj0000001181 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x16x160145xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/181.2/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/181.2/160.0000/160.0000/160.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/181.20/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.02.3130 | A1 | 6772Obj0000001187 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
252x16x160145xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0.8/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/0.8/160.0000/160.0000/160.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/0.80/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.02.3133 | A1 | 6772Obj0000001193 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
252x16x16019xxxxxx | Půdorys 1.PP | Stk | 0 | 252x16x16019xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/180.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/180.00/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.02.3141 | A1 | 6772Obj0000001234 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
25204125012519xxxxxx | Půdorys 1.PP | Kus | 0 | 25204125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 |  | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 125 | 125 | 125 | 120.000 |  | 1.0 | TA.02.3142 | A1 | 6772Obj0000001235 | Koleno | NEMSOK - K_POSITION: L.1; L_BES_DIM_B: 125; Podlaží: Podzemní podlaží 1.PP; Průměr: DN100
252x125012519xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3174 | A1 | 6772Obj0000001409 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125145xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3186 | A1 | 6772Obj0000001519 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x125012519xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3196 | A1 | 6772Obj0000001592 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1x01x19xxxxxx | Půdorys 1.PP | Stk | 0 | 252x1x01x19xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/356.8/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/356.8/100.0000/100.0000/100.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/356.80/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 0.000 | 0 | 1.0 | TA.02.3237 | A1 | 6772Obj0000002006 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN100
252x125012519xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3244 | A1 | 6772Obj0000002162 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125114xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125114xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/269.6/125.0000/125.0000/125.0000/2/30.0285/3.6604/0/13.9/0/269.6/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/269.60/0/125.00/1.00/13.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3246 | A1 | 6772Obj0000002172 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125114xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125114xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/89.6/125.0000/125.0000/125.0000/2/30.0285/3.6604/0/13.9/0/89.6/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/89.60/0/125.00/1.00/13.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3247 | A1 | 6772Obj0000002177 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
25204125012519xxxxxx | Půdorys 1.PP | Kus | 0 | 25204125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 |  | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 125 | 125 | 125 | 120.000 |  | 1.0 | TA.02.3261 | A1 | 6772Obj0000059672 | Koleno | NEMSOK - K_POSITION: L.1; L_BES_DIM_B: 125; Podlaží: Podzemní podlaží 1.PP; Průměr: DN100
252x125012519xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | TA.02.3264 | A1 | 6772Obj0000059689 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125115xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | TA.02.3266 | A1 | 6772Obj0000059699 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125115xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | TA.02.3268 | A1 | 6772Obj0000059709 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125145xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/337.4/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/337.4/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/337.40/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | TA.02.3272 | A1 | 6772Obj0000059729 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125145xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/163.6/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/163.6/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/163.60/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | TA.02.3274 | A1 | 6772Obj0000059739 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x16x16015xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x16x16015xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/89.4/160.0000/160.0000/160.0000/2/13.9449/0.6088/0/5.0/0/89.4/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/89.40/0/160.00/1.00/5.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.02.3277 | A1 | 6772Obj0000059774 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
252x16x16015xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x16x16015xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/13.9449/0.6088/0/5.0/0/270.0/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.00/0/160.00/1.00/5.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.02.3279 | A1 | 6772Obj0000059784 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
252x16x16013xxxxxx | Půdorys 1.PP | Stk | 0 | 252x16x16013xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/0/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | TA.02.3283 | A1 | 6772Obj0000059804 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
252x16x16013xxxxxx | Půdorys 1.PP | Stk | 0 | 252x16x16013xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/180.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/180.00/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | TA.02.3285 | A1 | 6772Obj0000059814 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
252x16x160141xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x16x160141xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/103.9117/38.3350/0/40.5/0/0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/0/0/160.00/1.00/40.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | TA.02.3288 | A1 | 6772Obj0000059924 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
252x16x16015xxxxxx | Půdorys 1.PP | Stk | 0 | 252x16x16015xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/121.6650/56.0883/0/49.5/0/0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/0/0/160.00/1.00/49.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | TA.02.3290 | A1 | 6772Obj0000059934 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
252x16x16019xxxxxx | Půdorys 1.PP | Stk | 0 | 252x16x16019xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/180.0/160.0000/160.0000/160.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/180.00/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.02.3294 | A1 | 6772Obj0000060096 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
252x125012519xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/151.1/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/151.1/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/151.10/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3299 | A1 | 6772Obj0000137997 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x125012519xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3302 | A1 | 6772Obj0000138012 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x125012519xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/0/125.0000/125.0000/125.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3307 | A1 | 6772Obj0000138462 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125145xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3326 | A1 | 6772Obj0000140060 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125145xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3330 | A1 | 6772Obj0000140275 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125145xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3332 | A1 | 6772Obj0000140285 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x125012513xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012513xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/143.4/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/143.4/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/143.40/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | TA.02.3336 | A1 | 6772Obj0000140310 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x125012513xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012513xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/327.3/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/327.3/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/327.30/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | TA.02.3339 | A1 | 6772Obj0000140325 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1x01x145xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1x01x145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/158.1/100.0000/100.0000/100.0000/2/70.7107/29.2893/0/45.0/0/158.1/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/158.10/0/100.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 1.0 | TA.02.3342 | A1 | 6772Obj0000140340 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN100
252x1x01x145xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1x01x145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/344.1/100.0000/100.0000/100.0000/2/70.7107/29.2893/0/45.0/0/344.1/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/344.10/0/100.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 1.0 | TA.02.3344 | A1 | 6772Obj0000140350 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN100
252x1250125145xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/345.3/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/345.3/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/345.30/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | TA.02.3347 | A1 | 6772Obj0000140365 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125145xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/169.5/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/169.5/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/169.50/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | TA.02.3349 | A1 | 6772Obj0000140375 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x125012519xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | TA.02.3351 | A1 | 6772Obj0000140385 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x125012519xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3352 | A1 | 6772Obj0000140395 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x125012519xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | TA.02.3354 | A1 | 6772Obj0000140470 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125115xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | TA.02.3356 | A1 | 6772Obj0000140480 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125115xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | TA.02.3358 | A1 | 6772Obj0000140490 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x125012513xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012513xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/139.2/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/139.2/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/139.20/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | TA.02.3365 | A1 | 6772Obj0000140765 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125128xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125128xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/219.8/125.0000/125.0000/125.0000/2/59.4530/15.0439/0/28.4/0/219.8/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/219.80/0/125.00/1.00/28.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | TA.02.3367 | A1 | 6772Obj0000140775 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x125012519xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3375 | A1 | 6772Obj0000140895 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x125012519xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3377 | A1 | 6772Obj0000140915 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x16x16017xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x16x16017xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/18.1125/1.0285/0/6.5/0/180.0/160.0000/160.0000/160.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/180.00/0/160.00/1.00/6.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.02.3397 | A1 | 6772Obj0000141625 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
252x16x16017xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x16x16017xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/18.1125/1.0285/0/6.5/0/0/160.0000/160.0000/160.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/0/0/160.00/1.00/6.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.02.3399 | A1 | 6772Obj0000141635 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
252x1250125112xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125112xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/26.8419/2.9160/0/12.4/0/270.0/125.0000/125.0000/125.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/12.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3409 | A1 | 6772Obj0000141780 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125113xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125113xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/27.4808/3.0582/0/12.7/0/90.0/125.0000/125.0000/125.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/12.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3411 | A1 | 6772Obj0000141790 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1x01x19xxxxxx | Půdorys 1.PP | Stk | 0 | 252x1x01x19xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/180.0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/180.00/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 1.0 | TA.02.3428 | A1 | 6772Obj0000142125 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN100
252x1x01x19xxxxxx | Půdorys 1.PP | Stk | 0 | 252x1x01x19xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/180.0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/180.00/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN100 | 100 | 100 | 100 | 120.000 | 0 | 1.0 | TA.02.3430 | A1 | 6772Obj0000142135 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN100
252x125012519xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | TA.02.3433 | A1 | 6772Obj0000142160 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
25204125012519xxxxxx | Půdorys 1.PP | Stk | 0 | 25204125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | TA.02.3435 | A1 | 6772Obj0000142185 | Koleno | 187.500/125.000/62.500/0.000/-62.500/-62.500/0.000/0.000/0.000/1.000 | NEMSOK - K_POSITION: L.1; Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252041x01x19xxxxxx | Půdorys 1.PP | Kus | 0 | 252041x01x19xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/90.0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/0/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 |  | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 100 | 100 | 100 | 120.000 |  | 1.0 | TA.02.3438 | A1 | 6772Obj0000142267 | Koleno | NEMSOK - K_POSITION: L.1; L_BES_DIM_B: 100; Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
252041x01x19xxxxxx | Půdorys 1.PP | Kus | 0 | 252041x01x19xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/100.0000/100.0000/100.0000/2/100.0000/100.0000/0/90.0/0/90.0/100.0000/100.0000/100.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/0/0/100.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 |  | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 100 | 100 | 100 | 120.000 |  | 1.0 | TA.02.3439 | A1 | 6772Obj0000142269 | Koleno | NEMSOK - K_POSITION: L.1; L_BES_DIM_B: 100; Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
252x125012516xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012516xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/108.2532/62.5000/0/60.0/0/0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3460 | A1 | 6772Obj0000142620 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125145xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/181.4/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/181.4/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/181.40/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3463 | A1 | 6772Obj0000142654 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125145xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/1.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/1.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/1.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3465 | A1 | 6772Obj0000142664 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x125012513xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012513xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/195.4/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/195.4/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/195.40/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3468 | A1 | 6772Obj0000142679 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x125012513xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012513xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/13.4/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/13.4/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/13.40/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3470 | A1 | 6772Obj0000142689 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x16x16019xxxxxx | Půdorys 1.PP | Stk | 0 | 252x16x16019xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/0/160.0000/160.0000/160.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/0/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.02.3475 | A1 | 6772Obj0000142779 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
252x125012513xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012513xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3479 | A1 | 6772Obj0000142822 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x125012513xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012513xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3481 | A1 | 6772Obj0000142832 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x125012513xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012513xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/60.9/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/60.9/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/60.90/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3484 | A1 | 6772Obj0000142847 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x125012513xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012513xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/237.3/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/237.3/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/237.30/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3486 | A1 | 6772Obj0000142857 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x125012513xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012513xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/198.8/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/198.8/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/198.80/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3489 | A1 | 6772Obj0000142872 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x125012513xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012513xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/16.4/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/16.4/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/16.40/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3491 | A1 | 6772Obj0000142882 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125115xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3494 | A1 | 6772Obj0000142922 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125115xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3496 | A1 | 6772Obj0000142932 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125115xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/228.1/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/228.1/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/228.10/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3499 | A1 | 6772Obj0000142947 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125115xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/47.1/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/47.1/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/47.10/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3501 | A1 | 6772Obj0000142957 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125115xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3504 | A1 | 6772Obj0000142972 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125115xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3507 | A1 | 6772Obj0000142987 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
252x1250125115xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125115xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/32.3524/4.2593/0/15.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3510 | A1 | 6772Obj0000143002 | Koleno | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
