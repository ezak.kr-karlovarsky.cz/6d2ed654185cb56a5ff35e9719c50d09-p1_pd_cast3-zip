Properties of the parts of a building model (IFC2X3), part 6 of 51

# IfcFlowFitting (2887)
Name | In | Jednotka | Délka (m) | Označení | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_DIM | L_BES_DIM_A2 | L_BES_DIM_B2 | L_BES_DIM_A | K_VOLSTROM | K_MLH_GOST = K_MLD_GOST | K_LISTVALUE | Kód prvku | Třída reakce na oheň | Allright_Stavebni_dil_ID | Název_objektu | K_EBT_BOX_WC | Plocha | L_BES_LAENGE | K_INTERNAL_ISO | Tloušťka (m) | Součinitel tepelné vodivost
2010416016x50501601x6xxxx0 | Půdorys 1.PP | m2 | 0 | 2010416016x50501601x6xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/1/230.8846/133.3013/0/60.0/0/90.0/1.0000/160.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/160.00/100.00/60.00/90.00/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3449 | A1 | 6772Obj0000142465 | Koleno | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.16 m; Výška: 0.16 m
2010416016x50501601x6xxxx0 | Půdorys 1.PP | m2 | 0 | 2010416016x50501601x6xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/1/230.8846/133.3013/0/60.0/0/90.0/1.0000/160.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/160.00/100.00/60.00/90.00/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3450 | A1 | 6772Obj0000142466 | Koleno | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.16 m; Výška: 0.16 m
2010416016x50501601x3016xxxx | Půdorys 1.PP | m2 | 0 | 2010416016x50501601x3016xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/1/183.3013/49.1154/0/30.0/0/0/1.0000/160.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/160.00/100.00/30.00/0/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3452 | A1 | 6772Obj0000142468 | Koleno | NEMSOK - K_POSITION: L.10; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.16 m; Výška: 0.16 m
2010416016x50501601x3016xxxx | Půdorys 1.PP | m2 | 0 | 2010416016x50501601x3016xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/1/183.3013/49.1154/0/30.0/0/180.0/1.0000/160.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/160.00/100.00/30.00/180.00/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3453 | A1 | 6772Obj0000142469 | Koleno | NEMSOK - K_POSITION: L.12; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.16 m; Výška: 0.16 m
2010416016x50501601x6016xxxx | Půdorys 1.PP | m2 | 0 | 2010416016x50501601x6016xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/1/230.8846/133.3013/0/60.0/0/90.0/1.0000/160.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/160.00/100.00/60.00/90.00/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3455 | A1 | 6772Obj0000142472 | Koleno | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.16 m; Výška: 0.16 m
2010416016x50501601x6016xxxx | Půdorys 1.PP | m2 | 0 | 2010416016x50501601x6016xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/1/230.8846/133.3013/0/60.0/0/270.0/1.0000/160.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/50.00/50.00/160.00/100.00/60.00/270.00/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3457 | A1 | 6772Obj0000142535 | Koleno | NEMSOK - K_POSITION: L.7; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.16 m; Výška: 0.16 m
20104315315050501601x9016xxxx | Půdorys 1.PP | m2 | 0 | 20104315315050501601x9016xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/180.0/315.0000/315.0000/160.0000/1/307.5000/307.5000/0/90.0/0/180.0/1.0000/315.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/0/50.00/50.00/160.00/100.00/90.00/180.00/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | TA.02.3643 | A1 | 6772Obj0000144262 | Koleno | NEMSOK - K_POSITION: L.18; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.030 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.315 m; Výška: 0.16 m
20104315315050501601x9xxxx0 | Půdorys 1.PP | m2 | 0 | 20104315315050501601x9xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/0/315.0000/315.0000/160.0000/1/307.5000/307.5000/0/90.0/0/0/1.0000/315.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/0/50.00/50.00/160.00/100.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | TA.02.3646 | A1 | 6772Obj0000144294 | Koleno |  | 1 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.315 m; Výška: 0.16 m
20104315315050501601x9016xxxx | Půdorys 1.PP | m2 | 0 | 20104315315050501601x9016xxxx | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/0/315.0000/315.0000/160.0000/1/307.5000/307.5000/0/90.0/0/0/1.0000/315.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/0/50.00/50.00/160.00/100.00/90.00/0/0/160.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | TA.02.3649 | A1 | 6772Obj0000144339 | Koleno |  | 1 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.315 m; Výška: 0.16 m
20104315315050501601x3xxxx0 | Půdorys 1.PP | m2 | 0 | 20104315315050501601x3xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/180.0/315.0000/315.0000/160.0000/1/222.0513/59.4985/0/30.0/0/180.0/1.0000/315.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/0/50.00/50.00/160.00/100.00/30.00/180.00/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | TA.02.3652 | A1 | 6772Obj0000144384 | Koleno |  | 1 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.315 m; Výška: 0.16 m
20104315315050501601x3xxxx0 | Půdorys 1.PP | m2 | 0 | 20104315315050501601x3xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/0/315.0000/315.0000/160.0000/1/222.0513/59.4985/0/30.0/0/0/1.0000/315.0000/160.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/0/50.00/50.00/160.00/100.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | TA.02.3654 | A1 | 6772Obj0000144414 | Koleno |  | 1 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.315 m; Výška: 0.16 m
7520516016016x26x13x9xxxx | Půdorys 1.PP | Stk | 0.26 | 7520516016016x26x13x9xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/260.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/130.0000/130.0000/0/90.0/0/0/160.0000/160.0000/160.0000/2/ | 75/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/160.00/0/0/260.00/0/130.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | TA.02.3006 | A1 | 6772Obj0000000616 | T - odbočka |  |  | 260 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
752051601601x019x12509xxxx | Půdorys 1.PP | Stk | 0.19 | 752051601601x019x12509xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/190.0000/0/0/0/0/0/125.0000/160.0000/160.0000/2/95.0000/125.0000/0/90.0/0/0/100.0000/100.0000/100.0000/2/ | 75/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/100.00/0/0/190.00/0/125.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | TA.02.3007 | A1 | 6772Obj0000000617 | T - odbočka |  |  | 190 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
752041601601250215012509xxxx | Půdorys 1.PP | Stk | 0.215 | 752041601601250215012509xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/215.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/107.5000/125.0000/0/90.0/0/0/125.0000/125.0000/125.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/125.00/0/0/215.00/0/125.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | TA.02.3016 | A1 | 6772Obj0000000638 | T - odbočka |  |  | 215 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
752041601601x019x12509xxxx | Půdorys 1.PP | Stk | 0.19 | 752041601601x019x12509xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/190.0000/0/0/0/0/180.0/160.0000/160.0000/160.0000/2/95.0000/125.0000/0/90.0/0/180.0/100.0000/100.0000/100.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/100.00/0/180.00/190.00/0/125.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | TA.02.3017 | A1 | 6772Obj0000000639 | T - odbočka |  |  | 190 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
752041601601250215012509xxxx | Půdorys 1.PP | Stk | 0.215 | 752041601601250215012509xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/215.0000/0/0/0/0/180.0/1.0000/160.0000/160.0000/2/107.5000/125.0000/0/90.0/0/180.0/125.0000/125.0000/125.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/125.00/0/180.00/215.00/0/125.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | TA.02.3018 | A1 | 6772Obj0000000644 | T - odbočka |  |  | 215 | NEMSOK - K_POSITION: L.2; Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
752051601601250215012509xxxx | Půdorys 1.PP | Stk | 0.215 | 752051601601250215012509xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/215.0000/0/0/0/0/180.0/1.0000/160.0000/160.0000/2/107.5000/125.0000/0/90.0/0/180.0/125.0000/125.0000/125.0000/2/ | 75/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/125.00/0/180.00/215.00/0/125.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.02.3048 | A1 | 6772Obj0000000902 | T - odbočka | 215.000/125.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 |  | 215 | NEMSOK - K_POSITION: L.1; Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
752041601601250215012509xxxx | Půdorys 1.PP | Stk | 0.215 | 752041601601250215012509xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/190.0000/0/0/0/0/180.0/1.0000/160.0000/160.0000/2/95.0000/125.0000/0/90.0/0/180.0/100.0000/100.0000/100.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/100.00/0/180.00/190.00/0/125.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | TA.02.3121 | A1 | 6772Obj0000001169 | T - odbočka | 190.000/125.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 |  | 190 | NEMSOK - K_POSITION: L.1; Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
752051601601x019x12509xxxx | Půdorys 1.PP | Stk | 0.19 | 752051601601x019x12509xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/215.0000/0/0/0/0/0/1.0000/160.0000/160.0000/2/107.5000/125.0000/0/90.0/0/0/125.0000/125.0000/125.0000/2/ | 75/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/125.00/0/0/215.00/0/125.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | TA.02.3143 | A1 | 6772Obj0000001237 | T - odbočka | 190.000/125.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 |  | 215 | NEMSOK - K_POSITION: L.1; Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
752051601601250215012509xxxx | Půdorys 1.PP | Stk | 0.215 | 752051601601250215012509xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/215.0000/0/0/0/0/180.0/1.0000/160.0000/160.0000/2/107.5000/125.0000/0/90.0/0/180.0/125.0000/125.0000/125.0000/2/ | 75/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/125.00/0/180.00/215.00/0/125.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.02.3171 | A1 | 6772Obj0000001404 | T - odbočka |  |  | 215 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
7520516016016x26x13x9xxxx | Půdorys 1.PP | Stk | 0.26 | 7520516016016x26x13x9xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/215.0000/0/0/0/0/0/1.0000/160.0000/160.0000/2/107.5000/125.0000/0/90.0/0/0/125.0000/125.0000/125.0000/2/ | 75/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/125.00/0/0/215.00/0/125.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | TA.02.3231 | A1 | 6772Obj0000001950 | T - odbočka | 260.000/130.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 |  | 215 | NEMSOK - K_POSITION: L.1; Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
752051251251250215011x9xxxx | Půdorys 1.PP | Stk | 0.215 | 752051251251250215011x9xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/215.0000/0/0/0/0/180.0/1.0000/125.0000/125.0000/2/107.5000/110.0000/0/90.0/0/180.0/125.0000/125.0000/125.0000/2/ | 75/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/125.00/0/180.00/215.00/0/110.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3234 | A1 | 6772Obj0000001991 | T - odbočka |  |  | 215 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
7520516016016x26x13x9xxxx | Půdorys 1.PP | Stk | 0.26 | 7520516016016x26x13x9xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/215.0000/0/0/0/0/180.0/1.0000/160.0000/160.0000/2/107.5000/125.0000/0/90.0/0/180.0/125.0000/125.0000/125.0000/2/ | 75/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/125.00/0/180.00/215.00/0/125.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 120.000 | 0 | 1.0 | TA.02.3262 | A1 | 6772Obj0000059679 | T - odbočka | 215.000/125.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 |  | 215 | NEMSOK - K_POSITION: L.1; Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
752061251251250215011x9xxxx | Půdorys 1.PP | Stk | 0.215 | 752061251251250215011x9xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/110.0000/-107.5000/0/270.0/0/0/125.0000/125.0000/125.0000/2/110.0000/107.5000/0/90.0/0/0/125.0000/125.0000/125.0000/2/ | 75/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/125.00/0/0/215.00/0/110.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | TA.02.3441 | A1 | 6772Obj0000142280 | T - odbočka |  |  | 215 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
701041601601601605050505016x046x | Půdorys 1.PP | m2 | 0.46 | 701041601601601605050505016x046x | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/1/460.0000/0/0/0/0/0/1.0000/160.0000/160.0000/1/230.0000/230.0000/0/90.0/0/0/160.0000/160.0000/160.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/160.00/160.00/50.00/50.00/50.00/50.00/160.00/0/0/0/460.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3040 | A1 | 6772Obj0000000843 | T - odbočka |  |  | 460 | NEMSOK - K_POSITION: L.34; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.16 m; Výška: 0.16 m
701043153151601605050505016x046x | Půdorys 1.PP | m2 | 0.46 | 701043153151601605050505016x046x | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/180.0/315.0000/315.0000/160.0000/1/460.0000/0/0/0/0/180.0/1.0000/315.0000/160.0000/1/230.0000/307.5000/0/90.0/0/180.0/160.0000/160.0000/160.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/160.00/160.00/50.00/50.00/50.00/50.00/160.00/0/0/180.00/460.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | TA.02.3052 | A1 | 6772Obj0000000941 | T - odbočka |  |  | 460 | NEMSOK - K_POSITION: L.20; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.315 m; Výška: 0.16 m
701061601602x2x5050505016x05x01x | Půdorys 1.PP | m2 | 0.5 | 701061601602x2x5050505016x05x01x | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/0/200.0000/200.0000/160.0000/1/230.0000/-250.0000/0/270.0/0/0/0/160.0000/160.0000/1/230.0000/250.0000/0/90.0/0/0/160.0000/160.0000/160.0000/1/ | 70/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/200.00/200.00/50.00/50.00/50.00/50.00/160.00/0/0/0/500.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x160 | 160 | 160 | 200 | 0.000 | 0 | 1.000 m2 | TA.02.3060 | A1 | 6772Obj0000000966 | T - odbočka |  |  | 500 | NEMSOK - K_POSITION: L.11; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.2 m; Výška: 0.16 m
701061601602x2x5050505016x05x01x | Půdorys 1.PP | m2 | 0.5 | 701061601602x2x5050505016x05x01x | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/0/200.0000/200.0000/160.0000/1/230.0000/-250.0000/0/270.0/0/0/310.0000/160.0000/160.0000/1/230.0000/250.0000/0/90.0/0/0/160.0000/160.0000/160.0000/1/ | 70/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/200.00/200.00/50.00/50.00/50.00/50.00/160.00/0/0/0/500.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x160 | 160 | 160 | 200 | 0.000 | 0 | 1.000 m2 | TA.02.3063 | A1 | 6772Obj0000000982 | T - odbočka |  |  | 500 | NEMSOK - K_POSITION: L.9; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.2 m; Výška: 0.16 m
711041602x1601605050505016x0460- | Půdorys 1.PP | m2 | 0.46 | 711041602x1601605050505016x0460- | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/1/460.0000/0/0/0/0/180.0/1.0000/160.0000/160.0000/1/230.0000/230.0000/0/90.0/0/180.0/160.0000/160.0000/160.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/160.00/160.00/50.00/50.00/50.00/50.00/160.00/0/0/0/460.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 120.000 | 0 | 1.000 m2 | TA.02.3070 | A1 | 6772Obj0000001024 | T - odbočka | 460.000/230.000/100.000/0.000/-140.000/-100.000/0.000/0.000/0.000/1.000 |  | 460 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.16 m; Výška: 0.16 m
701043153151601605050505016x046x | Půdorys 1.PP | m2 | 0.46 | 701043153151601605050505016x046x | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/0/315.0000/315.0000/160.0000/1/460.0000/0/0/0/0/0/1.0000/315.0000/160.0000/1/230.0000/307.5000/0/90.0/0/0/160.0000/160.0000/160.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/160.00/160.00/50.00/50.00/50.00/50.00/160.00/0/0/0/460.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | TA.02.3078 | A1 | 6772Obj0000001042 | T - odbočka |  |  | 460 | NEMSOK - K_POSITION: L.10; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.315 m; Výška: 0.16 m
701061601601601605050505016x046x | Půdorys 1.PP | m2 | 0.46 | 701061601601601605050505016x046x | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/1/230.0000/-230.0000/0/270.0/0/0/125.0000/160.0000/160.0000/1/230.0000/230.0000/0/90.0/0/0/160.0000/160.0000/160.0000/1/ | 70/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/160.00/160.00/50.00/50.00/50.00/50.00/160.00/0/0/0/460.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3097 | A1 | 6772Obj0000001088 | T - odbočka |  |  | 460 | NEMSOK - K_POSITION: L.42; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.16 m; Výška: 0.16 m
701042502502502505050505016x055x | Půdorys 1.PP | m2 | 0.55 | 701042502502502505050505016x055x | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/0/250.0000/250.0000/160.0000/1/460.0000/0/0/0/0/0/1.0000/250.0000/160.0000/1/230.0000/275.0000/0/90.0/0/0/160.0000/160.0000/160.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/250.00/160.00/160.00/50.00/50.00/50.00/50.00/160.00/0/0/0/460.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x160 | 250 | 160 | 250 | 0.000 | 0 | 1.000 m2 | TA.02.3166 | A1 | 6772Obj0000001393 | T - odbočka | 550.000/275.000/100.000/0.000/-145.000/-100.000/0.000/0.000/0.000/1.000 |  | 460 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.25 m; Výška: 0.16 m
701041601601601605050505016x046x | Půdorys 1.PP | m2 | 0.46 | 701041601601601605050505016x046x | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/1/460.0000/0/0/0/0/0/1.0000/160.0000/160.0000/1/230.0000/230.0000/0/90.0/0/0/160.0000/160.0000/160.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/160.00/160.00/50.00/50.00/50.00/50.00/160.00/0/0/0/460.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3176 | A1 | 6772Obj0000001435 | T - odbočka |  |  | 460 | NEMSOK - K_POSITION: L.5; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.16 m; Výška: 0.16 m
701043153151601605050505016x046x | Půdorys 1.PP | m2 | 0.46 | 701043153151601605050505016x046x | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/180.0/315.0000/315.0000/160.0000/1/460.0000/0/0/0/0/180.0/1.0000/315.0000/160.0000/1/230.0000/307.5000/0/90.0/0/180.0/160.0000/160.0000/160.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/160.00/160.00/50.00/50.00/50.00/50.00/160.00/0/0/180.00/460.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.000 m2 | TA.02.3182 | A1 | 6772Obj0000001498 | T - odbočka |  |  | 460 | NEMSOK - K_POSITION: L.17; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.315 m; Výška: 0.16 m
701045x5x1601605050505016x046x1x | Půdorys 1.PP | m2 | 0.46 | 701045x5x1601605050505016x046x1x | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/180.0/500.0000/500.0000/160.0000/1/460.0000/0/0/0/0/180.0/1.0000/500.0000/160.0000/1/230.0000/400.0000/0/90.0/0/180.0/160.0000/160.0000/160.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/500.00/160.00/160.00/50.00/50.00/50.00/50.00/160.00/0/0/180.00/460.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 500x160 | 500 | 160 | 500 | 0.000 | 0 | 1.000 m2 | TA.02.3206 | A1 | 6772Obj0000001625 | T - odbočka |  |  | 460 | NEMSOK - K_POSITION: L.30; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.5 m; Výška: 0.16 m; K_DATANORM: ";"
701043153155605605050505016x086x | Půdorys 1.PP | m2 | 0.86 | 701043153155605605050505016x086x | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/180.0/315.0000/315.0000/160.0000/1/860.0000/0/0/0/0/180.0/1.0000/315.0000/160.0000/1/430.0000/307.5000/0/90.0/0/180.0/560.0000/560.0000/160.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/560.00/560.00/50.00/50.00/50.00/50.00/160.00/0/0/180.00/860.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 315 | 160 | 315 | 0.000 | 0 | 1.030 m2 | TA.02.3213 | A1 | 6772Obj0000001652 | T - odbočka |  |  | 860 | NEMSOK - K_POSITION: L.31; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.360 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.315 m; Výška: 0.16 m
701041601601601605050505016x046x | Půdorys 1.PP | m2 | 0.46 | 701041601601601605050505016x046x | T-STCK. GERADE | 20 | 70 | 3/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/1/460.0000/0/0/0/0/180.0/1.0000/160.0000/160.0000/1/230.0000/230.0000/0/90.0/0/180.0/160.0000/160.0000/160.0000/1/ | 70/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/160.00/160.00/50.00/50.00/50.00/50.00/160.00/0/0/180.00/460.00/0/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 160 | 160 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3315 | A1 | 6772Obj0000139830 | T - odbočka | 460.000/230.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 |  | 460 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.16 m; Výška: 0.16 m
711041602x1601605050505016x0460- | Půdorys 1.PP | m2 | 0.46 | 711041602x1601605050505016x0460- | T-STCK. SCHRÄG | 20 | 71 | 3/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/1/460.0000/-20.0000/0/0/0/0/1.0000/200.0000/160.0000/1/230.0000/230.0000/0/90.0/0/0/160.0000/160.0000/160.0000/1/ | 71/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/200.00/160.00/160.00/50.00/50.00/50.00/50.00/160.00/0/0/0/460.00/-40.00/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 160x160 | 200 | 160 | 160 | 0.000 | 0 | 1.000 m2 | TA.02.3072 | A1 | 6772Obj0000001028 | T - odbočka |  |  | 460 | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.16 m; Výška: 0.16 m
711042x2501601605050505016x0460- | Půdorys 1.PP | m2 | 0.46 | 711042x2501601605050505016x0460- | T-STCK. SCHRÄG | 20 | 71 | 3/0/0/0/180.0/0/180.0/200.0000/200.0000/160.0000/1/460.0000/-25.0000/0/0/0/180.0/1.0000/250.0000/160.0000/1/230.0000/250.0000/0/90.0/0/180.0/160.0000/160.0000/160.0000/1/ | 71/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/250.00/160.00/160.00/50.00/50.00/50.00/50.00/160.00/0/0/180.00/460.00/-50.00/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x160 | 250 | 160 | 200 | 0.000 | 0 | 1.000 m2 | TA.02.3073 | A1 | 6772Obj0000001032 | T - odbočka |  |  | 460 | NEMSOK - K_POSITION: L.5; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.2 m; Výška: 0.16 m
711042503151601605050505016x0460 | Půdorys 1.PP | m2 | 0.46 | 711042503151601605050505016x0460 | T-STCK. SCHRÄG | 20 | 71 | 3/0/0/0/180.0/0/180.0/250.0000/250.0000/160.0000/1/460.0000/-32.5000/0/0/0/180.0/1.0000/315.0000/160.0000/1/230.0000/275.0000/0/90.0/0/180.0/160.0000/160.0000/160.0000/1/ | 71/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/315.00/160.00/160.00/50.00/50.00/50.00/50.00/160.00/0/0/180.00/460.00/-65.00/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x160 | 315 | 160 | 250 | 0.000 | 0 | 1.000 m2 | TA.02.3076 | A1 | 6772Obj0000001038 | T - odbočka |  |  | 460 | NEMSOK - K_POSITION: L.8; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.25 m; Výška: 0.16 m
711043153551601605050505016x0460 | Půdorys 1.PP | m2 | 0.46 | 711043153551601605050505016x0460 | T-STCK. SCHRÄG | 20 | 71 | 3/0/0/0/180.0/0/180.0/315.0000/315.0000/160.0000/1/460.0000/-20.0000/0/0/0/180.0/1.0000/355.0000/160.0000/1/230.0000/307.5000/0/90.0/0/180.0/160.0000/160.0000/160.0000/1/ | 71/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/355.00/160.00/160.00/50.00/50.00/50.00/50.00/160.00/0/0/180.00/460.00/-40.00/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 355 | 160 | 315 | 0.000 | 0 | 1.000 m2 | TA.02.3081 | A1 | 6772Obj0000001050 | T - odbočka |  |  | 460 | NEMSOK - K_POSITION: L.20; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.315 m; Výška: 0.16 m
711043554x1601605050505016x0460- | Půdorys 1.PP | m2 | 0.46 | 711043554x1601605050505016x0460- | T-STCK. SCHRÄG | 20 | 71 | 3/0/0/0/180.0/0/180.0/355.0000/355.0000/160.0000/1/460.0000/-22.5000/0/0/0/180.0/1.0000/400.0000/160.0000/1/230.0000/327.5000/0/90.0/0/180.0/160.0000/160.0000/160.0000/1/ | 71/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/355.00/400.00/160.00/160.00/50.00/50.00/50.00/50.00/160.00/0/0/180.00/460.00/-45.00/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 355x160 | 400 | 160 | 355 | 0.000 | 0 | 1.000 m2 | TA.02.3084 | A1 | 6772Obj0000001056 | T - odbočka |  |  | 460 | NEMSOK - K_POSITION: L.23; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.355 m; Výška: 0.16 m
711044x4501601605050505016x0460- | Půdorys 1.PP | m2 | 0.46 | 711044x4501601605050505016x0460- | T-STCK. SCHRÄG | 20 | 71 | 3/0/0/0/180.0/0/0/400.0000/400.0000/160.0000/1/460.0000/-25.0000/0/0/0/0/1.0000/450.0000/160.0000/1/230.0000/350.0000/0/90.0/0/0/160.0000/160.0000/160.0000/1/ | 71/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/450.00/160.00/160.00/50.00/50.00/50.00/50.00/160.00/0/0/0/460.00/-50.00/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 400x160 | 450 | 160 | 400 | 0.000 | 0 | 1.000 m2 | TA.02.3086 | A1 | 6772Obj0000001060 | T - odbočka |  |  | 460 | NEMSOK - K_POSITION: L.25; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.4 m; Výška: 0.16 m
711044505x1601605050505016x0460- | Půdorys 1.PP | m2 | 0.46 | 711044505x1601605050505016x0460- | T-STCK. SCHRÄG | 20 | 71 | 3/0/0/0/180.0/0/180.0/450.0000/450.0000/160.0000/1/460.0000/-25.0000/0/0/0/180.0/1.0000/500.0000/160.0000/1/230.0000/375.0000/0/90.0/0/180.0/160.0000/160.0000/160.0000/1/ | 71/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/500.00/160.00/160.00/50.00/50.00/50.00/50.00/160.00/0/0/180.00/460.00/-50.00/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450x160 | 500 | 160 | 450 | 0.000 | 0 | 1.000 m2 | TA.02.3089 | A1 | 6772Obj0000001066 | T - odbočka |  |  | 460 | NEMSOK - K_POSITION: L.28; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.45 m; Výška: 0.16 m
711042x1601601605050505016x04604 | Půdorys 1.PP | m2 | 0.46 | 711042x1601601605050505016x04604 | T-STCK. SCHRÄG | 20 | 71 | 3/0/0/0/180.0/0/180.0/200.0000/200.0000/160.0000/1/460.0000/20.0000/0/0/0/180.0/1.0000/160.0000/160.0000/1/230.0000/250.0000/0/90.0/0/180.0/160.0000/160.0000/160.0000/1/ | 71/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/160.00/160.00/160.00/50.00/50.00/50.00/50.00/160.00/0/0/180.00/460.00/40.00/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x160 | 160 | 160 | 200 | 0.000 | 0 | 1.000 m2 | TA.02.3162 | A1 | 6772Obj0000001367 | T - odbočka |  |  | 460 | NEMSOK - K_POSITION: L.8; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.2 m; Výška: 0.16 m
711042x2501601605050505016x0460- | Půdorys 1.PP | m2 | 0.46 | 711042x2501601605050505016x0460- | T-STCK. SCHRÄG | 20 | 71 | 3/0/0/0/180.0/0/0/200.0000/200.0000/160.0000/1/460.0000/-25.0000/0/0/0/0/1.0000/250.0000/160.0000/1/230.0000/250.0000/0/90.0/0/0/160.0000/160.0000/160.0000/1/ | 71/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/250.00/160.00/160.00/50.00/50.00/50.00/50.00/160.00/0/0/0/460.00/-50.00/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 200x160 | 250 | 160 | 200 | 0.000 | 0 | 1.000 m2 | TA.02.3164 | A1 | 6772Obj0000001383 | T - odbočka |  |  | 460 | NEMSOK - K_POSITION: L.6; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.2 m; Výška: 0.16 m
711042503151601605050505016x0460 | Půdorys 1.PP | m2 | 0.46 | 711042503151601605050505016x0460 | T-STCK. SCHRÄG | 20 | 71 | 3/0/0/0/180.0/0/0/250.0000/250.0000/160.0000/1/460.0000/-32.5000/0/0/0/0/1.0000/315.0000/160.0000/1/230.0000/275.0000/0/90.0/0/0/160.0000/160.0000/160.0000/1/ | 71/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/315.00/160.00/160.00/50.00/50.00/50.00/50.00/160.00/0/0/0/460.00/-65.00/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x160 | 315 | 160 | 250 | 0.000 | 0 | 1.000 m2 | TA.02.3194 | A1 | 6772Obj0000001588 | T - odbočka |  |  | 460 | NEMSOK - K_POSITION: L.17; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.25 m; Výška: 0.16 m
711043152502x2x5050505016x05x651 | Půdorys 1.PP | m2 | 0.5 | 711043152502x2x5050505016x05x651 | T-STCK. SCHRÄG | 20 | 71 | 3/0/0/0/180.0/0/0/315.0000/315.0000/160.0000/1/500.0000/32.5000/0/0/0/0/1.0000/250.0000/160.0000/1/250.0000/307.5000/0/90.0/0/0/200.0000/200.0000/160.0000/1/ | 71/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/250.00/200.00/200.00/50.00/50.00/50.00/50.00/160.00/0/0/0/500.00/65.00/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x160 | 250 | 160 | 315 | 0.000 | 0 | 1.000 m2 | TA.02.3228 | A1 | 6772Obj0000001909 | T - odbočka |  |  | 500 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.315 m; Výška: 0.16 m
711042501602x2x5050505016x05x901 | Půdorys 1.PP | m2 | 0.5 | 711042501602x2x5050505016x05x901 | T-STCK. SCHRÄG | 20 | 71 | 3/0/0/0/180.0/0/0/250.0000/250.0000/160.0000/1/500.0000/45.0000/0/0/0/0/1.0000/160.0000/160.0000/1/250.0000/275.0000/0/90.0/0/0/200.0000/200.0000/160.0000/1/ | 71/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/160.00/200.00/200.00/50.00/50.00/50.00/50.00/160.00/0/0/0/500.00/90.00/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250x160 | 160 | 160 | 250 | 0.000 | 0 | 1.000 m2 | TA.02.3230 | A1 | 6772Obj0000001944 | T - odbočka |  |  | 500 | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.25 m; Výška: 0.16 m
711045605x1601605050505016x04606 | Půdorys 1.PP | m2 | 0.46 | 711045605x1601605050505016x04606 | T-STCK. SCHRÄG | 20 | 71 | 3/0/0/0/180.0/0/0/560.0000/560.0000/160.0000/1/460.0000/30.0000/0/0/0/0/1.0000/500.0000/160.0000/1/230.0000/430.0000/0/90.0/0/0/160.0000/160.0000/160.0000/1/ | 71/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/500.00/160.00/160.00/50.00/50.00/50.00/50.00/160.00/0/0/0/460.00/60.00/100.00/100.00/90.00/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/SB 20// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 500 | 160 | 560 | 0.000 | 0 | 1.000 m2 | TA.02.3380 | A1 | 6772Obj0000140955 | T - odbočka |  |  | 460 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.56 m; Výška: 0.16 m
31206160125x160125078-18-180-353 | Půdorys 1.PP | Stk | 0.078 | 31206160125x160125078-18-180-353 | UE RUND AS | 20 | 31 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/78.0000/0/17.5000/0/0/0/125.0000/125.0000/125.0000/2/ | 31/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/0/0/160.00/125.00/0/78.00/-17.50/-17.50/0/-35.00/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 125 | 125 | 160 | 120.000 | 0 | 1.0 | TA.02.3123 | A1 | 6772Obj0000001173 | Přechodka |  |  | 78 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
31205125125x12512501x0-x03xx | Půdorys 1.PP | Stk | 0.1 | 31205125125x12512501x0-x03xx | UE RUND AS | 20 | 31 | 2/0/0/0/180.0/0/0/1.0000/125.0000/125.0000/2/100.0000/-0.0143/0/0/0/0/125.0000/125.0000/125.0000/2/ | 31/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/0/0/125.00/125.00/0/100.00/0.01/-0.01/0/0/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | TA.02.3334 | A1 | 6772Obj0000140300 | Přechodka |  |  | 100 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
30205160125x160125078-18-18-18-1 | Půdorys 1.PP | Stk | 0.078 | 30205160125x160125078-18-18-18-1 | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/78.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 30/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/0/0/160.00/125.00/0/78.00/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 125 | 125 | 160 | 120.000 | 0 | 1.0 | TA.02.3008 | A1 | 6772Obj0000000618 | Přechodka |  |  | 78 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
3020412516x012516x78181818183xx | Půdorys 1.PP | Stk | 0.078 | 3020412516x012516x78181818183xx | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/78.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/160.00/0/0/125.00/160.00/0/78.00/17.50/17.50/17.50/17.50/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 160 | 160 | 125 | 120.000 | 0 | 1.0 | TA.02.3014 | A1 | 6772Obj0000000636 | Přechodka |  |  | 78 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
30205160125x160125078-18-18-18-1 | Půdorys 1.PP | Stk | 0.078 | 30205160125x160125078-18-18-18-1 | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/78.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 30/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/0/0/160.00/125.00/0/78.00/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 125 | 125 | 160 | 0.000 | 0 | 1.0 | TA.02.3047 | A1 | 6772Obj0000000900 | Přechodka |  |  | 78 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
30205160125x160125078-18-18-18-1 | Půdorys 1.PP | Stk | 0.078 | 30205160125x160125078-18-18-18-1 | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/78.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 30/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/0/0/160.00/125.00/0/78.00/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 125 | 125 | 160 | 120.000 | 0 | 1.0 | TA.02.3066 | A1 | 6772Obj0000001006 | Přechodka |  |  | 78 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
3020616016x016016x96-x-x3xx | Půdorys 1.PP | Stk | 0.096 | 3020616016x016016x96-x-x3xx | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/2/96.0000/0.0798/-0.0322/0/0/0/160.0000/160.0000/160.0000/2/ | 30/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/0/160.00/160.00/0/96.00/-0.08/0.08/-0.03/0.03/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.02.3131 | A1 | 6772Obj0000001189 | Přechodka |  |  | 96 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
30205160125x160125078-18-18-18-1 | Půdorys 1.PP | Stk | 0.078 | 30205160125x160125078-18-18-18-1 | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/78.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 30/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/0/0/160.00/125.00/0/78.00/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 125 | 125 | 160 | 0.000 | 0 | 1.0 | TA.02.3172 | A1 | 6772Obj0000001405 | Přechodka |  |  | 78 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN160
302051251xx1251x064-13-13-13-133 | Půdorys 1.PP | Stk | 0.064 | 302051251xx1251x064-13-13-13-133 | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/64.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 30/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/100.00/0/0/125.00/100.00/0/64.00/-12.50/-12.50/-12.50/-12.50/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | DN125 | 100 | 100 | 125 | 0.000 | 0 | 1.0 | TA.02.3235 | A1 | 6772Obj0000001996 | Přechodka |  |  | 64 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
30204125125x125125092x-x3xx | Půdorys 1.PP | Stk | 0.092 | 30204125125x125125092x-x3xx | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/1.0000/125.0000/125.0000/2/92.0000/0/-0.2287/0/0/0/125.0000/125.0000/125.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/0/0/125.00/125.00/0/92.00/0/0/-0.23/0.23/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3300 | A1 | 6772Obj0000138002 | Přechodka |  |  | 92 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
30204125125x1251250920-0-x3xx | Půdorys 1.PP | Stk | 0.092 | 30204125125x1251250920-0-x3xx | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/1.0000/125.0000/125.0000/2/92.0000/-0.0093/-0.0336/0/0/0/125.0000/125.0000/125.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/0/0/125.00/125.00/0/92.00/0.01/-0.01/-0.03/0.03/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | TA.02.3337 | A1 | 6772Obj0000140315 | Přechodka |  |  | 92 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
30204125125x125125092-x0-03xx | Půdorys 1.PP | Stk | 0.092 | 30204125125x125125092-x0-03xx | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/1.0000/125.0000/125.0000/2/92.0000/0.0564/0.0355/0/0/0/125.0000/125.0000/125.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/0/0/125.00/125.00/0/92.00/-0.06/0.06/0.04/-0.04/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.0 | TA.02.3366 | A1 | 6772Obj0000140770 | Přechodka |  |  | 92 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
302041251xx1251x064-13-13-13-133 | Půdorys 1.PP | Stk | 0.064 | 302041251xx1251x064-13-13-13-133 | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/64.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/100.00/0/0/125.00/100.00/0/64.00/-12.50/-12.50/-12.50/-12.50/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 100 | 100 | 125 | 120.000 | 0 | 1.0 | TA.02.3442 | A1 | 6772Obj0000142285 | Přechodka |  |  | 64 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
302041251xx1251x064-13-13-13-133 | Půdorys 1.PP | Stk | 0.064 | 302041251xx1251x064-13-13-13-133 | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/0/125.0000/125.0000/2/64.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/100.00/0/0/125.00/100.00/0/64.00/-12.50/-12.50/-12.50/-12.50/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 100 | 100 | 125 | 120.000 | 0 | 1.0 | TA.02.3443 | A1 | 6772Obj0000142290 | Přechodka |  |  | 64 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
30204125125x125125092x0-03xx | Půdorys 1.PP | Stk | 0.092 | 30204125125x125125092x0-03xx | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/1.0000/125.0000/125.0000/2/92.0000/0/0.0278/0/0/0/125.0000/125.0000/125.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/0/0/125.00/125.00/0/92.00/0/0/0.03/-0.03/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3505 | A1 | 6772Obj0000142977 | Přechodka |  |  | 92 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
30205125125x125125092-x0-03xx | Půdorys 1.PP | Stk | 0.092 | 30205125125x125125092-x0-03xx | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/1.0000/125.0000/125.0000/2/92.0000/0.0040/0.0275/0/0/0/125.0000/125.0000/125.0000/2/ | 30/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/0/0/125.00/125.00/0/92.00/-0.00/0.00/0.03/-0.03/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3516 | A1 | 6772Obj0000143032 | Přechodka |  |  | 92 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
30205125125x125125092-x0-03xx | Půdorys 1.PP | Stk | 0.092 | 30205125125x125125092-x0-03xx | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/1.0000/125.0000/125.0000/2/92.0000/0.3685/0.1858/0/0/0/125.0000/125.0000/125.0000/2/ | 30/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/0/0/125.00/125.00/0/92.00/-0.37/0.37/0.19/-0.19/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3521 | A1 | 6772Obj0000143057 | Přechodka |  |  | 92 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
30204125125x125125092x0-03xx | Půdorys 1.PP | Stk | 0.092 | 30204125125x125125092x0-03xx | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/1.0000/125.0000/125.0000/2/92.0000/0/0.0278/0/0/0/125.0000/125.0000/125.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/0/0/125.00/125.00/0/92.00/0/0/0.03/-0.03/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3531 | A1 | 6772Obj0000143107 | Přechodka |  |  | 92 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
30204125125x125125092x0-03xx | Půdorys 1.PP | Stk | 0.092 | 30204125125x125125092x0-03xx | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/1.0000/125.0000/125.0000/2/92.0000/0/0.0278/0/0/0/125.0000/125.0000/125.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/0/0/125.00/125.00/0/92.00/0/0/0.03/-0.03/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3537 | A1 | 6772Obj0000143137 | Přechodka |  |  | 92 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
30204125125x125125092x0-03xx | Půdorys 1.PP | Stk | 0.092 | 30204125125x125125092x0-03xx | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/1.0000/125.0000/125.0000/2/92.0000/0/0.0278/0/0/0/125.0000/125.0000/125.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/0/0/125.00/125.00/0/92.00/0/0/0.03/-0.03/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3543 | A1 | 6772Obj0000143167 | Přechodka |  |  | 92 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
30204125125x125125092x0-03xx | Půdorys 1.PP | Stk | 0.092 | 30204125125x125125092x0-03xx | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/1.0000/125.0000/125.0000/2/92.0000/0/0.0278/0/0/0/125.0000/125.0000/125.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/0/0/125.00/125.00/0/92.00/0/0/0.03/-0.03/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3554 | A1 | 6772Obj0000143247 | Přechodka |  |  | 92 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
30204125125x125125092x0-03xx | Půdorys 1.PP | Stk | 0.092 | 30204125125x125125092x0-03xx | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/1.0000/125.0000/125.0000/2/92.0000/0/0.0278/0/0/0/125.0000/125.0000/125.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/0/0/125.00/125.00/0/92.00/0/0/0.03/-0.03/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3560 | A1 | 6772Obj0000143277 | Přechodka |  |  | 92 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
30204125125x1251250920-0-x3xx | Půdorys 1.PP | Stk | 0.092 | 30204125125x1251250920-0-x3xx | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/1.0000/125.0000/125.0000/2/92.0000/-0.0497/-0.0027/0/0/0/125.0000/125.0000/125.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/0/0/125.00/125.00/0/92.00/0.05/-0.05/-0.00/0.00/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3586 | A1 | 6772Obj0000143432 | Přechodka |  |  | 92 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
30204125125x125125092-x-x3xx | Půdorys 1.PP | Stk | 0.092 | 30204125125x125125092-x-x3xx | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/1.0000/125.0000/125.0000/2/92.0000/0.2771/-0.1652/0/0/0/125.0000/125.0000/125.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/0/0/125.00/125.00/0/92.00/-0.28/0.28/-0.17/0.17/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.3601 | A1 | 6772Obj0000143507 | Přechodka |  |  | 92 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: DN125
4110556031550501603150369-123-12 | Půdorys 1.PP | m2 | 0.369 | 4110556031550501603150369-123-12 | UEBERGANG ASYM. | 20 | 41 | 2/0/0/0/180.0/0/0/1.0000/560.0000/160.0000/1/368.5000/0/-77.5000/0/0/0/0/560.0000/315.0000/1/ | 41/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/50.00/50.00/160.00/315.00/0/368.50/0/0/0/155.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x160 | 560 | 315 | 560 | 0.000 | 0 | 1.000 m2 | TA.02.3148 | A1 | 6772Obj0000001258 | Přechodka | 368.500/300.000/100.000/0.000/-300.000/-255.000/0.000/0.000/0.000/1.000 |  | 369 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; K_LISTVALUE_ISO: 1.000 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: -; Šířka: 0.56 m; Výška: 0.16 m
