Properties of the parts of a building model (IFC2X3), part 40 of 51

# IfcFlowSegment (1090)
Name | In | Jednotka | Délka (m) | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_LAENGE | L_BES_DIM | L_BES_DIM_A2 = L_BES_DIM_A | L_BES_DIM_B2 | K_VOLSTROM | K_LISTVALUE | Kód prvku | Podlaží | Průměr | Teplonosná látka | Allright_Stavebni_dil_ID | Název_objektu | Označení | K_LISTVALUE_ISO
1010431516015xxxxxxx0 | Půdorys 1.PP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/1500.0000/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 315x160 | 315 | 160 | 0.000 | 1.420 m2 | PO.02.30128 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001044 | Hranaté potrubí | 1010431516015xxxxxxx0 | 1.910 m2 | NEMSOK - K_POSITION: L.11; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.315 m; Výška: 0.16 m
 | Půdorys 1.PP | m2 | 1.346 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/1346.1000/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/1346.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1346 | 315x160 | 315 | 160 | 0.000 | 1.280 m2 | PO.02.30129 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001046 | Hranaté potrubí |  | 1.710 m2 | NEMSOK - K_POSITION: L.16; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.315 m; Výška: 0.16 m
1010435516015xxxxxxx0 | Půdorys 1.PP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/355.0000/160.0000/1/1500.0000/0/0/0/0/0/1.0000/355.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/355.00/160.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 355x160 | 355 | 160 | 0.000 | 1.550 m2 | PO.02.30130 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001052 | Hranaté potrubí | 1010435516015xxxxxxx0 | 2.030 m2 | NEMSOK - K_POSITION: L.21; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.355 m; Výška: 0.16 m
10104355160916xxxxxx0 | Půdorys 1.PP | m2 | 0.916 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/355.0000/160.0000/1/916.1000/0/0/0/0/0/1.0000/355.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/355.00/160.00/916.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 916 | 355x160 | 355 | 160 | 0.000 | 0.940 m2 | PO.02.30131 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001054 | Hranaté potrubí | 10104355160916xxxxxx0 | 1.240 m2 | NEMSOK - K_POSITION: L.22; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.355 m; Výška: 0.16 m
101044x1602xxxxxx0 | Půdorys 1.PP | m2 | 0.002 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/400.0000/160.0000/1/2.3000/0/0/0/0/0/1.0000/400.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/160.00/2.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 2 | 400x160 | 400 | 160 | 0.000 | 1.000 m2 | PO.02.30132 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001058 | Hranaté potrubí | 101044x1602xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.24; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.4 m; Výška: 0.16 m
1010445016015xxxxxxx0 | Půdorys 1.PP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/450.0000/160.0000/1/1500.0000/0/0/0/0/0/1.0000/450.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/160.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 450x160 | 450 | 160 | 0.000 | 1.830 m2 | PO.02.30133 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001062 | Hranaté potrubí | 1010445016015xxxxxxx0 | 2.310 m2 | NEMSOK - K_POSITION: L.26; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.45 m; Výška: 0.16 m
1010445016048xxxxxxx | Půdorys 1.PP | m2 | 0.48 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/450.0000/160.0000/1/480.0000/0/0/0/0/0/1.0000/450.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/160.00/480.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 480 | 450x160 | 450 | 160 | 0.000 | 1.000 m2 | PO.02.30134 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001064 | Hranaté potrubí | 1010445016048xxxxxxx | 1.000 m2 | NEMSOK - K_POSITION: L.27; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.45 m; Výška: 0.16 m
10105315160485xxxxxx0 | Půdorys 1.PP | m2 | 0.485 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/485.0000/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/485.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 485 | 315x160 | 315 | 160 | 0.000 | 1.000 m2 | PO.02.30135 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001110 | Hranaté potrubí | 10105315160485xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.47; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.315 m; Výška: 0.16 m
1010456016015xxxxxxx0 | Půdorys 1.PP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/160.0000/1/1500.0000/0/0/0/0/0/1.0000/560.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/160.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 560x160 | 560 | 160 | 0.000 | 2.160 m2 | PO.02.30136 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001112 | Hranaté potrubí | 1010456016015xxxxxxx0 | 2.760 m2 | NEMSOK - K_POSITION: L.32; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.56 m; Výška: 0.16 m
1010456016015xxxxxxx0 | Půdorys 1.PP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/160.0000/1/1500.0000/0/0/0/0/0/1.0000/560.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/160.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 560x160 | 560 | 160 | 0.000 | 2.160 m2 | PO.02.30137 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001150 | Hranaté potrubí | 1010456016015xxxxxxx0 | 2.760 m2 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.56 m; Výška: 0.16 m
10104560160128xxxxxxx | Půdorys 1.PP | m2 | 1.28 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/160.0000/1/1280.0000/0/0/0/0/0/1.0000/560.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/160.00/1280.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1280 | 560x160 | 560 | 160 | 0.000 | 1.840 m2 | PO.02.30138 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001154 | Hranaté potrubí | 10104560160128xxxxxxx | 2.360 m2 | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.56 m; Výška: 0.16 m
1010556016012xxxxxxx0 | Půdorys 1.PP | m2 | 1.2 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/160.0000/1/1200.0000/0/0/0/0/0/1.0000/560.0000/160.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/160.00/1200.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1200 | 560x160 | 560 | 160 | 0.000 | 1.730 m2 | PO.02.30139 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001255 | Hranaté potrubí | 1010556016012xxxxxxx0 | 2.210 m2 | NEMSOK - K_POSITION: L.8; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.56 m; Výška: 0.16 m
101044507105xxxxxxx | Půdorys 1.PP | m2 | 0.05 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/450.0000/710.0000/1/50.0000/0/0/0/0/0/1.0000/450.0000/710.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/710.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 50 | 450x710 | 450 | 710 | 0.000 | 1.000 m2 | PO.02.30140 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001335 | Hranaté potrubí | 101044507105xxxxxxx | 1.000 m2 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 710; Šířka: 0.45 m; Výška: 0.71 m; K_EBT_BOX_WC: 50.000|170.000|220.000|0.000|-170.000|-220.000|0.000|0.000|0.000|1.000
101043x4x5xxxxxxx | Půdorys 1.PP | m2 | 0.05 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/300.0000/400.0000/1/50.0000/0/0/0/0/0/1.0000/300.0000/400.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/300.00/400.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 50 | 300x400 | 300 | 400 | 0.000 | 1.000 m2 | PO.02.30141 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001337 | Hranaté potrubí | 101043x4x5xxxxxxx | 1.000 m2 | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Šířka: 0.3 m; Výška: 0.4 m
101044507105xxxxxxx | Půdorys 1.PP | m2 | 0.05 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/450.0000/710.0000/1/50.0000/0/0/0/0/0/1.0000/450.0000/710.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/710.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 50 | 450x710 | 450 | 710 | 0.000 | 1.000 m2 | PO.02.30142 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001338 | Hranaté potrubí | 101044507105xxxxxxx | 1.000 m2 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 710; Šířka: 0.45 m; Výška: 0.71 m; K_EBT_BOX_WC: 50.000|170.000|220.000|0.000|-170.000|-220.000|0.000|0.000|0.000|1.000
101043x4x5xxxxxxx | Půdorys 1.PP | m2 | 0.05 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/300.0000/400.0000/1/50.0000/0/0/0/0/0/1.0000/300.0000/400.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/300.00/400.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 50 | 300x400 | 300 | 400 | 0.000 | 1.000 m2 | PO.02.30143 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001341 | Hranaté potrubí | 101043x4x5xxxxxxx | 1.000 m2 | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Šířka: 0.3 m; Výška: 0.4 m
101053153151xxxxxxx0 | Půdorys 1.PP | m2 | 0.1 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/315.0000/1/100.0000/0/0/0/0/0/1.0000/315.0000/315.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 100 | 315x315 | 315 | 315 | 0.000 | 1.000 m2 | PO.02.30144 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001345 | Hranaté potrubí | 101053153151xxxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 315; Šířka: 0.315 m; Výška: 0.315 m; K_EBT_BOX_WC: 375.000|177.500|177.500|0.000|-177.500|-177.500|0.000|0.000|0.000|1.000
101053153155xxxxxxx | Půdorys 1.PP | m2 | 0.05 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/315.0000/1/50.0000/0/0/0/0/0/1.0000/315.0000/315.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 50 | 315x315 | 315 | 315 | 0.000 | 1.000 m2 | PO.02.30145 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001347 | Hranaté potrubí | 101053153155xxxxxxx | 1.000 m2 | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 315; Šířka: 0.315 m; Výška: 0.315 m
10104560160299xxxxxx0 | Půdorys 1.PP | m2 | 0.299 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/160.0000/1/299.3000/0/0/0/0/0/1.0000/560.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/160.00/299.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 299 | 560x160 | 560 | 160 | 0.000 | 1.000 m2 | PO.02.30146 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001361 | Hranaté potrubí | 10104560160299xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.5; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.56 m; Výška: 0.16 m
101062x16015xxxxxxx0 | Půdorys 1.PP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/200.0000/160.0000/1/1500.0000/0/0/0/0/0/1.0000/200.0000/160.0000/1/ | 10/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/160.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 200x160 | 200 | 160 | 0.000 | 1.080 m2 | PO.02.30147 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001377 | Hranaté potrubí | 101062x16015xxxxxxx0 | 1.560 m2 | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.2 m; Výška: 0.16 m
1010425016015xxxxxxx0 | Půdorys 1.PP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/250.0000/160.0000/1/1500.0000/0/0/0/0/0/1.0000/250.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/160.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 250x160 | 250 | 160 | 0.000 | 1.230 m2 | PO.02.30148 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001389 | Hranaté potrubí | 1010425016015xxxxxxx0 | 1.710 m2 | NEMSOK - K_POSITION: L.11; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.25 m; Výška: 0.16 m
1010425016014xxxxxxx | Půdorys 1.PP | m2 | 0.14 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/250.0000/160.0000/1/140.0000/0/0/0/0/0/1.0000/250.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/160.00/140.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 140 | 250x160 | 250 | 160 | 0.000 | 1.000 m2 | PO.02.30149 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001395 | Hranaté potrubí | 1010425016014xxxxxxx | 1.000 m2 | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.25 m; Výška: 0.16 m
1010431516015xxxxxxx0 | Půdorys 1.PP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/1500.0000/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 315x160 | 315 | 160 | 0.000 | 1.420 m2 | PO.02.30150 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001496 | Hranaté potrubí | 1010431516015xxxxxxx0 | 1.910 m2 | NEMSOK - K_POSITION: L.18; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.315 m; Výška: 0.16 m
 | Půdorys 1.PP | m2 | 1.198 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/1198.2754/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/1198.28/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1198 | 160x160 | 160 | 160 | 0.000 | 0.770 m2 | PO.02.30151 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001511 | Hranaté potrubí |  | 1.150 m2 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.16 m; Výška: 0.16 m
 | Půdorys 1.PP | m2 | 1.198 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/1198.1659/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/1198.17/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1198 | 160x160 | 160 | 160 | 0.000 | 0.770 m2 | PO.02.30152 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001535 | Hranaté potrubí |  | 1.150 m2 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.16 m; Výška: 0.16 m
10104160160557xxxxxx0 | Půdorys 1.PP | m2 | 0.557 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/556.7000/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/556.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 557 | 160x160 | 160 | 160 | 0.000 | 1.000 m2 | PO.02.30153 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001549 | Hranaté potrubí | 10104160160557xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.8; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.16 m; Výška: 0.16 m
1010431516015xxxxxxx0 | Půdorys 1.PP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/1500.0000/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 315x160 | 315 | 160 | 0.000 | 1.420 m2 | PO.02.30154 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001582 | Hranaté potrubí | 1010431516015xxxxxxx0 | 1.910 m2 | NEMSOK - K_POSITION: L.24; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.315 m; Výška: 0.16 m
101064x3x221xxxxxx0 | Půdorys 1.PP | m2 | 0.221 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/400.0000/300.0000/1/221.0910/0/0/0/0/0/1.0000/400.0000/300.0000/1/ | 10/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/300.00/221.09/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 221 | 400x300 | 400 | 300 | 0.000 | 1.000 m2 | PO.02.30155 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001615 | Hranaté potrubí | 101064x3x221xxxxxx0 | 1.000 m2 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 300; Šířka: 0.4 m; Výška: 0.3 m
101065x160731xxxxxx0 | Půdorys 1.PP | m2 | 0.731 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/500.0000/160.0000/1/731.1000/0/0/0/0/0/1.0000/500.0000/160.0000/1/ | 10/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/160.00/731.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 731 | 500x160 | 500 | 160 | 0.000 | 1.000 m2 | PO.02.30156 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001621 | Hranaté potrubí | 101065x160731xxxxxx0 | 1.200 m2 | NEMSOK - K_POSITION: L.8; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.5 m; Výška: 0.16 m
10106315160316xxxxxx0 | Půdorys 1.PP | m2 | 0.316 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/315.5000/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/315.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 316 | 315x160 | 315 | 160 | 0.000 | 1.000 m2 | PO.02.30157 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001623 | Hranaté potrubí | 10106315160316xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.9; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.315 m; Výška: 0.16 m
101065x160551xxxxxx0 | Půdorys 1.PP | m2 | 0.551 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/500.0000/160.0000/1/551.1000/0/0/0/0/0/1.0000/500.0000/160.0000/1/ | 10/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/160.00/551.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 551 | 500x160 | 500 | 160 | 0.000 | 1.000 m2 | PO.02.30158 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001629 | Hranaté potrubí | 101065x160551xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.10; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.5 m; Výška: 0.16 m
101065x160157xxxxxx0 | Půdorys 1.PP | m2 | 0.157 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/500.0000/160.0000/1/157.0000/0/0/0/0/0/1.0000/500.0000/160.0000/1/ | 10/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/160.00/157.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 157 | 500x160 | 500 | 160 | 0.000 | 1.000 m2 | PO.02.30159 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001633 | Hranaté potrubí | 101065x160157xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.11; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.5 m; Výška: 0.16 m
10106250160486xxxxxx0 | Půdorys 1.PP | m2 | 0.486 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/250.0000/160.0000/1/486.4000/0/0/0/0/0/1.0000/250.0000/160.0000/1/ | 10/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/160.00/486.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 486 | 250x160 | 250 | 160 | 0.000 | 1.000 m2 | PO.02.30160 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001646 | Hranaté potrubí | 10106250160486xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.26; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.25 m; Výška: 0.16 m
101043x4x834xxxxxx0 | Půdorys 1.PP | m2 | 0.834 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/300.0000/400.0000/1/834.3000/0/0/0/0/0/1.0000/300.0000/400.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/300.00/400.00/834.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 834 | 300x400 | 300 | 400 | 0.000 | 1.170 m2 | PO.02.30161 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001658 | Hranaté potrubí | 101043x4x834xxxxxx0 | 1.430 m2 | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Šířka: 0.3 m; Výška: 0.4 m
10104560160574xxxxxx0 | Půdorys 1.PP | m2 | 0.574 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/160.0000/1/574.3000/0/0/0/0/0/1.0000/560.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/160.00/574.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 574 | 560x160 | 560 | 160 | 0.000 | 1.000 m2 | PO.02.30162 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001672 | Hranaté potrubí | 10104560160574xxxxxx0 | 1.010 m2 | NEMSOK - K_POSITION: L.7; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.56 m; Výška: 0.16 m
1010416016034xxxxxx0 | Půdorys 1.PP | m2 | 0.034 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/33.7259/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/33.73/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 34 | 160x160 | 160 | 160 | 0.000 | 1.000 m2 | PO.02.30163 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001690 | Hranaté potrubí | 1010416016034xxxxxx0 | 1.000 m2 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.16 m; Výška: 0.16 m
10104315160464xxxxxx0 | Půdorys 1.PP | m2 | 0.464 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/464.3000/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/464.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 464 | 315x160 | 315 | 160 | 0.000 | 1.000 m2 | PO.02.30164 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001693 | Hranaté potrubí | 10104315160464xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.9; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.315 m; Výška: 0.16 m
101052x16074xxxxxxx | Půdorys 1.PP | m2 | 0.74 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/200.0000/160.0000/1/740.0000/0/0/0/0/0/1.0000/200.0000/160.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/160.00/740.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 740 | 200x160 | 200 | 160 | 0.000 | 1.000 m2 | PO.02.30165 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001704 | Hranaté potrubí | 101052x16074xxxxxxx | 1.000 m2 | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.2 m; Výška: 0.16 m
101052x16058xxxxxxx | Půdorys 1.PP | m2 | 0.58 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/200.0000/160.0000/1/580.0000/0/0/0/0/0/1.0000/200.0000/160.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/160.00/580.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 580 | 200x160 | 200 | 160 | 0.000 | 1.000 m2 | PO.02.30166 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001872 | Hranaté potrubí | 101052x16058xxxxxxx | 1.000 m2 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.2 m; Výška: 0.16 m
1010425016065xxxxxxx | Půdorys 1.PP | m2 | 0.65 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/250.0000/160.0000/1/649.8000/0/0/0/0/0/1.0000/250.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/160.00/649.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 650 | 250x160 | 250 | 160 | 0.000 | 1.000 m2 | PO.02.30167 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001924 | Hranaté potrubí | 1010425016065xxxxxxx | 1.000 m2 | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.25 m; Výška: 0.16 m
10104160160196xxxxxx0 | Půdorys 1.PP | m2 | 0.196 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/196.0864/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/196.09/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 196 | 160x160 | 160 | 160 | 0.000 | 1.000 m2 | PO.02.30168 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000002212 | Hranaté potrubí | 10104160160196xxxxxx0 | 1.000 m2 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.16 m; Výška: 0.16 m
101062x16042xxxxxxx | Půdorys 1.PP | m2 | 0.42 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/200.0000/160.0000/1/419.5682/0/0/0/0/0/1.0000/200.0000/160.0000/1/ | 10/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/160.00/419.57/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 420 | 200x160 | 200 | 160 | 0.000 | 1.000 m2 | PO.02.30169 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000002347 | Hranaté potrubí | 101062x16042xxxxxxx | 1.000 m2 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.2 m; Výška: 0.16 m
1010425016054xxxxxxx | Půdorys 1.PP | m2 | 0.54 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/250.0000/160.0000/1/539.6717/0/0/0/0/0/1.0000/250.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/160.00/539.67/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 540 | 250x160 | 250 | 160 | 0.000 | 1.000 m2 | PO.02.30170 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000002377 | Hranaté potrubí | 1010425016054xxxxxxx | 1.000 m2 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.25 m; Výška: 0.16 m
101042x160888xxxxxx0 | Půdorys 1.PP | m2 | 0.888 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/200.0000/160.0000/1/887.7000/0/0/0/0/0/1.0000/200.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/160.00/887.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 888 | 200x160 | 200 | 160 | 0.000 | 1.000 m2 | PO.02.30171 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000002500 | Hranaté potrubí | 101042x160888xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.2 m; Výška: 0.16 m
10104250160361xxxxxx0 | Půdorys 1.PP | m2 | 0.361 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/250.0000/160.0000/1/360.9000/0/0/0/0/0/1.0000/250.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/160.00/360.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 361 | 250x160 | 250 | 160 | 0.000 | 1.000 m2 | PO.02.30172 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000002515 | Hranaté potrubí | 10104250160361xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.25 m; Výška: 0.16 m
10105560160785xxxxxx0 | Půdorys 1.PP | m2 | 0.785 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/160.0000/1/785.4504/0/0/0/0/0/1.0000/560.0000/160.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/160.00/785.45/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 785 | 560x160 | 560 | 160 | 0.000 | 1.130 m2 | PO.02.30173 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000031380 | Hranaté potrubí | 10105560160785xxxxxx0 | 1.440 m2 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.56 m; Výška: 0.16 m
1010556016019xxxxxx0 | Půdorys 1.PP | m2 | 0.019 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/160.0000/1/19.1025/0/0/0/0/0/1.0000/560.0000/160.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/160.00/19.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 19 | 560x160 | 560 | 160 | 0.000 | 1.000 m2 | PO.02.30174 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000031410 | Hranaté potrubí | 1010556016019xxxxxx0 | 1.000 m2 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.56 m; Výška: 0.16 m
101042x160165xxxxxx0 | Půdorys 1.PP | m2 | 0.165 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/200.0000/160.0000/1/164.7000/0/0/0/0/0/1.0000/200.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/160.00/164.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 165 | 200x160 | 200 | 160 | 0.000 | 1.000 m2 | PO.02.30175 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000031568 | Hranaté potrubí | 101042x160165xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.15; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.2 m; Výška: 0.16 m
101042x160165xxxxxx0 | Půdorys 1.PP | m2 | 0.165 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/200.0000/160.0000/1/164.7000/0/0/0/0/0/1.0000/200.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/160.00/164.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 165 | 200x160 | 200 | 160 | 0.000 | 1.000 m2 | PO.02.30176 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000031583 | Hranaté potrubí | 101042x160165xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.16; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.2 m; Výška: 0.16 m
10104160160204xxxxxx0 | Půdorys 1.PP | m2 | 0.204 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/203.8943/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/203.89/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 204 | 160x160 | 160 | 160 | 0.000 | 1.000 m2 | PO.02.30177 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000059974 | Hranaté potrubí | 10104160160204xxxxxx0 | 1.000 m2 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.16 m; Výška: 0.16 m
10104560160186xxxxxx0 | Půdorys 1.PP | m2 | 0.186 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/160.0000/1/186.0000/0/0/0/0/0/1.0000/560.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/160.00/186.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 186 | 560x160 | 560 | 160 | 0.000 | 1.000 m2 | PO.02.30178 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000139780 | Hranaté potrubí | 10104560160186xxxxxx0 | 1.000 m2 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.56 m; Výška: 0.16 m
1010456016034xxxxxxx | Půdorys 1.PP | m2 | 0.34 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/160.0000/1/340.0000/0/0/0/0/0/1.0000/560.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/160.00/340.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 340 | 560x160 | 560 | 160 | 0.000 | 1.000 m2 | PO.02.30179 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000139810 | Hranaté potrubí | 1010456016034xxxxxxx | 1.000 m2 | NEMSOK - K_POSITION: L.12; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.56 m; Výška: 0.16 m
10104160160327xxxxxx0 | Půdorys 1.PP | m2 | 0.327 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/327.3654/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/327.37/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 327 | 160x160 | 160 | 160 | 0.000 | 1.000 m2 | PO.02.30180 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000139885 | Hranaté potrubí | 10104160160327xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.16 m; Výška: 0.16 m
10104160160767xxxxxx0 | Půdorys 1.PP | m2 | 0.767 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/766.6870/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/766.69/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 767 | 160x160 | 160 | 160 | 0.000 | 1.000 m2 | PO.02.30181 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000139930 | Hranaté potrubí | 10104160160767xxxxxx0 | 1.000 m2 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.16 m; Výška: 0.16 m
10104160160579xxxxxx0 | Půdorys 1.PP | m2 | 0.579 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/578.5961/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/578.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 579 | 160x160 | 160 | 160 | 0.000 | 1.000 m2 | PO.02.30182 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000139960 | Hranaté potrubí | 10104160160579xxxxxx0 | 1.000 m2 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.16 m; Výška: 0.16 m
10104160160767xxxxxx0 | Půdorys 1.PP | m2 | 0.767 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/766.8605/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/766.86/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 767 | 160x160 | 160 | 160 | 0.000 | 1.000 m2 | PO.02.30183 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000139990 | Hranaté potrubí | 10104160160767xxxxxx0 | 1.000 m2 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.16 m; Výška: 0.16 m
101052x160303xxxxxx0 | Půdorys 1.PP | m2 | 0.303 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/200.0000/160.0000/1/302.6000/0/0/0/0/0/1.0000/200.0000/160.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/160.00/302.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 303 | 200x160 | 200 | 160 | 0.000 | 1.000 m2 | PO.02.30184 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000140150 | Hranaté potrubí | 101052x160303xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.10; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.2 m; Výška: 0.16 m
10106160160628xxxxxx0 | Půdorys 1.PP | m2 | 0.628 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/627.9000/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/627.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 628 | 160x160 | 160 | 160 | 0.000 | 1.000 m2 | PO.02.30185 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000140555 | Hranaté potrubí | 10106160160628xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.17; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.16 m; Výška: 0.16 m
10106315160471xxxxxx0 | Půdorys 1.PP | m2 | 0.471 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/471.1000/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/471.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 471 | 315x160 | 315 | 160 | 0.000 | 1.000 m2 | PO.02.30186 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000140570 | Hranaté potrubí | 10106315160471xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.18; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.315 m; Výška: 0.16 m
10106355160248xxxxxx0 | Půdorys 1.PP | m2 | 0.248 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/355.0000/160.0000/1/248.3000/0/0/0/0/0/1.0000/355.0000/160.0000/1/ | 10/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/355.00/160.00/248.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 248 | 355x160 | 355 | 160 | 0.000 | 1.000 m2 | PO.02.30187 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000140585 | Hranaté potrubí | 10106355160248xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.19; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.355 m; Výška: 0.16 m
1010416016034xxxxxx0 | Půdorys 1.PP | m2 | 0.034 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/33.7259/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/33.73/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 34 | 160x160 | 160 | 160 | 0.000 | 1.000 m2 | PO.02.30188 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000140855 | Hranaté potrubí | 1010416016034xxxxxx0 | 1.000 m2 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.16 m; Výška: 0.16 m
10104160160943xxxxxx0 | Půdorys 1.PP | m2 | 0.943 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/942.9991/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/943.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 943 | 160x160 | 160 | 160 | 0.000 | 0.600 m2 | PO.02.30189 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000140885 | Hranaté potrubí | 10104160160943xxxxxx0 | 1.000 m2 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.16 m; Výška: 0.16 m
101055x16062xxxxxxx | Půdorys 1.PP | m2 | 0.62 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/500.0000/160.0000/1/620.0000/0/0/0/0/0/1.0000/500.0000/160.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/160.00/620.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 620 | 500x160 | 500 | 160 | 0.000 | 1.000 m2 | PO.02.30190 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000140935 | Hranaté potrubí | 101055x16062xxxxxxx | 1.020 m2 | NEMSOK - K_POSITION: L.25; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.5 m; Výška: 0.16 m
101045x16016xxxxxx0 | Půdorys 1.PP | m2 | 0.016 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/500.0000/160.0000/1/15.7700/0/0/0/0/0/1.0000/500.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/160.00/15.77/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 16 | 500x160 | 500 | 160 | 0.000 | 1.000 m2 | PO.02.30191 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000140970 | Hranaté potrubí | 101045x16016xxxxxx0 | 1.000 m2 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.5 m; Výška: 0.16 m
10104315160115xxxxxx0 | Půdorys 1.PP | m2 | 0.115 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/114.6774/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/114.68/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 115 | 315x160 | 315 | 160 | 0.000 | 1.000 m2 | PO.02.30192 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000141172 | Hranaté potrubí | 10104315160115xxxxxx0 | 1.000 m2 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.315 m; Výška: 0.16 m
10104315160393xxxxxx0 | Půdorys 1.PP | m2 | 0.393 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/392.8282/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/392.83/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 393 | 315x160 | 315 | 160 | 0.000 | 1.000 m2 | PO.02.30193 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000141202 | Hranaté potrubí | 10104315160393xxxxxx0 | 1.000 m2 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.315 m; Výška: 0.16 m
101045x16088xxxxxxx | Půdorys 1.PP | m2 | 0.88 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/500.0000/160.0000/1/880.0000/0/0/0/0/0/1.0000/500.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/160.00/880.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 880 | 500x160 | 500 | 160 | 0.000 | 1.160 m2 | PO.02.30194 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000141335 | Hranaté potrubí | 101045x16088xxxxxxx | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.5 m; Výška: 0.16 m
10104160160562xxxxxx0 | Půdorys 1.PP | m2 | 0.562 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/561.5000/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/561.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 562 | 160x160 | 160 | 160 | 0.000 | 1.000 m2 | PO.02.30195 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000141350 | Hranaté potrubí | 10104160160562xxxxxx0 | NEMSOK - K_POSITION: L.5; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.16 m; Výška: 0.16 m
10104160160467xxxxxx0 | Půdorys 1.PP | m2 | 0.467 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/467.2000/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/467.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 467 | 160x160 | 160 | 160 | 0.000 | 1.000 m2 | PO.02.30196 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000141365 | Hranaté potrubí | 10104160160467xxxxxx0 | NEMSOK - K_POSITION: L.6; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.16 m; Výška: 0.16 m
1010416016015xxxxxxx0 | Půdorys 1.PP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/1500.0000/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 160x160 | 160 | 160 | 0.000 | 0.960 m2 | PO.02.30197 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000141655 | Hranaté potrubí | 1010416016015xxxxxxx0 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.16 m; Výška: 0.16 m
1010416016089xxxxxx0 | Půdorys 1.PP | m2 | 0.089 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/88.8878/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/88.89/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 89 | 160x160 | 160 | 160 | 0.000 | 1.000 m2 | PO.02.30198 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000141670 | Hranaté potrubí | 1010416016089xxxxxx0 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.16 m; Výška: 0.16 m
1010416016052xxxxxx0 | Půdorys 1.PP | m2 | 0.052 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/51.8587/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/51.86/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 52 | 160x160 | 160 | 160 | 0.000 | 1.000 m2 | PO.02.30199 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000141700 | Hranaté potrubí | 1010416016052xxxxxx0 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.16 m; Výška: 0.16 m
1010416016015xxxxxxx0 | Půdorys 1.PP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/1500.0000/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 160x160 | 160 | 160 | 0.000 | 0.960 m2 | PO.02.30200 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000141730 | Hranaté potrubí | 1010416016015xxxxxxx0 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.16 m; Výška: 0.16 m
1010416016089xxxxxx0 | Půdorys 1.PP | m2 | 0.089 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/88.9558/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/88.96/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 89 | 160x160 | 160 | 160 | 0.000 | 1.000 m2 | PO.02.30201 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000141745 | Hranaté potrubí | 1010416016089xxxxxx0 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.16 m; Výška: 0.16 m
10106160160141xxxxxx0 | Půdorys 1.PP | m2 | 0.141 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/141.4000/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/141.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 141 | 160x160 | 160 | 160 | 0.000 | 1.000 m2 | PO.02.30202 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000141810 | Hranaté potrubí | 10106160160141xxxxxx0 | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.16 m; Výška: 0.16 m
101062x160317xxxxxx0 | Půdorys 1.PP | m2 | 0.317 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/200.0000/160.0000/1/316.5521/0/0/0/0/0/1.0000/200.0000/160.0000/1/ | 10/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/160.00/316.55/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 317 | 200x160 | 200 | 160 | 0.000 | 1.000 m2 | PO.02.30203 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000141825 | Hranaté potrubí | 101062x160317xxxxxx0 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.2 m; Výška: 0.16 m
101062x160245xxxxxx0 | Půdorys 1.PP | m2 | 0.245 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/200.0000/160.0000/1/245.3005/0/0/0/0/0/1.0000/200.0000/160.0000/1/ | 10/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/160.00/245.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 245 | 200x160 | 200 | 160 | 0.000 | 1.000 m2 | PO.02.30204 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000141855 | Hranaté potrubí | 101062x160245xxxxxx0 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.2 m; Výška: 0.16 m
101062x160317xxxxxx0 | Půdorys 1.PP | m2 | 0.317 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/200.0000/160.0000/1/316.8174/0/0/0/0/0/1.0000/200.0000/160.0000/1/ | 10/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/160.00/316.82/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 317 | 200x160 | 200 | 160 | 0.000 | 1.000 m2 | PO.02.30205 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000141885 | Hranaté potrubí | 101062x160317xxxxxx0 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.2 m; Výška: 0.16 m
10104250160992xxxxxx0 | Půdorys 1.PP | m2 | 0.992 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/250.0000/160.0000/1/991.8316/0/0/0/0/0/1.0000/250.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/160.00/991.83/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 992 | 250x160 | 250 | 160 | 0.000 | 0.810 m2 | PO.02.30206 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000142005 | Hranaté potrubí | 10104250160992xxxxxx0 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.25 m; Výška: 0.16 m
10104250160169xxxxxx0 | Půdorys 1.PP | m2 | 0.169 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/250.0000/160.0000/1/169.1713/0/0/0/0/0/1.0000/250.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/160.00/169.17/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 169 | 250x160 | 250 | 160 | 0.000 | 1.000 m2 | PO.02.30207 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000142035 | Hranaté potrubí | 10104250160169xxxxxx0 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.25 m; Výška: 0.16 m
10104250160992xxxxxx0 | Půdorys 1.PP | m2 | 0.992 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/250.0000/160.0000/1/992.0285/0/0/0/0/0/1.0000/250.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/160.00/992.03/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 992 | 250x160 | 250 | 160 | 0.000 | 0.810 m2 | PO.02.30208 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000142065 | Hranaté potrubí | 10104250160992xxxxxx0 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.25 m; Výška: 0.16 m
10104250160851xxxxxx0 | Půdorys 1.PP | m2 | 0.851 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/250.0000/160.0000/1/851.0409/0/0/0/0/0/1.0000/250.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/160.00/851.04/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 851 | 250x160 | 250 | 160 | 0.000 | 1.000 m2 | PO.02.30209 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000142080 | Hranaté potrubí | 10104250160851xxxxxx0 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.25 m; Výška: 0.16 m
