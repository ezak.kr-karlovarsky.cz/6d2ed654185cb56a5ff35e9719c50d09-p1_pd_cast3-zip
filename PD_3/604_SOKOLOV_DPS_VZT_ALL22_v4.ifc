Properties of the parts of a building model (IFC2X3), part 8 of 51

# IfcFlowFitting (2887)
Name | In | Jednotka | Délka (m) | Označení | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_DIM | L_BES_DIM_A2 | L_BES_DIM_B2 | L_BES_DIM_A | K_VOLSTROM | K_MLH_GOST = K_MLD_GOST | K_LISTVALUE | Kód prvku | Třída reakce na oheň | Allright_Stavebni_dil_ID | Název_objektu | K_EBT_BOX_WC | Plocha | L_BES_LAENGE | K_INTERNAL_ISO | Tloušťka (m) | Součinitel tepelné vodivost
2010556056x50504x1x904xxxx0 | Půdorys 1.PP | m2 | 0 | 2010556056x50504x1x904xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/180.0/560.0000/560.0000/400.0000/1/430.0000/430.0000/0/90.0/0/180.0/1.0000/560.0000/400.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/0/50.00/50.00/400.00/100.00/90.00/180.00/1.00/400.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 2.180 m2 | TA.02.30071 | A1 | 6772Obj0000137829 | Objekt | NEMSOK - K_POSITION: L.23; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.0056 m; Výška: 0.004 m
411055604x50504x56x377-80-8x1603 | Půdorys 1.PP | m2 | 0.377 | 411055604x50504x56x377-80-8x1603 | UEBERGANG ASYM. | 20 | 41 | 2/0/0/0/180.0/0/0/560.0000/560.0000/400.0000/1/377.1000/0/-80.0000/0/0/0/0/400.0000/560.0000/1/ | 41/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/50.00/50.00/400.00/560.00/0/377.10/-80.00/-80.00/0/160.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 400 | 560 | 560 | 0.000 | 0 | 1.000 m2 | TA.02.30072 | A1 | 6772Obj0000137843 | Objekt |  |  | 377 | NEMSOK - K_POSITION: L.25; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.004 m; Výška: 0.0056 m
201054x4x050505601x3xxxx0 | Půdorys 1.PP | m2 | 0 | 201054x4x050505601x3xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/90.0/560.0000/560.0000/400.0000/1/243.3013/65.1924/0/30.0/0/90.0/1.0000/560.0000/400.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/400.00/0/50.00/50.00/560.00/100.00/30.00/90.00/1.00/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 1.000 m2 | TA.02.30077 | A1 | 6772Obj0000138742 | Objekt | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.0056 m; Výška: 0.004 m
201054x4x050505601x3xxxx0 | Půdorys 1.PP | m2 | 0 | 201054x4x050505601x3xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/90.0/560.0000/560.0000/400.0000/1/243.3013/65.1924/0/30.0/0/90.0/1.0000/560.0000/400.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/400.00/0/50.00/50.00/560.00/100.00/30.00/90.00/1.00/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 1.000 m2 | TA.02.30078 | A1 | 6772Obj0000138772 | Objekt | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.0056 m; Výška: 0.004 m
2010456056x50504x1x904xxxx0 | Půdorys 1.PP | m2 | 0 | 2010456056x50504x1x904xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/0/560.0000/560.0000/400.0000/1/380.0000/380.0000/0/90.0/0/0/1.0000/560.0000/400.0000/1/ | 20/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/560.00/0/50.00/50.00/400.00/50.00/90.00/0/1.00/400.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 2.030 m2 | TA.02.30080 | A1 | 6772Obj0000139325 | Objekt | 700.000/400.000/220.000/0.000/-300.000/-220.000/0.000/0.000/0.000/1.000 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.0056 m; Výška: 0.004 m
201054x4x050505601x304xxxx0 | Půdorys 1.PP | m2 | 0 | 201054x4x050505601x304xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/270.0/560.0000/560.0000/400.0000/1/243.3013/65.1924/0/30.0/0/270.0/1.0000/560.0000/400.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/400.00/0/50.00/50.00/560.00/100.00/30.00/270.00/1.00/400.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 1.000 m2 | TA.02.30084 | A1 | 6772Obj0000139519 | Objekt | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.0056 m; Výška: 0.004 m
201054x4x050505601x304xxxx0 | Půdorys 1.PP | m2 | 0 | 201054x4x050505601x304xxxx0 | BOGEN SYM. | 20 | 20 | 2/0/0/0/180.0/0/270.0/560.0000/560.0000/400.0000/1/243.3013/65.1924/0/30.0/0/270.0/1.0000/560.0000/400.0000/1/ | 20/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/400.00/0/50.00/50.00/560.00/100.00/30.00/270.00/1.00/400.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 560 | 400 | 560 | 0.000 | 0 | 1.000 m2 | TA.02.30085 | A1 | 6772Obj0000139549 | Objekt | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.0056 m; Výška: 0.004 m
411045608x50504x5x0516240-0-2312 | Půdorys 1.PP | m2 | 0.516 | 411045608x50504x5x0516240-0-2312 | UEBERGANG ASYM. | 20 | 41 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/515.7000/-120.0000/-72.5000/0/0/0/0/800.0000/500.0000/1/ | 41/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/800.00/50.00/50.00/400.00/500.00/0/515.70/240.00/-0.00/-22.50/122.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 560x400 | 800 | 500 | 560 | 0.000 | 0 | 1.480 m2 | TA.02.30104 | A1 | 6772Obj0000144928 | Objekt |  | 1.48 | 516 | NEMSOK - K_POSITION: L.28; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.008 m; Výška: 0.005 m
201048x8x0505012501x90125xxxx | Půdorys 1.PP | m2 | 0 | 201048x8x0505012501x90125xxxx | BOGEN ASY. | 20 | 21 | 2/0/0/0/180.0/0/0/800.0000/800.0000/1250.0000/1/505.0000/550.0000/0/90.0/0/270.0/1.0000/1250.0000/710.0000/1/ | 21/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/800.00/710.00/0/50.00/50.00/1250.00/100.00/90.00/0/1.00/1250.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/1.00 | SB 30/SB 30/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 800x1250 | 1250 | 710 | 800 | 0.000 | 0 | 6.210 m2 | TA.02.30111 | A1 | 6772Obj0000000501 | Objekt | 970.000/550.000/645.000/0.000/-420.000/-645.000/0.000/0.000/0.000/1.000 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1250; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.00125 m; Výška: 0.0071 m
411058x56050505x4x0516-24x-50-50 | Půdorys 1.PP | m2 | 0.516 | 411058x56050505x4x0516-24x-50-50 | UEBERGANG ASYM. | 20 | 41 | 2/0/0/0/180.0/0/0/800.0000/800.0000/500.0000/1/515.7000/120.0000/-0/0/0/0/0/560.0000/400.0000/1/ | 41/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/800.00/560.00/50.00/50.00/500.00/400.00/0/515.70/-240.00/0/-50.00/-50.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 800x500 | 560 | 400 | 800 | 0.000 | 0 | 1.480 m2 | TA.02.30076 | A1 | 6772Obj0000138694 | Objekt |  |  | 516 | NEMSOK - K_POSITION: L.11; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 500; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.0056 m; Výška: 0.004 m
411058604x505076056x498-230-230- | Půdorys 1.PP | m2 | 0.498 | 411058604x505076056x498-230-230- | UEBERGANG ASYM. | 20 | 41 | 2/0/0/0/180.0/0/0/860.0000/860.0000/760.0000/1/498.4000/0/-100.0000/0/0/0/0/400.0000/560.0000/1/ | 41/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/860.00/400.00/50.00/50.00/760.00/560.00/0/498.40/-230.00/-230.00/-200.00/0/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 30/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 860x760 | 400 | 560 | 860 | 0.000 | 0 | 1.780 m2 | TA.02.30079 | A1 | 6772Obj0000139280 | Objekt |  |  | 498 | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 760; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.004 m; Výška: 0.0056 m
4110586056050507604x0492-150-150 | Půdorys 1.PP | m2 | 0.492 | 4110586056050507604x0492-150-150 | UEBERGANG ASYM. | 20 | 41 | 2/0/0/0/180.0/0/0/1.0000/860.0000/760.0000/1/492.3000/0/-46.5000/0/0/0/0/560.0000/400.0000/1/ | 41/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/860.00/560.00/50.00/50.00/760.00/400.00/0/492.30/-150.00/-150.00/-226.50/-133.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 30/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 860x760 | 560 | 400 | 860 | 0.000 | 0 | 1.760 m2 | TA.02.30082 | A1 | 6772Obj0000139466 | Objekt |  |  | 492 | NEMSOK - K_POSITION: L.7; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 760; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.0056 m; Výška: 0.004 m
4110586056050507604x0358-150-150 | Půdorys 1.PP | m2 | 0.358 | 4110586056050507604x0358-150-150 | UEBERGANG ASYM. | 20 | 41 | 2/0/0/0/180.0/0/0/1.0000/860.0000/760.0000/1/357.8000/0/-1.5000/0/0/0/0/560.0000/400.0000/1/ | 41/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/860.00/560.00/50.00/50.00/760.00/400.00/0/357.80/-150.00/-150.00/-181.50/-178.50/35.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 30/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 860x760 | 560 | 400 | 860 | 0.000 | 0 | 1.300 m2 | TA.02.30083 | A1 | 6772Obj0000139488 | Objekt |  |  | 358 | NEMSOK - K_POSITION: L.6; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 760; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.0056 m; Výška: 0.004 m
411058604x505076056x324-230-230- | Půdorys 1.PP | m2 | 0.324 | 411058604x505076056x324-230-230- | UEBERGANG ASYM. | 20 | 41 | 2/0/0/0/180.0/0/0/1.0000/860.0000/760.0000/1/324.4000/0/100.0000/0/0/0/0/400.0000/560.0000/1/ | 41/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/860.00/400.00/50.00/50.00/760.00/560.00/0/324.40/-230.00/-230.00/0/-200.00/46.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 30/SB 20/// | Mineralwolle/0.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 860x760 | 400 | 560 | 860 | 0.000 | 0 | 1.290 m2 | TA.02.30110 | A1 | 6772Obj0000160286 | Objekt | 324.400/450.000/400.000/0.000/-450.000/-400.000/0.000/0.000/0.000/1.000 | 1.29 | 324 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 760; K_LISTVALUE_ISO: 1.290 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: 160 mm; Šířka: 0.004 m; Výška: 0.0056 m
252x125012519xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.30011 | A1 | 6772Obj0000136034 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 125; Šířka: 1.6 m; Výška: 0.16 m
3020612516x012516x78181818183xx | Půdorys 1.PP | Stk | 0.078 | 3020612516x012516x78181818183xx | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/78.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 30/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/160.00/0/0/125.00/160.00/0/78.00/17.50/17.50/17.50/17.50/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 160 | 160 | 125 | 0.000 | 0 | 1.0 | TA.02.30012 | A1 | 6772Obj0000136044 | Objekt |  |  | 78 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 125; Šířka: 1.6 m; Výška: 0.16 m
252x125012519xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.30017 | A1 | 6772Obj0000136169 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 125; Šířka: 1.6 m; Výška: 0.16 m
502161252x351x1251x1252x3838-13- | Půdorys 1.PP | m2 | 0.2 | 502161252x351x1251x1252x3838-13- | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/200.0000/0/0/0/0/0/0/200.0000/100.0000/1/ | 50/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/125.00/200.00/35.00/100.00/125.00/100.00/125.00/200.00/37.50/37.50/-12.50/-12.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 200 | 100 | 125 | 0.000 | 0 | 1.000 m2 | TA.02.30028 | A1 | 6772Obj0000136600 | Objekt |  |  | 200 | NEMSOK - K_POSITION: L.10; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); Podlaží: Podzemní podlaží 1.PP; Průměr: 125; Šířka: 1.6 m; Výška: 0.16 m
502161252x351x1251x1252x3838-13- | Půdorys 1.PP | m2 | 0.2 | 502161252x351x1251x1252x3838-13- | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/200.0000/0/0/0/0/0/0/200.0000/100.0000/1/ | 50/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/125.00/200.00/35.00/100.00/125.00/100.00/125.00/200.00/37.50/37.50/-12.50/-12.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 200 | 100 | 125 | 0.000 | 0 | 1.000 m2 | TA.02.30029 | A1 | 6772Obj0000136602 | Objekt |  |  | 200 | NEMSOK - K_POSITION: L.10; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); Podlaží: Podzemní podlaží 1.PP; Průměr: 125; Šířka: 1.6 m; Výška: 0.16 m
252x1250125145xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.30030 | A1 | 6772Obj0000136623 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 125; Šířka: 1.6 m; Výška: 0.16 m
252x1250125145xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/0/125.0000/125.0000/125.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.30031 | A1 | 6772Obj0000136633 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 125; Šířka: 1.6 m; Výška: 0.16 m
252x125012519xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/0/125.0000/125.0000/125.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.30032 | A1 | 6772Obj0000136638 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 125; Šířka: 1.6 m; Výška: 0.16 m
252x1250125145xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/0/125.0000/125.0000/125.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.30033 | A1 | 6772Obj0000136648 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 125; Šířka: 1.6 m; Výška: 0.16 m
252x1250125145xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/0/125.0000/125.0000/125.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.30034 | A1 | 6772Obj0000136658 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 125; Šířka: 1.6 m; Výška: 0.16 m
252x125012519xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.30035 | A1 | 6772Obj0000136670 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 125; Šířka: 1.6 m; Výška: 0.16 m
252x125012519xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/0/125.0000/125.0000/125.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.30036 | A1 | 6772Obj0000136710 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 125; Šířka: 1.6 m; Výška: 0.16 m
252x125012519xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.30037 | A1 | 6772Obj0000136730 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 125; Šířka: 1.6 m; Výška: 0.16 m
3020612516x012516x78181818183xx | Půdorys 1.PP | Stk | 0.078 | 3020612516x012516x78181818183xx | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/78.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 30/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/160.00/0/0/125.00/160.00/0/78.00/17.50/17.50/17.50/17.50/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 160 | 160 | 125 | 0.000 | 0 | 1.0 | TA.02.30038 | A1 | 6772Obj0000136740 | Objekt |  |  | 78 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 125; Šířka: 1.6 m; Výška: 0.16 m
3020612516x012516x78181818183xx | Půdorys 1.PP | Stk | 0.078 | 3020612516x012516x78181818183xx | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/78.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 30/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/160.00/0/0/125.00/160.00/0/78.00/17.50/17.50/17.50/17.50/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 160 | 160 | 125 | 0.000 | 0 | 1.0 | TA.02.30039 | A1 | 6772Obj0000136747 | Objekt |  |  | 78 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 125; Šířka: 1.6 m; Výška: 0.16 m
252x125012519xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.30045 | A1 | 6772Obj0000136900 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 125; Šířka: 1.6 m; Výška: 0.16 m
3020512516x012516x78181818183xx | Půdorys 1.PP | Stk | 0.078 | 3020512516x012516x78181818183xx | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/78.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 30/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/160.00/0/0/125.00/160.00/0/78.00/17.50/17.50/17.50/17.50/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 160 | 160 | 125 | 0.000 | 0 | 1.0 | TA.02.30046 | A1 | 6772Obj0000136910 | Objekt |  |  | 78 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 125; Šířka: 1.6 m; Výška: 0.16 m
252x125012519xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.30047 | A1 | 6772Obj0000136941 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 125; Šířka: 1.6 m; Výška: 0.16 m
3020512516x012516x78181818183xx | Půdorys 1.PP | Stk | 0.078 | 3020512516x012516x78181818183xx | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/78.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 30/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/160.00/0/0/125.00/160.00/0/78.00/17.50/17.50/17.50/17.50/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 160 | 160 | 125 | 0.000 | 0 | 1.0 | TA.02.30048 | A1 | 6772Obj0000136946 | Objekt |  |  | 78 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 125; Šířka: 1.6 m; Výška: 0.16 m
252x125012513xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012513xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.30058 | A1 | 6772Obj0000137132 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 125; Šířka: 1.6 m; Výška: 0.16 m
252x125012513xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012513xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.30059 | A1 | 6772Obj0000137142 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 125; Šířka: 1.6 m; Výška: 0.16 m
252x125012513xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012513xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.30060 | A1 | 6772Obj0000137148 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 125; Šířka: 1.6 m; Výška: 0.16 m
252x125012513xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012513xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.30061 | A1 | 6772Obj0000137150 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 125; Šířka: 1.6 m; Výška: 0.16 m
252x125012513xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012513xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.30065 | A1 | 6772Obj0000137319 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 125; Šířka: 1.6 m; Výška: 0.16 m
252x125012513xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012513xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.30066 | A1 | 6772Obj0000137329 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 125; Šířka: 1.6 m; Výška: 0.16 m
252x125012519xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.30088 | A1 | 6772Obj0000141375 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 125; Šířka: 1.6 m; Výška: 0.16 m
252x125012519xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.30089 | A1 | 6772Obj0000141385 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 125; Šířka: 1.6 m; Výška: 0.16 m
252x125012513xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012513xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.30090 | A1 | 6772Obj0000141400 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 125; Šířka: 1.6 m; Výška: 0.16 m
252x125012513xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012513xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.30091 | A1 | 6772Obj0000141410 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 125; Šířka: 1.6 m; Výška: 0.16 m
252x125012513xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012513xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.30092 | A1 | 6772Obj0000141478 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 125; Šířka: 1.6 m; Výška: 0.16 m
252x125012513xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012513xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.30093 | A1 | 6772Obj0000141488 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 125; Šířka: 1.6 m; Výška: 0.16 m
252x125012513xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012513xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.30094 | A1 | 6772Obj0000141503 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 125; Šířka: 1.6 m; Výška: 0.16 m
252x125012513xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012513xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.30095 | A1 | 6772Obj0000141513 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 125; Šířka: 1.6 m; Výška: 0.16 m
252x125012513xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012513xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/269.6/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/269.6/125.0000/125.0000/125.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/269.60/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.30099 | A1 | 6772Obj0000143706 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 125; Šířka: 1.6 m; Výška: 0.16 m
252x125012513xxxxxx | Půdorys 1.PP | Stk | 0 | 252x125012513xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/89.4/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/89.4/125.0000/125.0000/125.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/89.40/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.02.30100 | A1 | 6772Obj0000143716 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 125; Šířka: 1.6 m; Výška: 0.16 m
502161252x351x1251501252x3838131 | Půdorys 1.PP | m2 | 0.2 | 502161252x351x1251501252x3838131 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/200.0000/0/0/0/0/0/0/200.0000/150.0000/1/ | 50/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/125.00/200.00/35.00/100.00/125.00/150.00/125.00/200.00/37.50/37.50/12.50/12.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 200 | 150 | 125 | 0.000 | 0 | 1.000 m2 | TA.02.30101 | A1 | 6772Obj0000143755 | Objekt |  | 1 | 200 | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); Podlaží: Podzemní podlaží 1.PP; Průměr: 125; Šířka: 1.6 m; Výška: 0.16 m
502161252x351x1251501252x3838131 | Půdorys 1.PP | m2 | 0.2 | 502161252x351x1251501252x3838131 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/200.0000/0/0/0/0/0/0/200.0000/150.0000/1/ | 50/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/125.00/200.00/35.00/100.00/125.00/150.00/125.00/200.00/37.50/37.50/12.50/12.50/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 200 | 150 | 125 | 0.000 | 0 | 1.000 m2 | TA.02.30102 | A1 | 6772Obj0000143761 | Objekt |  | 1 | 200 | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); Podlaží: Podzemní podlaží 1.PP; Průměr: 125; Šířka: 1.6 m; Výška: 0.16 m
7520416016016x26x13x9xxxx | Půdorys 1.PP | Stk | 0.26 | 7520416016016x26x13x9xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/260.0000/0/0/0/0/0/50.0000/160.0000/160.0000/2/130.0000/130.0000/0/90.0/0/0/160.0000/160.0000/160.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/160.00/0/0/260.00/0/130.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.02.30014 | A1 | 6772Obj0000136134 | Objekt |  |  | 260 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 160; Šířka: 1.6 m; Výška: 0.16 m
252x16x16019xxxxxx | Půdorys 1.PP | Stk | 0 | 252x16x16019xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/180.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/180.00/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.02.30015 | A1 | 6772Obj0000136144 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 160; Šířka: 1.6 m; Výška: 0.16 m
252x16x16019xxxxxx | Půdorys 1.PP | Stk | 0 | 252x16x16019xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/0/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.02.30016 | A1 | 6772Obj0000136154 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 160; Šířka: 1.6 m; Výška: 0.16 m
7520516016016x26x13x9xxxx | Půdorys 1.PP | Stk | 0.26 | 7520516016016x26x13x9xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/260.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/130.0000/130.0000/0/90.0/0/0/160.0000/160.0000/160.0000/2/ | 75/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/160.00/0/0/260.00/0/130.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.02.30049 | A1 | 6772Obj0000136952 | Objekt |  |  | 260 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 160; Šířka: 1.6 m; Výška: 0.16 m
30205160125x160125078-18-18-18-1 | Půdorys 1.PP | Stk | 0.078 | 30205160125x160125078-18-18-18-1 | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/78.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 30/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/125.00/0/0/160.00/125.00/0/78.00/-17.50/-17.50/-17.50/-17.50/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 125 | 125 | 160 | 0.000 | 0 | 1.0 | TA.02.30050 | A1 | 6772Obj0000136957 | Objekt |  |  | 78 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 160; Šířka: 1.6 m; Výška: 0.16 m
252x16x160145xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.02.30054 | A1 | 6772Obj0000136979 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 160; Šířka: 1.6 m; Výška: 0.16 m
252x16x160145xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/270.0/160.0000/160.0000/160.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.02.30055 | A1 | 6772Obj0000136989 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 160; Šířka: 1.6 m; Výška: 0.16 m
7520416016016x26x13x9xxxx | Půdorys 1.PP | Stk | 0.26 | 7520416016016x26x13x9xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/45.0/160.0000/160.0000/160.0000/2/260.0000/0/0/0/0/45.0/1.0000/160.0000/160.0000/2/130.0000/130.0000/0/90.0/0/45.0/160.0000/160.0000/160.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/160.00/0/45.00/260.00/0/130.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.02.30056 | A1 | 6772Obj0000137100 | Objekt | 260.000/130.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 |  | 260 | NEMSOK - K_POSITION: L.1; Podlaží: Podzemní podlaží 1.PP; Průměr: 160; Šířka: 1.6 m; Výška: 0.16 m
252x16x160145xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/270.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.02.30057 | A1 | 6772Obj0000137115 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 160; Šířka: 1.6 m; Výška: 0.16 m
252x16x160145xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/0/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/0/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.02.30062 | A1 | 6772Obj0000137160 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 160; Šířka: 1.6 m; Výška: 0.16 m
252x16x160145xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/0/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/0/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.02.30063 | A1 | 6772Obj0000137170 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 160; Šířka: 1.6 m; Výška: 0.16 m
7520416016016x26x13x9xxxx | Půdorys 1.PP | Stk | 0.26 | 7520416016016x26x13x9xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/260.0000/0/0/0/0/0/1.0000/160.0000/160.0000/2/130.0000/130.0000/0/90.0/0/0/160.0000/160.0000/160.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/160.00/0/0/260.00/0/130.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.02.30086 | A1 | 6772Obj0000139648 | Objekt |  |  | 260 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 160; Šířka: 1.6 m; Výška: 0.16 m
252x16x16019xxxxxx | Půdorys 1.PP | Stk | 0 | 252x16x16019xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/180.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/180.00/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.02.30087 | A1 | 6772Obj0000139663 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 160; Šířka: 1.6 m; Výška: 0.16 m
252x16x16013xxxxxx | Půdorys 1.PP | Stk | 0 | 252x16x16013xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.02.30096 | A1 | 6772Obj0000143676 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 160; Šířka: 1.6 m; Výška: 0.16 m
3020416016x016016x96x0-03xx | Půdorys 1.PP | Stk | 0.096 | 3020416016x016016x96x0-03xx | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/2/96.0000/0/0.0388/0/0/0/160.0000/160.0000/160.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/0/160.00/160.00/0/96.00/0/0/0.04/-0.04/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.02.30097 | A1 | 6772Obj0000143681 | Objekt |  |  | 96 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 160; Šířka: 1.6 m; Výška: 0.16 m
252x16x16013xxxxxx | Půdorys 1.PP | Stk | 0 | 252x16x16013xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/270.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.00/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.02.30098 | A1 | 6772Obj0000143691 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 160; Šířka: 1.6 m; Výška: 0.16 m
252x16x160145xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/270.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.02.30105 | A1 | 6772Obj0000160146 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 160; Šířka: 1.6 m; Výška: 0.16 m
252x16x160145xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.02.30106 | A1 | 6772Obj0000160156 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 160; Šířka: 1.6 m; Výška: 0.16 m
252x16x160145xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.02.30107 | A1 | 6772Obj0000160171 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 160; Šířka: 1.6 m; Výška: 0.16 m
3020416016x016016x96x0-03xx | Půdorys 1.PP | Stk | 0.096 | 3020416016x016016x96x0-03xx | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/2/96.0000/0/0.0439/0/0/0/160.0000/160.0000/160.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/0/160.00/160.00/0/96.00/0/0/0.04/-0.04/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.02.30108 | A1 | 6772Obj0000160176 | Objekt |  |  | 96 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 160; Šířka: 1.6 m; Výška: 0.16 m
252x16x160145xxxxx0 | Půdorys 1.PP | Stk | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/270.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.02.30109 | A1 | 6772Obj0000160186 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 160; Šířka: 1.6 m; Výška: 0.16 m
252x224022419xxxxxx | Půdorys 1.PP | Stk | 0 | 252x224022419xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/224.0000/224.0000/224.0000/2/224.0000/224.0000/0/90.0/0/90.0/224.0000/224.0000/224.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/224.00/90.00/0/224.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN224 | 224 | 224 | 224 | 0.000 | 0 | 1.0 | TA.02.30027 | A1 | 6772Obj0000136536 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 224; Šířka: 1.6 m; Výška: 0.16 m
252x224022419xxxxxx | Půdorys 1.PP | Stk | 0 | 252x224022419xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/224.0000/224.0000/224.0000/2/224.0000/224.0000/0/90.0/0/90.0/224.0000/224.0000/224.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/224.00/90.00/0/224.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN224 | 224 | 224 | 224 | 0.000 | 0 | 1.0 | TA.02.30040 | A1 | 6772Obj0000136813 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 224; Šířka: 1.6 m; Výška: 0.16 m
252x224022419xxxxxx | Půdorys 1.PP | Stk | 0 | 252x224022419xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/224.0000/224.0000/224.0000/2/224.0000/224.0000/0/90.0/0/90.0/224.0000/224.0000/224.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/224.00/0/0/224.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN224 | 224 | 224 | 224 | 0.000 | 0 | 1.0 | TA.02.30042 | A1 | 6772Obj0000136824 | Objekt | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 224; Šířka: 1.6 m; Výška: 0.16 m
7520522422416x26x16509xxxx | Půdorys 1.PP | Stk | 0.26 | 7520522422416x26x16509xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/0/224.0000/224.0000/224.0000/2/260.0000/0/0/0/0/0/224.0000/224.0000/224.0000/2/130.0000/165.0000/0/90.0/0/0/160.0000/160.0000/160.0000/2/ | 75/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/224.00/224.00/160.00/0/0/260.00/0/165.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN224 | 224 | 224 | 224 | 0.000 | 0 | 1.0 | TA.02.30043 | A1 | 6772Obj0000136835 | Objekt |  |  | 260 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 224; Šířka: 1.6 m; Výška: 0.16 m
752062242242240355018x9xxxx | Půdorys 1.PP | Stk | 0.355 | 752062242242240355018x9xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/270.0/224.0000/224.0000/224.0000/2/180.0000/-177.5000/0/270.0/0/270.0/125.0000/224.0000/224.0000/2/180.0000/177.5000/0/90.0/0/270.0/224.0000/224.0000/224.0000/2/ | 75/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/224.00/224.00/224.00/0/270.00/355.00/0/180.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN224 | 224 | 224 | 224 | 0.000 | 0 | 1.0 | TA.02.30051 | A1 | 6772Obj0000136963 | Objekt |  |  | 355 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 224; Šířka: 1.6 m; Výška: 0.16 m
3020622416x022416x118-32-32-32-3 | Půdorys 1.PP | Stk | 0.118 | 3020622416x022416x118-32-32-32-3 | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/224.0000/224.0000/224.0000/2/118.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 30/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/224.00/160.00/0/0/224.00/160.00/0/118.00/-32.00/-32.00/-32.00/-32.00/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN224 | 160 | 160 | 224 | 0.000 | 0 | 1.0 | TA.02.30052 | A1 | 6772Obj0000136968 | Objekt |  |  | 118 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 224; Šířka: 1.6 m; Výška: 0.16 m
3020622416x022416x118-32-32-32-3 | Půdorys 1.PP | Stk | 0.118 | 3020622416x022416x118-32-32-32-3 | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/224.0000/224.0000/224.0000/2/118.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 30/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/224.00/160.00/0/0/224.00/160.00/0/118.00/-32.00/-32.00/-32.00/-32.00/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN224 | 160 | 160 | 224 | 0.000 | 0 | 1.0 | TA.02.30053 | A1 | 6772Obj0000136969 | Objekt |  |  | 118 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 224; Šířka: 1.6 m; Výška: 0.16 m
3120522416x022416x118-32-320-643 | Půdorys 1.PP | Stk | 0.118 | 3120522416x022416x118-32-320-643 | UE RUND AS | 20 | 31 | 2/0/0/0/180.0/0/0/224.0000/224.0000/224.0000/2/118.0000/0/32.0000/0/0/0/160.0000/160.0000/160.0000/2/ | 31/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/224.00/160.00/0/0/224.00/160.00/0/118.00/-32.00/-32.00/0/-64.00/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN224 | 160 | 160 | 224 | 0.000 | 0 | 1.0 | TA.02.30064 | A1 | 6772Obj0000137186 | Objekt |  |  | 118 | NEMSOK - Podlaží: Podzemní podlaží 1.PP; Průměr: 224; Šířka: 1.6 m; Výška: 0.16 m
 | Půdorys 1.PP | m | 1.098 |  | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1097.6000/125.0000/125.0000/2/1097.6000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/1097.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 120.000 | 0 | 1.098 m | PO.02.30266 | A1 | 6772Obj0000001020 | Kruhové potrubí |  |  | 1098 | NEMSOK - K_LISTVALUE_ISO: 0.707 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: DN125; Teplonosná látka: vzduch
15206125125188xxxxxx0 | Půdorys 1.PP | m | 0.188 | 15206125125188xxxxxx0 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/188.3000/125.0000/125.0000/2/188.3000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/188.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 0.188 m | PO.02.30268 | A1 | 6772Obj0000001084 | Kruhové potrubí |  |  | 188 | NEMSOK - K_LISTVALUE_ISO: 0.121 m2; Podlaží: Podzemní podlaží 1.PP; Průměr: DN125; Teplonosná látka: vzduch
10104315160115xxxxxx0 | Půdorys 1.PP | Kus | 0.05 | 10104315160115xxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/300.0000/400.0000/1/50.0000/0/0/0/0/0/1.0000/300.0000/400.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/300.00/400.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 300x400 | 300 | 400 | 300 | 0.000 | 0 | 1.000 m2 | IT.02.30001 | B | 6774Obj0000008310 | Objekt | 50.000/170.000/220.000/0.000/-170.000/-220.000/0.000/0.000/0.000/1.000 | 1 | 50 | __ISO | 0.05 | 0,041 W/m.K | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; K_LISTVALUE_ISO: 1.000 m2
101043x4x5xxxxxxx | Půdorys 1.PP | Kus | 0 | 101043x4x5xxxxxxx | BOGEN ASY. | 20 | 1016 | 2/0/0/0/180.0/0/270.0/300.0000/300.0000/400.0000/1/307.5000/350.0000/0/90.0/0/270.0/0/300.0000/315.0000/1/ | 21/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/315.00/0/50.00/50.00/300.00/100.00/90.00/270.00/0/300.00/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 300x400 | 300 | 315 | 300 | 0.000 | 0 | 1.240 m2 | IT.02.30002 | B | 6774Obj0000008354 | Objekt | 485.000/350.000/170.000/0.000/-220.000/-170.000/0.000/0.000/0.000/1.000 | 1.24 |  | __ISO | 0.05 | 0,041 W/m.K | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; K_LISTVALUE_ISO: 2.290 m2
211044x315050503x1x903xxxx0 | Půdorys 1.PP | Kus | 0.1 | 211044x315050503x1x903xxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/315.0000/1/100.0000/0/0/0/0/0/1.0000/315.0000/315.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x315 | 315 | 315 | 315 | 0.000 | 0 | 1.000 m2 | IT.02.30003 | B | 6774Obj0000008368 | Objekt | 100.000/177.500/177.500/0.000/-177.500/-177.500/0.000/0.000/0.000/1.000 | 1 | 100 | __ISO | 0.05 | 0,041 W/m.K | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 315; K_LISTVALUE_ISO: 1.000 m2
101053153151xxxxxxx0 | Půdorys 1.PP | Kus | 0.05 | 101053153151xxxxxxx0 | LUFTLEITUNG | 10 | 1016 | 2/0/0/0/180.0/0/0/1.0000/315.0000/315.0000/1/50.0000/0/0/0/0/0/1.0000/315.0000/315.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/315.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 315x315 | 315 | 315 | 315 | 0.000 | 0 | 1.000 m2 | IT.02.30004 | B | 6774Obj0000008382 | Objekt | 50.000/177.500/177.500/0.000/-177.500/-177.500/0.000/0.000/0.000/1.000 | 1 | 50 | __ISO | 0.05 | 0,041 W/m.K | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 315; K_LISTVALUE_ISO: 1.000 m2
