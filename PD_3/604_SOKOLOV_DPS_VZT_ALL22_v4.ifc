Properties of the parts of a building model (IFC2X3), part 41 of 51

# IfcFlowSegment (1090)
Name | In | Jednotka | Délka (m) | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_LAENGE | L_BES_DIM | L_BES_DIM_A2 = L_BES_DIM_A | L_BES_DIM_B2 | K_VOLSTROM | K_LISTVALUE | Kód prvku | Podlaží | Průměr | Teplonosná látka | Allright_Stavebni_dil_ID | Název_objektu | Označení | K_LISTVALUE_ISO
1010425016033xxxxxxx | Půdorys 1.PP | m2 | 0.33 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/250.0000/160.0000/1/329.8835/0/0/0/0/0/1.0000/250.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/160.00/329.88/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 330 | 250x160 | 250 | 160 | 0.000 | 1.000 m2 | PO.02.30210 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000142110 | Hranaté potrubí | 1010425016033xxxxxxx | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.25 m; Výška: 0.16 m
10104450315304xxxxxx0 | Půdorys 1.PP | m2 | 0.304 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/450.0000/315.0000/1/303.5000/0/0/0/0/0/1.0000/450.0000/315.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/315.00/303.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 304 | 450x315 | 450 | 315 | 0.000 | 1.000 m2 | PO.02.30211 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000142335 | Hranaté potrubí | 10104450315304xxxxxx0 | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 315; Šířka: 0.45 m; Výška: 0.315 m
1010416016018xxxxxxx | Půdorys 1.PP | m2 | 0.18 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/180.0000/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/180.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 180 | 160x160 | 160 | 160 | 0.000 | 1.000 m2 | PO.02.30212 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000142467 | Hranaté potrubí | 1010416016018xxxxxxx | 1.000 m2 | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.16 m; Výška: 0.16 m
1010416016017xxxxxxx | Půdorys 1.PP | m2 | 0.17 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/169.7000/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/169.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 170 | 160x160 | 160 | 160 | 0.000 | 1.000 m2 | PO.02.30213 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000142471 | Hranaté potrubí | 1010416016017xxxxxxx | 1.000 m2 | NEMSOK - K_POSITION: L.13; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.16 m; Výška: 0.16 m
10104160160187xxxxxx0 | Půdorys 1.PP | m2 | 0.187 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/186.6154/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/186.62/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 187 | 160x160 | 160 | 160 | 0.000 | 1.000 m2 | PO.02.30214 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000142520 | Hranaté potrubí | 10104160160187xxxxxx0 | NEMSOK - K_POSITION: L.6; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.16 m; Výška: 0.16 m
10104160160392xxxxxx0 | Půdorys 1.PP | m2 | 0.392 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/392.3000/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/392.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 392 | 160x160 | 160 | 160 | 0.000 | 1.000 m2 | PO.02.30215 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000142580 | Hranaté potrubí | 10104160160392xxxxxx0 | NEMSOK - K_POSITION: L.10; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.16 m; Výška: 0.16 m
101042x160627xxxxxx0 | Půdorys 1.PP | m2 | 0.627 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/200.0000/160.0000/1/626.6000/0/0/0/0/0/1.0000/200.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/160.00/626.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 627 | 200x160 | 200 | 160 | 0.000 | 1.000 m2 | PO.02.30216 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000143963 | Hranaté potrubí | 101042x160627xxxxxx0 | NEMSOK - K_POSITION: L.14; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.2 m; Výška: 0.16 m
10104315160748xxxxxx0 | Půdorys 1.PP | m2 | 0.748 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/747.5000/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/747.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 748 | 315x160 | 315 | 160 | 0.000 | 1.000 m2 | PO.02.30217 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000143978 | Hranaté potrubí | 10104315160748xxxxxx0 | NEMSOK - K_POSITION: L.15; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.315 m; Výška: 0.16 m; Plocha: 1
1010456016011xxxxxxx | Půdorys 1.PP | m2 | 0.11 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/160.0000/1/110.2000/0/0/0/0/0/1.0000/560.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/160.00/110.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 110 | 560x160 | 560 | 160 | 0.000 | 1.000 m2 | PO.02.30218 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000144008 | Hranaté potrubí | 1010456016011xxxxxxx | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.56 m; Výška: 0.16 m; Plocha: 1
10104560160712xxxxxx0 | Půdorys 1.PP | m2 | 0.712 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/160.0000/1/712.3000/0/0/0/0/0/1.0000/560.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/160.00/712.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/50.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 712 | 560x160 | 560 | 160 | 0.000 | 1.030 m2 | PO.02.30219 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000144075 | Hranaté potrubí | 10104560160712xxxxxx0 | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.56 m; Výška: 0.16 m; Plocha: 1.03
101043151601xxxxxxxx | Půdorys 1.PP | m2 | 1 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/1000.0000/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/1000.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1000 | 315x160 | 315 | 160 | 0.000 | 0.950 m2 | PO.02.30220 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000144123 | Hranaté potrubí | 101043151601xxxxxxxx | 1.000 m2 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.315 m; Výška: 0.16 m; K_EBT_BOX_WC: 1500.000|177.500|100.000|0.000|-177.500|-100.000|0.000|0.000|0.000|1.000; Plocha: 0.95
101064x3x37xxxxxx0 | Půdorys 1.PP | m2 | 0.037 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/400.0000/300.0000/1/37.3000/0/0/0/0/0/1.0000/400.0000/300.0000/1/ | 10/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/300.00/37.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/0.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 37 | 400x300 | 400 | 300 | 0.000 | 1.000 m2 | PO.02.30221 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000144252 | Hranaté potrubí | 101064x3x37xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 300; Šířka: 0.4 m; Výška: 0.3 m; K_EBT_BOX_WC: 1287.300|220.000|170.000|0.000|-220.000|-170.000|0.000|0.000|0.000|1.000; Plocha: 1
10104315160451xxxxxx0 | Půdorys 1.PP | m2 | 0.451 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/450.9475/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/450.95/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 451 | 315x160 | 315 | 160 | 0.000 | 1.000 m2 | PO.02.30222 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000144264 | Hranaté potrubí | 10104315160451xxxxxx0 | 1.000 m2 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.315 m; Výška: 0.16 m
10104315160831xxxxxx0 | Půdorys 1.PP | m2 | 0.831 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/830.5468/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/830.55/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 831 | 315x160 | 315 | 160 | 0.000 | 1.000 m2 | PO.02.30223 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000144279 | Hranaté potrubí | 10104315160831xxxxxx0 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.315 m; Výška: 0.16 m; Plocha: 1
101043151606xxxxxxx | Půdorys 1.PP | m2 | 0.06 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/60.3498/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/60.35/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 60 | 315x160 | 315 | 160 | 0.000 | 1.000 m2 | PO.02.30224 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000144309 | Hranaté potrubí | 101043151606xxxxxxx | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.315 m; Výška: 0.16 m; Plocha: 1
 | Půdorys 1.PP | m2 | 1.088 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/1088.1603/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/1088.16/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1088 | 315x160 | 315 | 160 | 0.000 | 1.030 m2 | PO.02.30225 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000144324 | Hranaté potrubí | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.315 m; Výška: 0.16 m; Plocha: 1.03
1010431516019xxxxxxx | Půdorys 1.PP | m2 | 0.19 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/190.3211/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/190.32/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 190 | 315x160 | 315 | 160 | 0.000 | 1.000 m2 | PO.02.30226 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000144354 | Hranaté potrubí | 1010431516019xxxxxxx | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.315 m; Výška: 0.16 m; Plocha: 1
10104315160301xxxxxx0 | Půdorys 1.PP | m2 | 0.301 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/301.3852/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/301.39/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 301 | 315x160 | 315 | 160 | 0.000 | 1.000 m2 | PO.02.30227 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000144369 | Hranaté potrubí | 10104315160301xxxxxx0 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.315 m; Výška: 0.16 m; Plocha: 1
10104315160337xxxxxx0 | Půdorys 1.PP | m2 | 0.337 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/336.6236/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/336.62/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 337 | 315x160 | 315 | 160 | 0.000 | 1.000 m2 | PO.02.30228 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000144399 | Hranaté potrubí | 10104315160337xxxxxx0 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.315 m; Výška: 0.16 m; Plocha: 1
10104315160302xxxxxx0 | Půdorys 1.PP | m2 | 0.302 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/301.6000/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/301.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 302 | 315x160 | 315 | 160 | 0.000 | 1.000 m2 | PO.02.30229 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000144474 | Hranaté potrubí | 10104315160302xxxxxx0 | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.315 m; Výška: 0.16 m; Plocha: 1
101065x1608xxxxxxx0 | Půdorys 1.PP | m2 | 0.8 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/500.0000/160.0000/1/800.0000/0/0/0/0/0/1.0000/500.0000/160.0000/1/ | 10/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/160.00/800.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// |  | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 800 | 500x160 | 500 | 160 | 0.000 | 1.060 m2 | PO.02.30230 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000161618 | Hranaté potrubí | 101065x1608xxxxxxx0 | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.5 m; Výška: 0.16 m; Plocha: 1.06
10105560160408xxxxxx0 | Půdorys 1.PP | m2 | 0.408 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/160.0000/1/407.9000/0/0/0/0/0/1.0000/560.0000/160.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/160.00/407.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Blech ummantelt/0.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 408 | 560x160 | 560 | 160 | 0.000 | 1.000 m2 | PO.02.30231 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000161711 | Hranaté potrubí | 10105560160408xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.56 m; Výška: 0.16 m; K_EBT_BOX_WC: 717.900|300.000|100.000|0.000|-300.000|-100.000|0.000|0.000|0.000|1.000; Plocha: 1
10104315160376xxxxxx0 | Půdorys 1.PP | m2 | 0.376 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/375.6000/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/375.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// |  | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 376 | 315x160 | 315 | 160 | 0.000 | 1.000 m2 | PO.02.30232 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000161800 | Hranaté potrubí | 10104315160376xxxxxx0 | NEMSOK - K_POSITION: L.6; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.315 m; Výška: 0.16 m; Plocha: 1
10104160160524xxxxxx0 | Půdorys 1.PP | m2 | 0.524 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/524.0000/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/524.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// |  | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 524 | 160x160 | 160 | 160 | 0.000 | 1.000 m2 | PO.02.30233 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000161830 | Hranaté potrubí | 10104160160524xxxxxx0 | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.16 m; Výška: 0.16 m; Plocha: 1
1010431516064xxxxxxx | Půdorys 1.PP | m2 | 0.64 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/640.0000/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/640.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// |  | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 640 | 315x160 | 315 | 160 | 0.000 | 1.000 m2 | PO.02.30234 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000161845 | Hranaté potrubí | 1010431516064xxxxxxx | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.315 m; Výška: 0.16 m; Plocha: 1
 | Půdorys 1.PP | m2 | 1.015 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/1014.5000/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/1014.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// |  | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1015 | 315x160 | 315 | 160 | 0.000 | 0.960 m2 | PO.02.30235 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000161860 | Hranaté potrubí | NEMSOK - K_POSITION: L.5; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.315 m; Výška: 0.16 m; Plocha: 0.96
101045x160435xxxxxx0 | Půdorys 1.PP | m2 | 0.435 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/500.0000/160.0000/1/435.0000/0/0/0/0/0/1.0000/500.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/500.00/160.00/435.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// |  | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 435 | 500x160 | 500 | 160 | 0.000 | 1.000 m2 | PO.02.30236 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000161875 | Hranaté potrubí | 101045x160435xxxxxx0 | NEMSOK - K_POSITION: L.6; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.5 m; Výška: 0.16 m; Plocha: 1
15205125125456xxxxxx0 | Půdorys 1.PP | m | 0.456 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/455.6968/125.0000/125.0000/2/455.6968/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/455.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 456 | DN125 | 125 | 125 | 120.000 | 0.456 m | PO.02.30237 | Podzemní podlaží 1.PP | DN125 | voda | 6772Obj0000000619 | Kruhové potrubí | 15205125125456xxxxxx0 | 0.293 m2
15204125125267xxxxxx0 | Půdorys 1.PP | m | 0.267 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/267.4175/125.0000/125.0000/2/267.4175/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/267.42/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 267 | DN125 | 125 | 125 | 120.000 | 0.267 m | PO.02.30238 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000000633 | Kruhové potrubí | 15204125125267xxxxxx0 | 0.172 m2
1520416016074xxxxxx0 | Půdorys 1.PP | m | 0.074 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/74.1000/160.0000/160.0000/2/74.1000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/74.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 74 | DN160 | 160 | 160 | 120.000 | 0.074 m | PO.02.30239 | Podzemní podlaží 1.PP | DN160 | vzduch | 6772Obj0000000637 | Kruhové potrubí | 1520416016074xxxxxx0 | 0.056 m2
152041251256xxxxxxx | Půdorys 1.PP | m | 0.06 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/60.1801/125.0000/125.0000/2/60.1801/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/60.18/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 60 | DN125 | 125 | 125 | 120.000 | 0.060 m | PO.02.30240 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000000645 | Kruhové potrubí | 152041251256xxxxxxx | 0.039 m2
15204125125348xxxxxx0 | Půdorys 1.PP | m | 0.348 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/347.9569/125.0000/125.0000/2/347.9569/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/347.96/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 348 | DN125 | 125 | 125 | 120.000 | 0.348 m | PO.02.30241 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000000653 | Kruhové potrubí | 15204125125348xxxxxx0 | 0.224 m2
152041251253xxxxxxx | Půdorys 1.PP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.02.30242 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000000789 | Kruhové potrubí | 152041251253xxxxxxx | 0.019 m2
152041251253xxxxxxx | Půdorys 1.PP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.02.30243 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000000791 | Kruhové potrubí | 152041251253xxxxxxx | 0.019 m2
152041251253xxxxxxx | Půdorys 1.PP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.02.30244 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000000795 | Kruhové potrubí | 152041251253xxxxxxx | 0.019 m2
152041251253xxxxxxx | Půdorys 1.PP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.02.30245 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000000798 | Kruhové potrubí | 152041251253xxxxxxx | 0.019 m2
152041251253xxxxxxx | Půdorys 1.PP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.02.30246 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000000799 | Kruhové potrubí | 152041251253xxxxxxx | 0.019 m2
152041251253xxxxxxx | Půdorys 1.PP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.02.30247 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000000801 | Kruhové potrubí | 152041251253xxxxxxx | 0.019 m2
152041251253xxxxxxx | Půdorys 1.PP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.02.30248 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000000803 | Kruhové potrubí | 152041251253xxxxxxx | 0.019 m2
152041251253xxxxxxx | Půdorys 1.PP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.02.30249 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000000805 | Kruhové potrubí | 152041251253xxxxxxx | 0.019 m2
152041251253xxxxxxx | Půdorys 1.PP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.02.30250 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000000806 | Kruhové potrubí | 152041251253xxxxxxx | 0.019 m2
152041251253xxxxxxx | Půdorys 1.PP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.02.30251 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000000807 | Kruhové potrubí | 152041251253xxxxxxx | 0.019 m2
152041251253xxxxxxx | Půdorys 1.PP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.02.30252 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000000809 | Kruhové potrubí | 152041251253xxxxxxx | 0.019 m2
152041251253xxxxxxx | Půdorys 1.PP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.02.30253 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000000811 | Kruhové potrubí | 152041251253xxxxxxx | 0.019 m2
152041251253xxxxxxx | Půdorys 1.PP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.02.30254 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000000813 | Kruhové potrubí | 152041251253xxxxxxx | 0.019 m2
152041251253xxxxxxx | Půdorys 1.PP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.02.30255 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000000815 | Kruhové potrubí | 152041251253xxxxxxx | 0.019 m2
152041251253xxxxxxx | Půdorys 1.PP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.02.30256 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000000821 | Kruhové potrubí | 152041251253xxxxxxx | 0.019 m2
 | Půdorys 1.PP | m | 2.836 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/2526.0000/125.0000/125.0000/2/2526.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/2526.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 2526 | DN125 | 125 | 125 | 0.000 | 2.526 m | PO.02.30257 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000000867 | Kruhové potrubí |  | 1.627 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 2835.985|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
152041251253xxxxxxx | Půdorys 1.PP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.02.30258 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000000870 | Kruhové potrubí | 152041251253xxxxxxx | 0.019 m2
152041251253xxxxxxx | Půdorys 1.PP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.02.30259 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000000907 | Kruhové potrubí | 152041251253xxxxxxx | 0.019 m2
152041251253xxxxxxx | Půdorys 1.PP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.02.30260 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000000929 | Kruhové potrubí | 152041251253xxxxxxx | 0.019 m2
152041251253xxxxxxx | Půdorys 1.PP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.02.30261 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000000948 | Kruhové potrubí | 152041251253xxxxxxx | 0.019 m2
152041251253xxxxxxx | Půdorys 1.PP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.02.30262 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000000950 | Kruhové potrubí | 152041251253xxxxxxx | 0.019 m2
152041251253xxxxxxx | Půdorys 1.PP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.02.30263 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000000952 | Kruhové potrubí | 152041251253xxxxxxx | 0.019 m2
152041251253xxxxxxx | Půdorys 1.PP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.02.30264 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000000954 | Kruhové potrubí | 152041251253xxxxxxx | 0.019 m2
15205125125106xxxxxxx | Půdorys 1.PP | m | 1.06 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1059.7113/125.0000/125.0000/2/1059.7113/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/1059.71/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1060 | DN125 | 125 | 125 | 120.000 | 1.060 m | PO.02.30265 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000001008 | Kruhové potrubí | 15205125125106xxxxxxx | 0.682 m2
15205160160193xxxxxx0 | Půdorys 1.PP | m | 0.193 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/192.8895/160.0000/160.0000/2/192.8895/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/192.89/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 193 | DN160 | 160 | 160 | 120.000 | 0.193 m | PO.02.30267 | Podzemní podlaží 1.PP | DN160 | vzduch | 6772Obj0000001072 | Kruhové potrubí | 15205160160193xxxxxx0 | 0.145 m2
1520512512514xxxxxx0 | Půdorys 1.PP | m | 0.014 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/14.4874/125.0000/125.0000/2/14.4874/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/14.49/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 14 | DN125 | 125 | 125 | 0.000 | 0.015 m | PO.02.30269 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000001092 | Kruhové potrubí | 1520512512514xxxxxx0 | 0.009 m2
15205125125222xxxxxx0 | Půdorys 1.PP | m | 0.222 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/221.7157/125.0000/125.0000/2/221.7157/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/221.72/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 222 | DN125 | 125 | 125 | 0.000 | 0.222 m | PO.02.30270 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000001096 | Kruhové potrubí | 15205125125222xxxxxx0 | 0.143 m2
1520512512514xxxxxx0 | Půdorys 1.PP | m | 0.014 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/14.1593/125.0000/125.0000/2/14.1593/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/14.16/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 14 | DN125 | 125 | 125 | 0.000 | 0.014 m | PO.02.30271 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000001100 | Kruhové potrubí | 1520512512514xxxxxx0 | 0.009 m2
 | Půdorys 1.PP | m | 1.463 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1463.0342/125.0000/125.0000/2/1463.0342/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/1463.03/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1463 | DN125 | 125 | 125 | 0.000 | 1.463 m | PO.02.30272 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000001104 | Kruhové potrubí |  | 0.942 m2
152041x1x6xxxxxxx | Půdorys 1.PP | m | 0.06 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/59.5884/100.0000/100.0000/2/59.5884/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/59.59/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 60 | DN100 | 100 | 100 | 120.000 | 0.060 m | PO.02.30273 | Podzemní podlaží 1.PP | DN100 | vzduch | 6772Obj0000001158 | Kruhové potrubí | 152041x1x6xxxxxxx | 0.034 m2
152041x1x2xxxxxxx | Půdorys 1.PP | m | 0.02 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/20.1703/100.0000/100.0000/2/20.1703/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/20.17/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 20 | DN100 | 100 | 100 | 120.000 | 0.020 m | PO.02.30274 | Podzemní podlaží 1.PP | DN100 | vzduch | 6772Obj0000001162 | Kruhové potrubí | 152041x1x2xxxxxxx | 0.011 m2
152041x1x91xxxxxx0 | Půdorys 1.PP | m | 0.091 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/91.1020/100.0000/100.0000/2/91.1020/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/91.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 91 | DN100 | 100 | 100 | 120.000 | 0.091 m | PO.02.30275 | Podzemní podlaží 1.PP | DN100 | vzduch | 6772Obj0000001166 | Kruhové potrubí | 152041x1x91xxxxxx0 | 0.052 m2
1520616016012xxxxxx0 | Půdorys 1.PP | m | 0.012 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/12.0000/160.0000/160.0000/2/12.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/12.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 12 | DN160 | 160 | 160 | 120.000 | 0.012 m | PO.02.30276 | Podzemní podlaží 1.PP | DN160 | vzduch | 6772Obj0000001171 | Kruhové potrubí | 1520616016012xxxxxx0 | 0.009 m2
15206125125145xxxxxx0 | Půdorys 1.PP | m | 0.145 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/144.5306/125.0000/125.0000/2/144.5306/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/144.53/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 145 | DN125 | 125 | 125 | 120.000 | 0.144 m | PO.02.30277 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000001175 | Kruhové potrubí | 15206125125145xxxxxx0 | 0.093 m2
15206125125693xxxxxx0 | Půdorys 1.PP | m | 0.693 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/693.3145/125.0000/125.0000/2/693.3145/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/693.31/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 693 | DN125 | 125 | 125 | 120.000 | 0.693 m | PO.02.30278 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000001179 | Kruhové potrubí | 15206125125693xxxxxx0 | 0.447 m2
15206125125127xxxxxx0 | Půdorys 1.PP | m | 0.127 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/127.0062/125.0000/125.0000/2/127.0062/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/127.01/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 127 | DN125 | 125 | 125 | 120.000 | 0.127 m | PO.02.30279 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000001183 | Kruhové potrubí | 15206125125127xxxxxx0 | 0.082 m2
15206160160412xxxxxx0 | Půdorys 1.PP | m | 0.412 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/411.9229/160.0000/160.0000/2/411.9229/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/411.92/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 412 | DN160 | 160 | 160 | 0.000 | 0.412 m | PO.02.30280 | Podzemní podlaží 1.PP | DN160 | vzduch | 6772Obj0000001185 | Kruhové potrubí | 15206160160412xxxxxx0 | 0.311 m2
15206160160242xxxxxx0 | Půdorys 1.PP | m | 0.242 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/241.9755/160.0000/160.0000/2/241.9755/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/241.98/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 242 | DN160 | 160 | 160 | 0.000 | 0.242 m | PO.02.30281 | Podzemní podlaží 1.PP | DN160 | vzduch | 6772Obj0000001191 | Kruhové potrubí | 15206160160242xxxxxx0 | 0.182 m2
152041251253xxxxxxx | Půdorys 1.PP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.02.30282 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000001213 | Kruhové potrubí | 152041251253xxxxxxx | 0.019 m2
15205125125386xxxxxx0 | Půdorys 1.PP | m | 0.386 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/386.3159/125.0000/125.0000/2/386.3159/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/386.32/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 386 | DN125 | 125 | 125 | 0.000 | 0.386 m | PO.02.30283 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000001215 | Kruhové potrubí | 15205125125386xxxxxx0 | 0.249 m2
15205125125386xxxxxx0 | Půdorys 1.PP | m | 0.386 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/76.3000/125.0000/125.0000/2/76.3000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/76.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 76 | DN125 | 125 | 125 | 0.000 | 0.076 m | PO.02.30284 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000001217 | Kruhové potrubí | 15205125125386xxxxxx0 | 0.049 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 386.316|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
15205125125956xxxxxx0 | Půdorys 1.PP | m | 0.956 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/645.9000/125.0000/125.0000/2/645.9000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/645.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 646 | DN125 | 125 | 125 | 0.000 | 0.646 m | PO.02.30285 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000001220 | Kruhové potrubí | 15205125125956xxxxxx0 | 0.416 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 955.860|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
15206160160412xxxxxx0 | Půdorys 1.PP | m | 0.412 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/101.9000/160.0000/160.0000/2/101.9000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/101.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 102 | DN160 | 160 | 160 | 0.000 | 0.102 m | PO.02.30286 | Podzemní podlaží 1.PP | DN160 | vzduch | 6772Obj0000001223 | Kruhové potrubí | 15206160160412xxxxxx0 | 0.077 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 411.923|80.000|80.000|0.000|-80.000|-80.000|0.000|0.000|0.000|1.000
15204125125111xxxxxx0 | Půdorys 1.PP | m | 0.111 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/110.6849/125.0000/125.0000/2/110.6849/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/110.68/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 111 | DN125 | 125 | 125 | 120.000 | 0.111 m | PO.02.30287 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000001249 | Kruhové potrubí | 15204125125111xxxxxx0 | 0.071 m2
15205160160215xxxxxx0 | Půdorys 1.PP | m | 0.215 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/215.0000/160.0000/160.0000/2/215.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/215.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 215 | DN160 | 160 | 160 | 120.000 | 0.215 m | PO.02.30288 | Podzemní podlaží 1.PP | DN160 | vzduch | 6772Obj0000001251 | Kruhové potrubí | 15205160160215xxxxxx0 | 0.162 m2
15205160160738xxxxxx0 | Půdorys 1.PP | m | 0.738 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/738.4000/160.0000/160.0000/2/738.4000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/738.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 738 | DN160 | 160 | 160 | 120.000 | 0.738 m | PO.02.30289 | Podzemní podlaží 1.PP | DN160 | vzduch | 6772Obj0000001253 | Kruhové potrubí | 15205160160738xxxxxx0 | 0.557 m2
152041251253xxxxxxx | Půdorys 1.PP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.02.30290 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000001401 | Kruhové potrubí | 152041251253xxxxxxx | 0.019 m2
 | Půdorys 1.PP | m | 1.103 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1102.5000/125.0000/125.0000/2/1102.5000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/1102.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1103 | DN125 | 125 | 125 | 0.000 | 1.103 m | PO.02.30291 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000001407 | Kruhové potrubí |  | 0.710 m2
15205125125422xxxxxx0 | Půdorys 1.PP | m | 0.422 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/112.5000/125.0000/125.0000/2/112.5000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/112.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 113 | DN125 | 125 | 125 | 0.000 | 0.113 m | PO.02.30292 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000001417 | Kruhové potrubí | 15205125125422xxxxxx0 | 0.072 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 422.488|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
152041251253xxxxxxx | Půdorys 1.PP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.02.30293 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000001467 | Kruhové potrubí | 152041251253xxxxxxx | 0.019 m2
152041251253xxxxxxx | Půdorys 1.PP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.02.30294 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000001494 | Kruhové potrubí | 152041251253xxxxxxx | 0.019 m2
 | Půdorys 1.PP | m | 1.463 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1153.0000/125.0000/125.0000/2/1153.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/1153.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1153 | DN125 | 125 | 125 | 0.000 | 1.153 m | PO.02.30295 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000001503 | Kruhové potrubí |  | 0.743 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 1463.034|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
1520412512513xxxxxxx0 | Půdorys 1.PP | m | 1.3 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1300.0000/125.0000/125.0000/2/1300.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/1300.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1300 | DN125 | 125 | 125 | 0.000 | 1.300 m | PO.02.30296 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000001521 | Kruhové potrubí | 1520412512513xxxxxxx0 | 0.837 m2
15204160160189xxxxxx0 | Půdorys 1.PP | m | 0.189 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/188.5000/160.0000/160.0000/2/188.5000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/188.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 189 | DN160 | 160 | 160 | 120.000 | 0.189 m | PO.02.30297 | Podzemní podlaží 1.PP | DN160 | vzduch | 6772Obj0000001553 | Kruhové potrubí | 15204160160189xxxxxx0 | 0.142 m2
1520516016062xxxxxxx | Půdorys 1.PP | m | 0.62 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/620.0000/160.0000/160.0000/2/620.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/620.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 620 | DN160 | 160 | 160 | 120.000 | 0.620 m | PO.02.30298 | Podzemní podlaží 1.PP | DN160 | vzduch | 6772Obj0000001559 | Kruhové potrubí | 1520516016062xxxxxxx | 0.467 m2
152041251253xxxxxxx | Půdorys 1.PP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.02.30299 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000001635 | Kruhové potrubí | 152041251253xxxxxxx | 0.019 m2
15205125125211xxxxxx0 | Půdorys 1.PP | m | 0.211 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/210.8103/125.0000/125.0000/2/210.8103/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/210.81/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 211 | DN125 | 125 | 125 | 120.000 | 0.211 m | PO.02.30300 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000001955 | Kruhové potrubí | 15205125125211xxxxxx0 | 0.136 m2
1520512512518xxxxxx0 | Půdorys 1.PP | m | 0.018 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/17.5000/125.0000/125.0000/2/17.5000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/17.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | 18 | DN125 | 125 | 125 | 0.000 | 0.018 m | PO.02.30301 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000001985 | Kruhové potrubí | 1520512512518xxxxxx0 | 0.011 m2
152051x1x414xxxxxx0 | Půdorys 1.PP | m | 0.414 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/414.2496/100.0000/100.0000/2/414.2496/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/414.25/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 414 | DN100 | 100 | 100 | 0.000 | 0.414 m | PO.02.30302 | Podzemní podlaží 1.PP | DN100 | vzduch | 6772Obj0000002001 | Kruhové potrubí | 152051x1x414xxxxxx0 | 0.234 m2
152051x1x1281xxxxxx0 | Půdorys 1.PP | m | 1.281 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1280.5016/100.0000/100.0000/2/1280.5016/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/1280.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1281 | DN100 | 100 | 100 | 0.000 | 1.280 m | PO.02.30303 | Podzemní podlaží 1.PP | DN100 | vzduch | 6772Obj0000002011 | Kruhové potrubí | 152051x1x1281xxxxxx0 | 0.724 m2
1520512512515xxxxxx0 | Půdorys 1.PP | m | 0.015 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/15.0000/125.0000/125.0000/2/15.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/15.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 15 | DN125 | 125 | 125 | 0.000 | 0.015 m | PO.02.30304 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000002026 | Kruhové potrubí | 1520512512515xxxxxx0 | 0.010 m2
 | Půdorys 1.PP | m | 1.145 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1144.9923/125.0000/125.0000/2/1144.9923/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/1144.99/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1145 | DN125 | 125 | 125 | 0.000 | 1.145 m | PO.02.30305 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000002051 | Kruhové potrubí |  | 0.737 m2
 | Půdorys 1.PP | m | 1.145 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1145.0192/125.0000/125.0000/2/1145.0192/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/1145.02/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Blech ummantelt/30.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1145 | DN125 | 125 | 125 | 0.000 | 1.145 m | PO.02.30306 | Podzemní podlaží 1.PP | DN125 | vzduch | 6772Obj0000002071 | Kruhové potrubí |  | 0.737 m2
