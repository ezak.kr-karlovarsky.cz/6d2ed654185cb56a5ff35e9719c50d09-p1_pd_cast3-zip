Properties of the parts of a building model (IFC2X3), part 24 of 51

# IfcFlowFitting (2887)
Name | In | Jednotka | Délka (m) | Označení | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_DIM | L_BES_DIM_A2 | L_BES_DIM_B2 | L_BES_DIM_A | K_VOLSTROM | K_MLH_GOST = K_MLD_GOST | K_LISTVALUE | Kód prvku | Třída reakce na oheň | Allright_Stavebni_dil_ID | Název_objektu | K_EBT_BOX_WC | Plocha | L_BES_LAENGE | K_INTERNAL_ISO | Tloušťka (m) | Součinitel tepelné vodivost
252x1250125145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30063 | A1 | 6782Obj0798479448 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x125012513xxxxxx | Půdorys 1.NP | Stk | 0 | 252x125012513xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30088 | A1 | 6782Obj0798479563 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x125012513xxxxxx | Půdorys 1.NP | Stk | 0 | 252x125012513xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30089 | A1 | 6782Obj0798479565 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x125012519xxxxxx | Půdorys 1.NP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/315.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/315.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/315.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30130 | A1 | 6782Obj0798479719 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x1250125145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30131 | A1 | 6782Obj0798479723 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x125012519xxxxxx | Půdorys 1.NP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/315.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/315.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/315.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30147 | A1 | 6782Obj0798479807 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x1250125145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30148 | A1 | 6782Obj0798479809 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x1250125145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/202.7/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/202.7/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/202.70/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30155 | A1 | 6782Obj0798479916 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x1250125145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/16.5/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/16.5/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/16.50/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30156 | A1 | 6782Obj0798479926 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x1250125145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30192 | A1 | 6782Obj0798486589 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x1250125145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30193 | A1 | 6782Obj0798486599 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x125012513xxxxxx | Půdorys 1.NP | Stk | 0 | 252x125012513xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/62.5000/16.7468/0/30.0/0/0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/0/0/125.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30196 | A1 | 6782Obj0798486751 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x1250125145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/270.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/270.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30200 | A1 | 6782Obj0798487014 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x1250125145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30201 | A1 | 6782Obj0798487024 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x125012519xxxxxx | Půdorys 1.NP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/224.9/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/224.9/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/224.90/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30232 | A1 | 6782Obj0798487956 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x1250125145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1250125145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/125.0000/125.0000/125.0000/2/88.3883/36.6117/0/45.0/0/90.0/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/90.00/0/125.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30233 | A1 | 6782Obj0798487966 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x125012519xxxxxx | Půdorys 1.NP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/160.5/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/160.5/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/160.50/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30259 | A1 | 6782Obj0798489806 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
30204125125x125125092-x-x3xx | Půdorys 1.NP | Stk | 0.092 | 30204125125x125125092-x-x3xx | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/1.0000/125.0000/125.0000/2/92.0000/0.0225/-0.3091/0/0/0/125.0000/125.0000/125.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/0/0/125.00/125.00/0/92.00/-0.02/0.02/-0.31/0.31/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30260 | A1 | 6782Obj0798489811 | Objekt |  |  | 92 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x125012519xxxxxx | Půdorys 1.NP | Stk | 0 | 252x125012519xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/125.0000/125.0000/125.0000/2/125.0000/125.0000/0/90.0/0/180.0/125.0000/125.0000/125.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/180.00/0/125.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30261 | A1 | 6782Obj0798489821 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x1250125162xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1250125162xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/205.8/125.0000/125.0000/125.0000/2/110.0597/65.7390/0/61.7/0/205.8/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/205.80/0/125.00/1.00/61.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30273 | A1 | 6782Obj0798490744 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
252x1250125138xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x1250125138xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/147.3/125.0000/125.0000/125.0000/2/76.0952/25.8308/0/37.5/0/147.3/125.0000/125.0000/125.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/147.30/0/125.00/1.00/37.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 125 | 125 | 125 | 0.000 | 0 | 1.0 | TA.03.30274 | A1 | 6782Obj0798490754 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 125 mm
302041252xx1252x0133383838383xx | Půdorys 1.NP | Stk | 0.133 | 302041252xx1252x0133383838383xx | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/133.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/200.00/0/0/125.00/200.00/0/133.00/37.50/37.50/37.50/37.50/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 200 | 200 | 125 | 0.000 | 0 | 1.0 | TA.03.30149 | A1 | 6782Obj0798479814 | Objekt |  |  | 133 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
302041252xx1252x0133383838383xx | Půdorys 1.NP | Stk | 0.133 | 302041252xx1252x0133383838383xx | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/125.0000/125.0000/125.0000/2/133.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/200.00/0/0/125.00/200.00/0/133.00/37.50/37.50/37.50/37.50/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN125 | 200 | 200 | 125 | 0.000 | 0 | 1.0 | TA.03.30154 | A1 | 6782Obj0798479849 | Objekt |  |  | 133 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
302051601xx1601x0112-30-30-30-30 | Půdorys 1.NP | Stk | 0.112 | 302051601xx1601x0112-30-30-30-30 | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/112.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 30/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/100.00/0/0/160.00/100.00/0/112.00/-30.00/-30.00/-30.00/-30.00/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 100 | 100 | 160 | 0.000 | 0 | 1.0 | TA.03.30080 | A1 | 6782Obj0798479531 | Objekt |  |  | 112 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 100 mm
302051601xx1601x0112-30-30-30-30 | Půdorys 1.NP | Stk | 0.112 | 302051601xx1601x0112-30-30-30-30 | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/112.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 30/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/100.00/0/0/160.00/100.00/0/112.00/-30.00/-30.00/-30.00/-30.00/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 100 | 100 | 160 | 0.000 | 0 | 1.0 | TA.03.30083 | A1 | 6782Obj0798479536 | Objekt |  |  | 112 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 100 mm
302051601xx1601x0112-30-30-30-30 | Půdorys 1.NP | Stk | 0.112 | 302051601xx1601x0112-30-30-30-30 | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/112.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 30/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/100.00/0/0/160.00/100.00/0/112.00/-30.00/-30.00/-30.00/-30.00/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 100 | 100 | 160 | 0.000 | 0 | 1.0 | TA.03.30209 | A1 | 6782Obj0798487226 | Objekt |  |  | 112 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 100 mm
252x16x16019xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16019xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/330.0/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/330.0/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/330.00/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30032 | A1 | 6782Obj0798479342 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
252x16x16013xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16013xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/80.0000/21.4359/0/30.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30033 | A1 | 6782Obj0798479343 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
7520516016016x26x13x9xxxx | Půdorys 1.NP | Stk | 0.26 | 7520516016016x26x13x9xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/260.0000/0/0/0/0/180.0/1.0000/160.0000/160.0000/2/130.0000/130.0000/0/90.0/0/180.0/160.0000/160.0000/160.0000/2/ | 75/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/160.00/0/180.00/260.00/0/130.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30079 | A1 | 6782Obj0798479530 | Objekt |  |  | 260 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
252x16x16019xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16019xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/270.0/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.00/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30081 | A1 | 6782Obj0798479534 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
7520516016016x26x13x9xxxx | Půdorys 1.NP | Stk | 0.26 | 7520516016016x26x13x9xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/260.0000/0/0/0/0/180.0/1.0000/160.0000/160.0000/2/130.0000/130.0000/0/90.0/0/180.0/160.0000/160.0000/160.0000/2/ | 75/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/160.00/0/180.00/260.00/0/130.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30082 | A1 | 6782Obj0798479535 | Objekt |  |  | 260 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
252x16x160145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/270.0/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30104 | A1 | 6782Obj0798479625 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
252x16x160145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30105 | A1 | 6782Obj0798479627 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
252x16x16019xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16019xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/225.0/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/225.0/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/225.00/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30112 | A1 | 6782Obj0798479652 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
252x16x160145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30113 | A1 | 6782Obj0798479654 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
252x16x160145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30118 | A1 | 6782Obj0798479676 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
252x16x160145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/270.0/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30119 | A1 | 6782Obj0798479678 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
752041601601x019x12509xxxx | Půdorys 1.NP | Stk | 0.19 | 752041601601x019x12509xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/190.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/95.0000/125.0000/0/90.0/0/0/100.0000/100.0000/100.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/100.00/0/0/190.00/0/125.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30140 | A1 | 6782Obj0798479782 | Objekt |  |  | 190 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
752041601601x019x12509xxxx | Půdorys 1.NP | Stk | 0.19 | 752041601601x019x12509xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/190.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/95.0000/125.0000/0/90.0/0/0/100.0000/100.0000/100.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/100.00/0/0/190.00/0/125.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30141 | A1 | 6782Obj0798479783 | Objekt |  |  | 190 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
252x16x16019xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16019xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/224.9/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/224.9/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/224.90/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30157 | A1 | 6782Obj0798480251 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
252x16x160145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30158 | A1 | 6782Obj0798480261 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
252x16x16019xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16019xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/224.9/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/224.9/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/224.90/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30164 | A1 | 6782Obj0798483887 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
252x16x160145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30165 | A1 | 6782Obj0798483897 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
252x16x16019xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16019xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/315.0/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/315.0/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/315.00/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30167 | A1 | 6782Obj0798484019 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
252x16x160145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/89.9/160.0000/160.0000/160.0000/2/112.5432/46.2721/0/44.7/0/89.9/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/89.90/0/160.00/1.00/44.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30168 | A1 | 6782Obj0798484029 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
252x16x16019xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16019xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/45.0/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/45.0/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/45.00/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30169 | A1 | 6782Obj0798484841 | Objekt | 240.000/160.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 | NEMSOK - K_POSITION: L.1; Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
252x16x160145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30170 | A1 | 6782Obj0798484851 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
7520416016016x26x13x9xxxx | Půdorys 1.NP | Stk | 0.26 | 7520416016016x26x13x9xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/260.0000/0/0/0/0/180.0/200.0000/160.0000/160.0000/2/130.0000/130.0000/0/90.0/0/180.0/160.0000/160.0000/160.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/160.00/0/180.00/260.00/0/130.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30174 | A1 | 6782Obj0798485368 | Objekt |  |  | 260 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
252x16x160145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30177 | A1 | 6782Obj0798485405 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
252x16x160145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/270.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30178 | A1 | 6782Obj0798485415 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
252x16x160145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30179 | A1 | 6782Obj0798485425 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
252x16x160145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/180.0/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/180.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30204 | A1 | 6782Obj0798487109 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
252x16x160145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/270.0/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30205 | A1 | 6782Obj0798487124 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
252x16x160145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30206 | A1 | 6782Obj0798487134 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
7520516016016x26x13x9xxxx | Půdorys 1.NP | Stk | 0.26 | 7520516016016x26x13x9xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/260.0000/0/0/0/0/270.0/1.0000/160.0000/160.0000/2/130.0000/130.0000/0/90.0/0/270.0/160.0000/160.0000/160.0000/2/ | 75/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/160.00/0/270.00/260.00/0/130.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30207 | A1 | 6782Obj0798487196 | Objekt | 260.000/130.000/80.000/0.000/-80.000/-80.000/0.000/0.000/0.000/1.000 |  | 260 | NEMSOK - K_POSITION: L.1; Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
252x16x16019xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16019xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/270.0/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.00/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30208 | A1 | 6782Obj0798487206 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
252x16x160145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/270.0/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30219 | A1 | 6782Obj0798487384 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
252x16x160145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30220 | A1 | 6782Obj0798487394 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
252x16x16019xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16019xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/0/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/0/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30221 | A1 | 6782Obj0798487437 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
252x16x160145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/270.0/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30222 | A1 | 6782Obj0798487450 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
252x16x160145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30223 | A1 | 6782Obj0798487460 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
252x16x160145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30229 | A1 | 6782Obj0798487869 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
252x16x160145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/270.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/270.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30230 | A1 | 6782Obj0798487879 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
252x16x16019xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16019xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/341.2/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/341.2/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/341.20/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30255 | A1 | 6782Obj0798489520 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
252x16x16019xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16019xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/0/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30256 | A1 | 6782Obj0798489530 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
252x16x160137xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x16x160137xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/289.8/160.0000/160.0000/160.0000/2/96.5133/32.3866/0/37.1/0/289.8/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/289.80/0/160.00/1.00/37.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30262 | A1 | 6782Obj0798489876 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
252x16x160178xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x16x160178xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/8.3/160.0000/160.0000/160.0000/2/156.6188/127.2806/0/78.2/0/8.3/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/8.30/0/160.00/1.00/78.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30263 | A1 | 6782Obj0798489886 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
252x16x16019xxxxxx | Půdorys 1.NP | Stk | 0 | 252x16x16019xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/315.0/160.0000/160.0000/160.0000/2/160.0000/160.0000/0/90.0/0/315.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/315.00/0/160.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30276 | A1 | 6782Obj0798490830 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
3020416016x016016x96xx3xx | Půdorys 1.NP | Stk | 0.096 | 3020416016x016016x96xx3xx | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/2/96.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/0/0/160.00/160.00/0/96.00/0/0/0/0/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30277 | A1 | 6782Obj0798490835 | Objekt |  |  | 96 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
252x16x160145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x16x160145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/160.0000/160.0000/160.0000/2/113.1371/46.8629/0/45.0/0/90.0/160.0000/160.0000/160.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/90.00/0/160.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 160 | 160 | 160 | 0.000 | 0 | 1.0 | TA.03.30278 | A1 | 6782Obj0798490845 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
3020416018x016018x57101010103xx | Půdorys 1.NP | Stk | 0.057 | 3020416018x016018x57101010103xx | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/57.0000/0/0/0/0/0/180.0000/180.0000/180.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/180.00/0/0/160.00/180.00/0/57.00/10.00/10.00/10.00/10.00/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 180 | 180 | 160 | 0.000 | 0 | 1.0 | TA.03.30072 | A1 | 6782Obj0798479521 | Objekt |  |  | 57 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 180 mm
302041602xx1602x085202020203xx | Půdorys 1.NP | Stk | 0.085 | 302041602xx1602x085202020203xx | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/160.0000/160.0000/160.0000/2/85.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/200.00/0/0/160.00/200.00/0/85.00/20.00/20.00/20.00/20.00/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN160 | 200 | 200 | 160 | 0.000 | 0 | 1.0 | TA.03.30175 | A1 | 6782Obj0798485378 | Objekt |  |  | 85 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
752041801801250215013509xxxx | Půdorys 1.NP | Stk | 0.215 | 752041801801250215013509xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/0/180.0000/180.0000/180.0000/2/215.0000/0/0/0/0/0/180.0000/180.0000/180.0000/2/107.5000/135.0000/0/90.0/0/0/125.0000/125.0000/125.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/180.00/180.00/125.00/0/0/215.00/0/135.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN180 | 180 | 180 | 180 | 0.000 | 0 | 1.0 | TA.03.30073 | A1 | 6782Obj0798479522 | Objekt |  |  | 215 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 180 mm
502161802x351x1802x1801521010101 | Půdorys 1.NP | m2 | 0.152 | 502161802x351x1802x1801521010101 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/180.0000/180.0000/180.0000/2/152.3000/0/0/0/0/0/0/200.0000/200.0000/1/ | 50/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/180.00/200.00/35.00/100.00/180.00/200.00/180.00/152.30/10.00/10.00/10.00/10.00/30.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN180 | 200 | 200 | 180 | 0.000 | 0 | 1.000 m2 | TA.03.30076 | A1 | 6782Obj0798479526 | Objekt |  |  | 152 | NEMSOK - K_POSITION: L.23; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
302052x16x02x16x85-20-20-20-203x | Půdorys 1.NP | Stk | 0.085 | 302052x16x02x16x85-20-20-20-203x | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/200.0000/200.0000/200.0000/2/85.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 30/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/160.00/0/0/200.00/160.00/0/85.00/-20.00/-20.00/-20.00/-20.00/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 160 | 160 | 200 | 0.000 | 0 | 1.0 | TA.03.30218 | A1 | 6782Obj0798487371 | Objekt |  |  | 85 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 160 mm
502162x2x351x2x2012x136x1129x0 | Půdorys 1.NP | m2 | 0.136 | 502162x2x351x2x2012x136x1129x0 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/200.0000/200.0000/200.0000/2/135.9000/0/0/0/0/0/0/200.0000/201.0000/1/ | 50/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/200.00/200.00/35.00/100.00/200.00/201.00/200.00/135.90/0/0/0.50/0.50/29.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 201 | 200 | 0.000 | 0 | 1.000 m2 | TA.03.30034 | A1 | 6782Obj0798479367 | Objekt |  |  | 136 | NEMSOK - K_POSITION: L.24; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
252x2x02x145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x2x02x145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/200.0000/200.0000/200.0000/2/141.4214/58.5786/0/45.0/0/90.0/200.0000/200.0000/200.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/90.00/0/200.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30040 | A1 | 6782Obj0798479378 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
302042x2xx2x2x0112x0-03xx | Půdorys 1.NP | Stk | 0.112 | 302042x2xx2x2x0112x0-03xx | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/2/112.0000/0/0.0468/0/0/0/200.0000/200.0000/200.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/0/0/200.00/200.00/0/112.00/0/0/0.05/-0.05/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30041 | A1 | 6782Obj0798479379 | Objekt |  |  | 112 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
252x2x02x145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x2x02x145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/200.0000/200.0000/200.0000/2/141.4214/58.5786/0/45.0/0/270.0/200.0000/200.0000/200.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/270.00/0/200.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30042 | A1 | 6782Obj0798479381 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
252x2x02x145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x2x02x145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/200.0000/200.0000/200.0000/2/141.4214/58.5786/0/45.0/0/90.0/200.0000/200.0000/200.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/90.00/0/200.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30043 | A1 | 6782Obj0798479384 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
302042x2xx2x2x0112x0-03xx | Půdorys 1.NP | Stk | 0.112 | 302042x2xx2x2x0112x0-03xx | UE RUND S | 20 | 30 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/2/112.0000/0/0.0468/0/0/0/200.0000/200.0000/200.0000/2/ | 30/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/0/0/200.00/200.00/0/112.00/0/0/0.05/-0.05/30.00/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30044 | A1 | 6782Obj0798479385 | Objekt |  |  | 112 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
252x2x02x145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x2x02x145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/200.0000/200.0000/200.0000/2/141.4214/58.5786/0/45.0/0/270.0/200.0000/200.0000/200.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/270.00/0/200.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30045 | A1 | 6782Obj0798479387 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
252x2x02x19xxxxxx | Půdorys 1.NP | Stk | 0 | 252x2x02x19xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/225.0/200.0000/200.0000/200.0000/2/200.0000/200.0000/0/90.0/0/225.0/200.0000/200.0000/200.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/225.00/0/200.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30046 | A1 | 6782Obj0798479389 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
252x2x02x145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x2x02x145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/200.0000/200.0000/200.0000/2/141.4214/58.5786/0/45.0/0/90.0/200.0000/200.0000/200.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/90.00/0/200.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30047 | A1 | 6782Obj0798479391 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
252x2x02x145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x2x02x145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/270.0/200.0000/200.0000/200.0000/2/141.4214/58.5786/0/45.0/0/270.0/200.0000/200.0000/200.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/270.00/0/200.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30100 | A1 | 6782Obj0798479615 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
252x2x02x145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x2x02x145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/90.0/200.0000/200.0000/200.0000/2/141.4214/58.5786/0/45.0/0/90.0/200.0000/200.0000/200.0000/2/ | 25/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/90.00/0/200.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30101 | A1 | 6782Obj0798479617 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
252x2x02x19xxxxxx | Půdorys 1.NP | Stk | 0 | 252x2x02x19xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/200.0000/200.0000/200.0000/2/200.0000/200.0000/0/90.0/0/180.0/200.0000/200.0000/200.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/180.00/0/200.00/1.00/90.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30138 | A1 | 6782Obj0798479780 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
502162x2x351x2x2012x136x1129x0 | Půdorys 1.NP | m2 | 0.136 | 502162x2x351x2x2012x136x1129x0 | UEBERGANG ECK/RU Z | 20 | 50 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/2/135.9000/0/0/0/0/0/0/200.0000/201.0000/1/ | 50/1/2/0/0/0/0/1000/0/-1/1/0/0/0/0/0/0/0/0/0/200.00/200.00/35.00/100.00/200.00/201.00/200.00/135.90/0/0/0.50/0.50/29.00/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20//// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 201 | 200 | 0.000 | 0 | 1.000 m2 | TA.03.30150 | A1 | 6782Obj0798479830 | Objekt |  |  | 136 | NEMSOK - K_POSITION: L.33; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); K_LISTVALUE_ISO: 1.000 m2; Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
752042x2x1x019x14509xxxx | Půdorys 1.NP | Stk | 0.19 | 752042x2x1x019x14509xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/0/200.0000/200.0000/200.0000/2/190.0000/0/0/0/0/0/125.0000/200.0000/200.0000/2/95.0000/145.0000/0/90.0/0/0/100.0000/100.0000/100.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/100.00/0/0/190.00/0/145.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30152 | A1 | 6782Obj0798479838 | Objekt |  |  | 190 | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
252x2x02x145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x2x02x145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/117.0/200.0000/200.0000/200.0000/2/141.4214/58.5786/0/45.0/0/117.0/200.0000/200.0000/200.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/117.00/0/200.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30159 | A1 | 6782Obj0798482972 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
252x2x02x145xxxxx0 | Půdorys 1.NP | Stk | 0 | 252x2x02x145xxxxx0 | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/305.8/200.0000/200.0000/200.0000/2/141.4214/58.5786/0/45.0/0/305.8/200.0000/200.0000/200.0000/2/ | 25/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/305.80/0/200.00/1.00/45.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30160 | A1 | 6782Obj0798482982 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
252x2x02x13xxxxxx | Půdorys 1.NP | Stk | 0 | 252x2x02x13xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/0/200.0000/200.0000/200.0000/2/100.0000/26.7949/0/30.0/0/0/200.0000/200.0000/200.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/0/0/200.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30161 | A1 | 6782Obj0798483002 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
252x2x02x13xxxxxx | Půdorys 1.NP | Stk | 0 | 252x2x02x13xxxxxx | BOGEN RUND | 20 | 25 | 2/0/0/0/180.0/0/180.0/200.0000/200.0000/200.0000/2/100.0000/26.7949/0/30.0/0/180.0/200.0000/200.0000/200.0000/2/ | 25/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/180.00/0/200.00/1.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30162 | A1 | 6782Obj0798483012 | Objekt | NEMSOK - Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
752042x2x16x26x15x9xxxx | Půdorys 1.NP | Stk | 0.26 | 752042x2x16x26x15x9xxxx | T-RUND90 | 20 | 75 | 3/0/0/0/180.0/0/315.0/200.0000/200.0000/200.0000/2/260.0000/0/0/0/0/315.0/1.0000/200.0000/200.0000/2/130.0000/150.0000/0/90.0/0/315.0/160.0000/160.0000/160.0000/2/ | 75/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/160.00/0/315.00/260.00/0/150.00/0/90.00/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | DN200 | 200 | 200 | 200 | 0.000 | 0 | 1.0 | TA.03.30163 | A1 | 6782Obj0798483877 | Objekt | 260.000/150.000/100.000/0.000/-100.000/-100.000/0.000/0.000/0.000/1.000 |  | 260 | NEMSOK - K_POSITION: L.1; Podlaží: Nadzemní podlaží 1.NP; Průměr: 200 mm
