Properties of the parts of a building model (IFC2X3), part 46 of 51

# IfcFlowSegment (1090)
Name | In | Jednotka | Délka (m) | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_LAENGE | L_BES_DIM | L_BES_DIM_A2 = L_BES_DIM_A | L_BES_DIM_B2 | K_VOLSTROM | K_LISTVALUE | Kód prvku | Podlaží | Průměr | Teplonosná látka | Allright_Stavebni_dil_ID | Název_objektu | Označení | K_LISTVALUE_ISO
101043152x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/315.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 315x200 | 315 | 200 | 0.000 | 1.550 m2 | PO.03.30033 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798479286 | Objekt | 101043152x15xxxxxxx0 | 2.030 m2 | NEMSOK - K_POSITION: L.11; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.315 m; Výška: 0.2 m
101043152x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/315.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 315x200 | 315 | 200 | 0.000 | 1.550 m2 | PO.03.30034 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798479287 | Objekt | 101043152x15xxxxxxx0 | 2.030 m2 | NEMSOK - K_POSITION: L.12; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.315 m; Výška: 0.2 m
15205125125301xxxxxx0 | Půdorys 1.NP | m | 0.301 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/300.5451/125.0000/125.0000/2/300.5451/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/300.55/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 301 | DN125 | 125 | 125 | 0.000 | 0.301 m | PO.03.30035 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798479298 | Objekt | 15205125125301xxxxxx0 | 0.194 m2
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/160.0000/160.0000/2/30.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN160 | 160 | 160 | 0.000 | 0.030 m | PO.03.30036 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798479315 | Objekt | 152041251253xxxxxxx | 0.023 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 30.000|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
101053152x353xxxxxx0 | Půdorys 1.NP | m2 | 0.353 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/200.0000/1/352.8204/0/0/0/0/0/1.0000/315.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/200.00/352.82/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 353 | 315x200 | 315 | 200 | 0.000 | 1.000 m2 | PO.03.30037 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798479339 | Objekt | 101053152x353xxxxxx0 | 1.000 m2 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.315 m; Výška: 0.2 m
1520516016063xxxxxx0 | Půdorys 1.NP | m | 0.063 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/62.6321/160.0000/160.0000/2/62.6321/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/62.63/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 63 | DN160 | 160 | 160 | 0.000 | 0.063 m | PO.03.30038 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798479344 | Objekt | 1520516016063xxxxxx0 | 0.047 m2
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/200.0000/200.0000/2/30.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN200 | 200 | 200 | 0.000 | 0.030 m | PO.03.30039 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798479358 | Objekt | 152041251253xxxxxxx | 0.026 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 30.000|80.000|80.000|0.000|-80.000|-80.000|0.000|0.000|0.000|1.000
152042x2x139xxxxxx0 | Půdorys 1.NP | m | 0.139 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/139.4608/200.0000/200.0000/2/139.4608/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/139.46/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 139 | DN200 | 200 | 200 | 0.000 | 0.140 m | PO.03.30040 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798479380 | Objekt | 152042x2x139xxxxxx0 | 0.123 m2
152042x2x139xxxxxx0 | Půdorys 1.NP | m | 0.139 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/139.4608/200.0000/200.0000/2/139.4608/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/139.46/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 139 | DN200 | 200 | 200 | 0.000 | 0.140 m | PO.03.30041 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798479386 | Objekt | 152042x2x139xxxxxx0 | 0.123 m2
152052x2x134xxxxxx0 | Půdorys 1.NP | m | 0.134 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/134.3503/200.0000/200.0000/2/134.3503/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/134.35/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 134 | DN200 | 200 | 200 | 0.000 | 0.134 m | PO.03.30042 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798479390 | Objekt | 152052x2x134xxxxxx0 | 0.118 m2
152052x2x832xxxxxx0 | Půdorys 1.NP | m | 0.832 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/832.1573/200.0000/200.0000/2/832.1573/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/832.16/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 832 | DN200 | 200 | 200 | 0.000 | 0.832 m | PO.03.30043 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798479392 | Objekt | 152052x2x832xxxxxx0 | 0.732 m2
152051x1x198xxxxxx0 | Půdorys 1.NP | m | 0.198 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/198.0000/100.0000/100.0000/2/198.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/198.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | 198 | DN100 | 100 | 100 | 120.000 | 0.198 m | PO.03.30044 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798479394 | Objekt | 152051x1x198xxxxxx0 | 0.112 m2
15204125125208xxxxxx0 | Půdorys 1.NP | m | 0.208 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/208.2806/125.0000/125.0000/2/208.2806/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/208.28/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 208 | DN125 | 125 | 125 | 0.000 | 0.208 m | PO.03.30045 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798479397 | Objekt | 15204125125208xxxxxx0 | 0.134 m2
1520512512546xxxxxx0 | Půdorys 1.NP | m | 0.046 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/46.2927/125.0000/125.0000/2/46.2927/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/46.29/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 46 | DN125 | 125 | 125 | 0.000 | 0.046 m | PO.03.30046 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798479405 | Objekt | 1520512512546xxxxxx0 | 0.030 m2
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.03.30047 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798479422 | Objekt | 152041251253xxxxxxx | 0.019 m2
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.03.30048 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798479424 | Objekt | 152041251253xxxxxxx | 0.019 m2
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.03.30049 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798479426 | Objekt | 152041251253xxxxxxx | 0.019 m2
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.03.30050 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798479428 | Objekt | 152041251253xxxxxxx | 0.019 m2
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.03.30051 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798479430 | Objekt | 152041251253xxxxxxx | 0.019 m2
15204125125293xxxxxx0 | Půdorys 1.NP | m | 0.293 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/293.4493/125.0000/125.0000/2/293.4493/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/293.45/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 293 | DN125 | 125 | 125 | 0.000 | 0.293 m | PO.03.30052 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798479435 | Objekt | 15204125125293xxxxxx0 | 0.189 m2
15204125125293xxxxxx0 | Půdorys 1.NP | m | 0.293 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/293.4493/125.0000/125.0000/2/293.4493/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/293.45/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 293 | DN125 | 125 | 125 | 0.000 | 0.293 m | PO.03.30053 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798479438 | Objekt | 15204125125293xxxxxx0 | 0.189 m2
15204125125293xxxxxx0 | Půdorys 1.NP | m | 0.293 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/293.4493/125.0000/125.0000/2/293.4493/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/293.45/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 293 | DN125 | 125 | 125 | 0.000 | 0.293 m | PO.03.30054 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798479441 | Objekt | 15204125125293xxxxxx0 | 0.189 m2
15204125125293xxxxxx0 | Půdorys 1.NP | m | 0.293 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/293.4493/125.0000/125.0000/2/293.4493/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/293.45/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 293 | DN125 | 125 | 125 | 0.000 | 0.293 m | PO.03.30055 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798479444 | Objekt | 15204125125293xxxxxx0 | 0.189 m2
15204125125293xxxxxx0 | Půdorys 1.NP | m | 0.293 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/293.4493/125.0000/125.0000/2/293.4493/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/293.45/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 293 | DN125 | 125 | 125 | 0.000 | 0.293 m | PO.03.30056 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798479447 | Objekt | 15204125125293xxxxxx0 | 0.189 m2
101042502x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/250.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/250.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 250x200 | 250 | 200 | 0.000 | 1.350 m2 | PO.03.30057 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798479468 | Objekt | 101042502x15xxxxxxx0 | 1.830 m2 | NEMSOK - K_POSITION: L.15; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.25 m; Výška: 0.2 m
101042502x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/250.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/250.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 250x200 | 250 | 200 | 0.000 | 1.350 m2 | PO.03.30058 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798479469 | Objekt | 101042502x15xxxxxxx0 | 1.830 m2 | NEMSOK - K_POSITION: L.16; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.25 m; Výška: 0.2 m
101042x2x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/200.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 200x200 | 200 | 200 | 0.000 | 1.200 m2 | PO.03.30059 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798479472 | Objekt | 101042x2x15xxxxxxx0 | 1.680 m2 | NEMSOK - K_POSITION: L.19; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.2 m; Výška: 0.2 m
152041x1x5xxxxxxx | Půdorys 1.NP | m | 0.05 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/50.0000/100.0000/100.0000/2/50.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | 50 | DN100 | 100 | 100 | 120.000 | 0.050 m | PO.03.30060 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798479499 | Objekt | 152041x1x5xxxxxxx | 0.028 m2
152041601601x9xxxxxx0 | Půdorys 1.NP | m | 1.009 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1009.0000/160.0000/160.0000/2/1009.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/1009.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1009 | DN160 | 160 | 160 | 0.000 | 1.009 m | PO.03.30061 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798479523 | Objekt | 152041601601x9xxxxxx0 | 0.761 m2
15205160160112xxxxxxx | Půdorys 1.NP | m | 1.12 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1120.4000/160.0000/160.0000/2/1120.4000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/1120.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1120 | DN160 | 160 | 160 | 0.000 | 1.120 m | PO.03.30062 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798479529 | Objekt | 15205160160112xxxxxxx | 0.845 m2
 | Půdorys 1.NP | m | 2.687 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/2686.8000/180.0000/180.0000/2/2686.8000/0/0/0/0/0/180.0000/180.0000/180.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/180.00/180.00/2686.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 2687 | DN180 | 180 | 180 | 0.000 | 2.687 m | PO.03.30063 | Nadzemní podlaží 1.NP | 180 mm | - | 6782Obj0798479540 | Objekt |  | 2.195 m2
101052x2x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/200.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 200x200 | 200 | 200 | 0.000 | 1.200 m2 | PO.03.30064 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798479541 | Objekt | 101052x2x15xxxxxxx0 | 1.680 m2 | NEMSOK - K_POSITION: L.38; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.2 m; Výška: 0.2 m
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/160.0000/160.0000/2/30.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN160 | 160 | 160 | 0.000 | 0.030 m | PO.03.30065 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798479548 | Objekt | 152041251253xxxxxxx | 0.023 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 30.000|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
152051601603xxxxxxx0 | Půdorys 1.NP | m | 0.3 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/300.0000/160.0000/160.0000/2/300.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/300.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | 300 | DN160 | 160 | 160 | 120.000 | 0.300 m | PO.03.30066 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798479559 | Objekt | 152051601603xxxxxxx0 | 0.226 m2
152051x1x36xxxxxxx | Půdorys 1.NP | m | 0.36 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/360.0000/100.0000/100.0000/2/360.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/360.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | 360 | DN100 | 100 | 100 | 120.000 | 0.360 m | PO.03.30067 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798479560 | Objekt | 152051x1x36xxxxxxx | 0.204 m2
152051x1x36xxxxxxx | Půdorys 1.NP | m | 0.36 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/360.0000/100.0000/100.0000/2/360.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/360.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | 360 | DN100 | 100 | 100 | 120.000 | 0.360 m | PO.03.30068 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798479561 | Objekt | 152051x1x36xxxxxxx | 0.204 m2
15204125125298xxxxxx0 | Půdorys 1.NP | m | 0.298 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/297.9044/125.0000/125.0000/2/297.9044/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/297.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 298 | DN125 | 125 | 125 | 0.000 | 0.298 m | PO.03.30069 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798479564 | Objekt | 15204125125298xxxxxx0 | 0.192 m2
101062x2x641xxxxxx0 | Půdorys 1.NP | m2 | 0.641 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/1/641.3000/0/0/0/0/0/1.0000/200.0000/200.0000/1/ | 10/1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/641.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 641 | 200x200 | 200 | 200 | 0.000 | 1.000 m2 | PO.03.30070 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798479572 | Objekt | 101062x2x641xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.2 m; Výška: 0.2 m
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.03.30071 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798479594 | Objekt | 152041251253xxxxxxx | 0.019 m2
152051x1x36xxxxxxx | Půdorys 1.NP | m | 0.36 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/360.0000/100.0000/100.0000/2/360.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/360.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | 360 | DN100 | 100 | 100 | 120.000 | 0.360 m | PO.03.30072 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798479604 | Objekt | 152051x1x36xxxxxxx | 0.204 m2
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/200.0000/200.0000/2/30.0000/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN200 | 200 | 200 | 0.000 | 0.030 m | PO.03.30073 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798479607 | Objekt | 152041251253xxxxxxx | 0.026 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 30.000|80.000|80.000|0.000|-80.000|-80.000|0.000|0.000|0.000|1.000
152052x2x322xxxxxx0 | Půdorys 1.NP | m | 0.322 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/322.2183/200.0000/200.0000/2/322.2183/0/0/0/0/0/200.0000/200.0000/200.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/322.22/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 322 | DN200 | 200 | 200 | 0.000 | 0.322 m | PO.03.30074 | Nadzemní podlaží 1.NP | 200 mm | - | 6782Obj0798479616 | Objekt | 152052x2x322xxxxxx0 | 0.283 m2
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/160.0000/160.0000/2/30.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN160 | 160 | 160 | 0.000 | 0.030 m | PO.03.30075 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798479624 | Objekt | 152041251253xxxxxxx | 0.023 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 30.000|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
15205160160384xxxxxx0 | Půdorys 1.NP | m | 0.384 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/383.5689/160.0000/160.0000/2/383.5689/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/383.57/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 384 | DN160 | 160 | 160 | 0.000 | 0.384 m | PO.03.30076 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798479626 | Objekt | 15205160160384xxxxxx0 | 0.289 m2
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/160.0000/160.0000/2/30.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN160 | 160 | 160 | 0.000 | 0.030 m | PO.03.30077 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798479633 | Objekt | 152041251253xxxxxxx | 0.023 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 30.000|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
152041x1x5xxxxxxx | Půdorys 1.NP | m | 0.05 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/50.0000/100.0000/100.0000/2/50.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | 50 | DN100 | 100 | 100 | 120.000 | 0.050 m | PO.03.30078 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798479644 | Objekt | 152041x1x5xxxxxxx | 0.028 m2
101044x2x1458xxxxxx0 | Půdorys 1.NP | m2 | 1.458 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/400.0000/200.0000/1/1457.5000/0/0/0/0/0/1.0000/400.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/200.00/1457.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1458 | 400x200 | 400 | 200 | 0.000 | 1.750 m2 | PO.03.30080 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798479648 | Objekt | 101044x2x1458xxxxxx0 | 2.210 m2 | NEMSOK - K_POSITION: L.100; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.4 m; Výška: 0.2 m
1520516016029xxxxxxx | Půdorys 1.NP | m | 0.29 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/289.9138/160.0000/160.0000/2/289.9138/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/289.91/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 290 | DN160 | 160 | 160 | 0.000 | 0.290 m | PO.03.30081 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798479653 | Objekt | 1520516016029xxxxxxx | 0.219 m2
101044502x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 450x200 | 450 | 200 | 0.000 | 1.950 m2 | PO.03.30082 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798479662 | Objekt | 101044502x15xxxxxxx0 | 2.430 m2 | NEMSOK - K_POSITION: L.117; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.45 m; Výška: 0.2 m
101044502x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 450x200 | 450 | 200 | 0.000 | 1.950 m2 | PO.03.30083 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798479663 | Objekt | 101044502x15xxxxxxx0 | 2.430 m2 | NEMSOK - K_POSITION: L.118; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.45 m; Výška: 0.2 m
152051x1x426xxxxxx0 | Půdorys 1.NP | m | 0.426 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/426.2742/100.0000/100.0000/2/426.2742/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/426.27/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 426 | DN100 | 100 | 100 | 0.000 | 0.426 m | PO.03.30084 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798479667 | Objekt | 152051x1x426xxxxxx0 | 0.241 m2
15205160160334xxxxxx0 | Půdorys 1.NP | m | 0.334 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/334.1422/160.0000/160.0000/2/334.1422/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/334.14/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 334 | DN160 | 160 | 160 | 0.000 | 0.334 m | PO.03.30085 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798479677 | Objekt | 15205160160334xxxxxx0 | 0.252 m2
 | Půdorys 1.NP | m | 2.312 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/2312.0000/160.0000/160.0000/2/2312.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/2312.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 2312 | DN160 | 160 | 160 | 0.000 | 2.312 m | PO.03.30086 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798479679 | Objekt |  | 1.743 m2
101043152x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/315.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 315x200 | 315 | 200 | 0.000 | 1.550 m2 | PO.03.30087 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798479690 | Objekt | 101043152x15xxxxxxx0 | 2.030 m2 | NEMSOK - K_POSITION: L.12; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.315 m; Výška: 0.2 m
101043152x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/315.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 315x200 | 315 | 200 | 0.000 | 1.550 m2 | PO.03.30088 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798479691 | Objekt | 101043152x15xxxxxxx0 | 2.030 m2 | NEMSOK - K_POSITION: L.13; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.315 m; Výška: 0.2 m
101048x125015xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/800.0000/1250.0000/1/1500.0000/0/0/0/0/0/1.0000/800.0000/1250.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/800.00/1250.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/1.00 | SB 30/SB 30/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 800x1250 | 800 | 1250 | 0.000 | 6.150 m2 | PO.03.30089 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798479709 | Objekt | 101048x125015xxxxxxx0 | 6.630 m2 | NEMSOK - K_POSITION: L.12; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1250; Šířka: 0.8 m; Výška: 1.25 m
101048x125015xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/800.0000/1250.0000/1/1500.0000/0/0/0/0/0/1.0000/800.0000/1250.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/800.00/1250.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/1.00 | SB 30/SB 30/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 800x1250 | 800 | 1250 | 0.000 | 6.150 m2 | PO.03.30090 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798479710 | Objekt | 101048x125015xxxxxxx0 | 6.630 m2 | NEMSOK - K_POSITION: L.13; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1250; Šířka: 0.8 m; Výška: 1.25 m
101048x125041xxxxxxx | Půdorys 1.NP | m2 | 0.41 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/800.0000/1250.0000/1/410.0000/0/0/0/0/0/1.0000/800.0000/1250.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/800.00/1250.00/410.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/1.00 | SB 30/SB 30/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 410 | 800x1250 | 800 | 1250 | 0.000 | 1.680 m2 | PO.03.30091 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798479711 | Konstrukce v aktuální hladině | 101048x125041xxxxxxx | 1.810 m2 | NEMSOK - K_POSITION: L.16; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1250; Šířka: 0.8 m; Výška: 1.25 m
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.03.30092 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798479721 | Objekt | 152041251253xxxxxxx | 0.019 m2
1520512512581xxxxxx0 | Půdorys 1.NP | m | 0.081 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/81.3173/125.0000/125.0000/2/81.3173/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/81.32/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 81 | DN125 | 125 | 125 | 0.000 | 0.081 m | PO.03.30093 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798479722 | Objekt | 1520512512581xxxxxx0 | 0.052 m2
101054502x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 450x200 | 450 | 200 | 0.000 | 1.950 m2 | PO.03.30094 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798479725 | Objekt | 101054502x15xxxxxxx0 | 2.430 m2 | NEMSOK - K_POSITION: L.125; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.45 m; Výška: 0.2 m
101054502x159xxxxxx0 | Půdorys 1.NP | m2 | 0.159 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/158.5786/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/158.58/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 159 | 450x200 | 450 | 200 | 0.000 | 1.000 m2 | PO.03.30095 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798479727 | Objekt | 101054502x159xxxxxx0 | 1.000 m2 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.45 m; Výška: 0.2 m
101054502x11xxxxxxx0 | Půdorys 1.NP | m2 | 1.1 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/1100.0000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/1100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1100 | 450x200 | 450 | 200 | 0.000 | 1.430 m2 | PO.03.30096 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798479729 | Objekt | 101054502x11xxxxxxx0 | 1.780 m2 | NEMSOK - K_POSITION: L.130; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.45 m; Výška: 0.2 m
101054502x381xxxxxx0 | Půdorys 1.NP | m2 | 0.381 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/380.5000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/380.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 381 | 450x200 | 450 | 200 | 0.000 | 1.000 m2 | PO.03.30097 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798479730 | Objekt | 101054502x381xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.131; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.45 m; Výška: 0.2 m
101046302x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/630.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/630.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/630.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 630x200 | 630 | 200 | 0.000 | 2.490 m2 | PO.03.30098 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798479745 | Objekt | 101046302x15xxxxxxx0 | 2.970 m2 | NEMSOK - K_POSITION: L.8; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.63 m; Výška: 0.2 m
101046302x1035xxxxxx0 | Půdorys 1.NP | m2 | 1.035 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/630.0000/200.0000/1/1034.8000/0/0/0/0/0/1.0000/630.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/630.00/200.00/1034.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1035 | 630x200 | 630 | 200 | 0.000 | 1.720 m2 | PO.03.30099 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798479746 | Objekt | 101046302x1035xxxxxx0 | 2.050 m2 | NEMSOK - K_POSITION: L.11; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.63 m; Výška: 0.2 m
101043552x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/355.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/355.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/355.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 355x200 | 355 | 200 | 0.000 | 1.660 m2 | PO.03.30100 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798479759 | Objekt | 101043552x15xxxxxxx0 | 2.150 m2 | NEMSOK - K_POSITION: L.20; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.355 m; Výška: 0.2 m
101043552x5xxxxxxx | Půdorys 1.NP | m2 | 0.05 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/355.0000/200.0000/1/50.0000/0/0/0/0/0/1.0000/355.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/355.00/200.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 50 | 355x200 | 355 | 200 | 0.000 | 1.000 m2 | PO.03.30101 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798479760 | Objekt | 101043552x5xxxxxxx | 1.000 m2 | NEMSOK - K_POSITION: L.21; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.355 m; Výška: 0.2 m
101044502x116xxxxxxx | Půdorys 1.NP | m2 | 1.16 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/450.0000/200.0000/1/1159.6000/0/0/0/0/0/1.0000/450.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/450.00/200.00/1159.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1160 | 450x200 | 450 | 200 | 0.000 | 1.510 m2 | PO.03.30102 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798479763 | Objekt | 101044502x116xxxxxxx | 1.880 m2 | NEMSOK - K_POSITION: L.24; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.45 m; Výška: 0.2 m
101048x125085xxxxxxx | Půdorys 1.NP | m2 | 0.85 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/800.0000/1250.0000/1/850.0000/0/0/0/0/0/1.0000/800.0000/1250.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/800.00/1250.00/850.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/1.00 | SB 30/SB 30/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 850 | 800x1250 | 800 | 1250 | 0.000 | 3.480 m2 | PO.03.30103 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798479764 | Objekt | 101048x125085xxxxxxx | 3.760 m2 | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 1250; Šířka: 0.8 m; Výška: 1.25 m
1010456035515xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/355.0000/1/1500.0000/0/0/0/0/0/1.0000/560.0000/355.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/355.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 560x355 | 560 | 355 | 0.000 | 2.750 m2 | PO.03.30104 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798479767 | Objekt | 1010456035515xxxxxxx0 | 3.220 m2 | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355; Šířka: 0.56 m; Výška: 0.355 m
1010456035515xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/355.0000/1/1500.0000/0/0/0/0/0/1.0000/560.0000/355.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/355.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 560x355 | 560 | 355 | 0.000 | 2.750 m2 | PO.03.30105 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798479768 | Objekt | 1010456035515xxxxxxx0 | 3.220 m2 | NEMSOK - K_POSITION: L.7; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355; Šířka: 0.56 m; Výška: 0.355 m
1010456035515xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/355.0000/1/1500.0000/0/0/0/0/0/1.0000/560.0000/355.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/355.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 560x355 | 560 | 355 | 0.000 | 2.750 m2 | PO.03.30106 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798479769 | Objekt | 1010456035515xxxxxxx0 | 3.220 m2 | NEMSOK - K_POSITION: L.8; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355; Šířka: 0.56 m; Výška: 0.355 m
 | Půdorys 1.NP | m2 | 1.255 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/355.0000/1/1255.0000/0/0/0/0/0/1.0000/560.0000/355.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/355.00/1255.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1255 | 560x355 | 560 | 355 | 0.000 | 2.300 m2 | PO.03.30107 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798479770 | Objekt |  | 2.700 m2 | NEMSOK - K_POSITION: L.19; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355; Šířka: 0.56 m; Výška: 0.355 m
101042802x916xxxxxx0 | Půdorys 1.NP | m2 | 0.916 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/280.0000/200.0000/1/915.5680/0/0/0/0/0/1.0000/280.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/280.00/200.00/915.57/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 916 | 280x200 | 280 | 200 | 0.000 | 0.880 m2 | PO.03.30108 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798479776 | Objekt | 101042802x916xxxxxx0 | 1.170 m2 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.28 m; Výška: 0.2 m
101042x2x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/200.0000/200.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 200x200 | 200 | 200 | 0.000 | 1.200 m2 | PO.03.30109 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798479779 | Objekt | 101042x2x15xxxxxxx0 | 1.680 m2 | NEMSOK - K_POSITION: L.38; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.2 m; Výška: 0.2 m
152041x1x5xxxxxxx | Půdorys 1.NP | m | 0.05 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/50.0000/100.0000/100.0000/2/50.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | 50 | DN100 | 100 | 100 | 120.000 | 0.050 m | PO.03.30110 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798479788 | Objekt | 152041x1x5xxxxxxx | 0.028 m2
152041x1x36xxxxxxx | Půdorys 1.NP | m | 0.36 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/360.0000/100.0000/100.0000/2/360.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/360.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | 360 | DN100 | 100 | 100 | 120.000 | 0.360 m | PO.03.30111 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798479790 | Objekt | 152041x1x36xxxxxxx | 0.204 m2
152041x1x209xxxxxxx | Půdorys 1.NP | m | 2.09 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/2090.0000/100.0000/100.0000/2/2090.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/2090.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 2090 | DN100 | 100 | 100 | 0.000 | 2.090 m | PO.03.30112 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798479792 | Objekt | 152041x1x209xxxxxxx | 1.182 m2
152041x1x5xxxxxxx | Půdorys 1.NP | m | 0.05 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/50.0000/100.0000/100.0000/2/50.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | 50 | DN100 | 100 | 100 | 120.000 | 0.050 m | PO.03.30113 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798479796 | Objekt | 152041x1x5xxxxxxx | 0.028 m2
152041x1x36xxxxxxx | Půdorys 1.NP | m | 0.36 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/360.0000/100.0000/100.0000/2/360.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/360.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | 360 | DN100 | 100 | 100 | 120.000 | 0.360 m | PO.03.30114 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798479798 | Objekt | 152041x1x36xxxxxxx | 0.204 m2
152041x1x5xxxxxxx | Půdorys 1.NP | m | 0.05 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/50.0000/100.0000/100.0000/2/50.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | 50 | DN100 | 100 | 100 | 120.000 | 0.050 m | PO.03.30115 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798479800 | Objekt | 152041x1x5xxxxxxx | 0.028 m2
152041x1x36xxxxxxx | Půdorys 1.NP | m | 0.36 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/360.0000/100.0000/100.0000/2/360.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/360.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | 360 | DN100 | 100 | 100 | 120.000 | 0.360 m | PO.03.30116 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798479802 | Objekt | 152041x1x36xxxxxxx | 0.204 m2
15204125125293xxxxxx0 | Půdorys 1.NP | m | 0.293 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/293.4493/125.0000/125.0000/2/293.4493/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/293.45/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 293 | DN125 | 125 | 125 | 0.000 | 0.293 m | PO.03.30117 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798479808 | Objekt | 15204125125293xxxxxx0 | 0.189 m2
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.03.30118 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798479811 | Objekt | 152041251253xxxxxxx | 0.019 m2
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/160.0000/160.0000/2/30.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN160 | 160 | 160 | 0.000 | 0.030 m | PO.03.30119 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798479819 | Objekt | 152041251253xxxxxxx | 0.023 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 30.000|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/125.0000/125.0000/2/30.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN125 | 125 | 125 | 0.000 | 0.030 m | PO.03.30120 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798479827 | Objekt | 152041251253xxxxxxx | 0.019 m2
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/160.0000/160.0000/2/30.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN160 | 160 | 160 | 0.000 | 0.030 m | PO.03.30121 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798479829 | Objekt | 152041251253xxxxxxx | 0.023 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 30.000|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
152041x1x5xxxxxxx | Půdorys 1.NP | m | 0.05 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/50.0000/100.0000/100.0000/2/50.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | 50 | DN100 | 100 | 100 | 120.000 | 0.050 m | PO.03.30122 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798479840 | Objekt | 152041x1x5xxxxxxx | 0.028 m2
152041x1x31xxxxxxx | Půdorys 1.NP | m | 0.31 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/310.0000/100.0000/100.0000/2/310.0000/0/0/0/0/0/100.0000/100.0000/100.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/100.00/100.00/310.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Tlaková třída 2 u 5 (do 2500 Pa a -1000 Pa)/Plech ST37 pozink/SPIRO POTRUBÍ/OVALROHR | 310 | DN100 | 100 | 100 | 120.000 | 0.310 m | PO.03.30123 | Nadzemní podlaží 1.NP | 100 mm | - | 6782Obj0798479842 | Objekt | 152041x1x31xxxxxxx | 0.175 m2
152041251253xxxxxxx | Půdorys 1.NP | m | 0.03 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/30.0000/160.0000/160.0000/2/30.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/30.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 30 | DN160 | 160 | 160 | 0.000 | 0.030 m | PO.03.30124 | Nadzemní podlaží 1.NP | 160 mm | - | 6782Obj0798479854 | Objekt | 152041251253xxxxxxx | 0.023 m2 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 30.000|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
 | Půdorys 1.NP | m | 1.115 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1114.7072/125.0000/125.0000/2/1114.7072/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/1114.71/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1115 | DN125 | 125 | 125 | 0.000 | 1.115 m | PO.03.30125 | Nadzemní podlaží 1.NP | 125 mm | - | 6782Obj0798479921 | Objekt |  | 0.718 m2
101052x2x1205xxxxxx0 | Půdorys 1.NP | m2 | 1.205 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/1/1205.3000/0/0/0/0/0/1.0000/200.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/1205.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1205 | 200x200 | 200 | 200 | 0.000 | 0.960 m2 | PO.03.30126 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798479981 | Objekt | 101052x2x1205xxxxxx0 | 1.350 m2 | NEMSOK - K_POSITION: L.52; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.2 m; Výška: 0.2 m
101052x2x15xxxxxxx0 | Půdorys 1.NP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/1/1500.0000/0/0/0/0/0/1.0000/200.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 200x200 | 200 | 200 | 0.000 | 1.200 m2 | PO.03.30127 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798480016 | Objekt | 101052x2x15xxxxxxx0 | 1.680 m2 | NEMSOK - K_POSITION: L.55; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.2 m; Výška: 0.2 m
101052x2x17xxxxxxx | Půdorys 1.NP | m2 | 0.17 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/200.0000/200.0000/1/170.0000/0/0/0/0/0/1.0000/200.0000/200.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/200.00/170.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 170 | 200x200 | 200 | 200 | 0.000 | 1.000 m2 | PO.03.30128 | Nadzemní podlaží 1.NP | - | - | 6782Obj0798480031 | Objekt | 101052x2x17xxxxxxx | 1.000 m2 | NEMSOK - K_POSITION: L.56; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 200; Šířka: 0.2 m; Výška: 0.2 m
