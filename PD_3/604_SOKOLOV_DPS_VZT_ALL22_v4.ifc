Properties of the parts of a building model (IFC2X3), part 39 of 51

# IfcFlowSegment (1090)
Name | In | Jednotka | Délka (m) | K_BLOCKNAME | K_TYP | K_FORMEL | K_APUNKT | K_DIMENSION | K_MATERIAL | K_PROFIL | K_ISOLATION | K_ETAGE | L_BES_LAENGE | L_BES_DIM | L_BES_DIM_A2 = L_BES_DIM_A | L_BES_DIM_B2 | K_VOLSTROM | K_LISTVALUE | Kód prvku | Podlaží | Průměr | Teplonosná látka | Allright_Stavebni_dil_ID | Název_objektu | Označení | K_LISTVALUE_ISO
 | Půdorys 1.PP | m | 1.673 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1673.0315/160.0000/160.0000/2/1673.0315/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/1673.03/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1673 | DN160 | 160 | 160 | 0.000 | 1.673 m | PO.02.30035 | Podzemní podlaží 1.PP | 160 mm | - | 6772Obj0000137269 | Objekt
 | Půdorys 1.PP | m | 4.035 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/4035.0000/125.0000/125.0000/2/4035.0000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/4035.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 4035 | DN125 | 125 | 125 | 0.000 | 4.035 m | PO.02.30036 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000137304 | Objekt
15205125125287xxxxxx0 | Půdorys 1.PP | m | 0.287 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/286.8005/125.0000/125.0000/2/286.8005/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/286.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 287 | DN125 | 125 | 125 | 0.000 | 0.287 m | PO.02.30037 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000137314 | Objekt | 15205125125287xxxxxx0
15205125125131xxxxxx0 | Půdorys 1.PP | m | 0.131 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/131.0128/125.0000/125.0000/2/131.0128/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/131.01/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 131 | DN125 | 125 | 125 | 0.000 | 0.131 m | PO.02.30038 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000137324 | Objekt | 15205125125131xxxxxx0
15205125125287xxxxxx0 | Půdorys 1.PP | m | 0.287 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/286.7392/125.0000/125.0000/2/286.7392/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/286.74/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 287 | DN125 | 125 | 125 | 0.000 | 0.287 m | PO.02.30039 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000137334 | Objekt | 15205125125287xxxxxx0
 | Půdorys 1.PP | m | 2.889 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/2888.5000/160.0000/160.0000/2/2888.5000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/2888.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 2889 | DN160 | 160 | 160 | 0.000 | 2.889 m | PO.02.30040 | Podzemní podlaží 1.PP | 160 mm | - | 6772Obj0000137354 | Objekt
 | Půdorys 1.PP | m | 4.047 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/4047.4000/125.0000/125.0000/2/4047.4000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/4047.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 4047 | DN125 | 125 | 125 | 0.000 | 4.047 m | PO.02.30041 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000137374 | Objekt
10105560355173xxxxxx0 | Půdorys 1.PP | m2 | 0.173 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/355.0000/1/173.2000/0/0/0/0/0/1.0000/560.0000/355.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/355.00/173.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 173 | 560x355 | 560 | 355 | 0.000 | 1.000 m2 | PO.02.30042 | Podzemní podlaží 1.PP | - | - | 6772Obj0000137434 | Objekt | 10105560355173xxxxxx0 | NEMSOK - K_POSITION: L.26; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355; Šířka: 0.56 m; Výška: 0.355 m
101054x560322xxxxxx0 | Půdorys 1.PP | m2 | 0.322 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/400.0000/560.0000/1/321.5000/0/0/0/0/0/1.0000/400.0000/560.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/560.00/321.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 322 | 400x560 | 400 | 560 | 0.000 | 1.000 m2 | PO.02.30043 | Podzemní podlaží 1.PP | - | - | 6772Obj0000137449 | Objekt | 101054x560322xxxxxx0 | NEMSOK - K_POSITION: L.27; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 560; Šířka: 0.4 m; Výška: 0.56 m
101045604x38xxxxxx0 | Půdorys 1.PP | m2 | 0.038 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/38.0000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/38.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 38 | 560x400 | 560 | 400 | 0.000 | 1.000 m2 | PO.02.30044 | Podzemní podlaží 1.PP | - | - | 6772Obj0000137492 | Objekt | 101045604x38xxxxxx0 | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Šířka: 0.56 m; Výška: 0.4 m
101045604x25xxxxxxx | Půdorys 1.PP | m2 | 0.25 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/250.0000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/250.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 250 | 560x400 | 560 | 400 | 0.000 | 1.000 m2 | PO.02.30045 | Podzemní podlaží 1.PP | - | - | 6772Obj0000137607 | Objekt | 101045604x25xxxxxxx | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Šířka: 0.56 m; Výška: 0.4 m; K_EBT_BOX_WC: 1500.000|300.000|220.000|0.000|-300.000|-220.000|0.000|0.000|0.000|1.000
101054x560361xxxxxx0 | Půdorys 1.PP | m2 | 0.361 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/400.0000/560.0000/1/361.0913/0/0/0/0/0/1.0000/400.0000/560.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/560.00/361.09/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 361 | 400x560 | 400 | 560 | 0.000 | 1.000 m2 | PO.02.30046 | Podzemní podlaží 1.PP | - | - | 6772Obj0000137858 | Objekt | 101054x560361xxxxxx0 | NEMSOK - K_POSITION: L.26; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 560; Šířka: 0.4 m; Výška: 0.56 m
101055604x15xxxxxxx0 | Půdorys 1.PP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/1500.0000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 560x400 | 560 | 400 | 0.000 | 2.880 m2 | PO.02.30047 | Podzemní podlaží 1.PP | - | - | 6772Obj0000137942 | Objekt | 101055604x15xxxxxxx0 | NEMSOK - K_POSITION: L.32; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Šířka: 0.56 m; Výška: 0.4 m
101054x560732xxxxxx0 | Půdorys 1.PP | m2 | 0.732 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/400.0000/560.0000/1/732.4000/0/0/0/0/0/1.0000/400.0000/560.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/560.00/732.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 732 | 400x560 | 400 | 560 | 0.000 | 1.410 m2 | PO.02.30048 | Podzemní podlaží 1.PP | - | - | 6772Obj0000138643 | Objekt | 101054x560732xxxxxx0 | NEMSOK - K_POSITION: L.9; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 560; Šířka: 0.4 m; Výška: 0.56 m
101058x5x384xxxxxx0 | Půdorys 1.PP | m2 | 0.384 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/800.0000/500.0000/1/384.3000/0/0/0/0/0/1.0000/800.0000/500.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/800.00/500.00/384.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 384 | 800x500 | 800 | 500 | 0.000 | 1.000 m2 | PO.02.30049 | Podzemní podlaží 1.PP | - | - | 6772Obj0000138687 | Objekt | 101058x5x384xxxxxx0 | NEMSOK - K_POSITION: L.10; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 500; Šířka: 0.8 m; Výška: 0.5 m
101055604x5xxxxxxx0 | Půdorys 1.PP | m2 | 0.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/500.0000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 500 | 560x400 | 560 | 400 | 0.000 | 1.000 m2 | PO.02.30050 | Podzemní podlaží 1.PP | - | - | 6772Obj0000138710 | Objekt | 101055604x5xxxxxxx0 | NEMSOK - K_POSITION: L.12; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Šířka: 0.56 m; Výška: 0.4 m
101055604x399xxxxxx0 | Půdorys 1.PP | m2 | 0.399 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/399.2304/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/399.23/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 399 | 560x400 | 560 | 400 | 0.000 | 1.000 m2 | PO.02.30051 | Podzemní podlaží 1.PP | - | - | 6772Obj0000138757 | Objekt | 101055604x399xxxxxx0 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Šířka: 0.56 m; Výška: 0.4 m
101055604x886xxxxxx0 | Půdorys 1.PP | m2 | 0.886 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/886.3000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/886.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 886 | 560x400 | 560 | 400 | 0.000 | 1.700 m2 | PO.02.30052 | Podzemní podlaží 1.PP | - | - | 6772Obj0000138802 | Objekt | 101055604x886xxxxxx0 | NEMSOK - K_POSITION: L.13; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Šířka: 0.56 m; Výška: 0.4 m
101055604x42xxxxxx0 | Půdorys 1.PP | m2 | 0.042 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/41.5000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/41.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// |  | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 42 | 560x400 | 560 | 400 | 0.000 | 1.000 m2 | PO.02.30053 | Podzemní podlaží 1.PP | - | - | 6772Obj0000138817 | Objekt | 101055604x42xxxxxx0 | NEMSOK - K_POSITION: L.14; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Šířka: 0.56 m; Výška: 0.4 m
101058607601xxxxxxx0 | Půdorys 1.PP | m2 | 0.1 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/860.0000/760.0000/1/100.0000/0/0/0/0/0/1.0000/860.0000/760.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/860.00/760.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 30/SB 30/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 100 | 860x760 | 860 | 760 | 0.000 | 1.000 m2 | PO.02.30054 | Podzemní podlaží 1.PP | - | - | 6772Obj0000139236 | Objekt | 101058607601xxxxxxx0 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 760; Šířka: 0.9 m; Výška: 0.76 m; K_EBT_BOX_WC: 100.000|450.000|352.500|0.000|-450.000|-352.500|0.000|0.000|0.000|1.000
101054x560114xxxxxxx | Půdorys 1.PP | m2 | 1.14 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/400.0000/560.0000/1/1140.0000/0/0/0/0/0/1.0000/400.0000/560.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/560.00/1140.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1140 | 400x560 | 400 | 560 | 0.000 | 2.190 m2 | PO.02.30055 | Podzemní podlaží 1.PP | - | - | 6772Obj0000139295 | Objekt | 101054x560114xxxxxxx | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 560; Šířka: 0.4 m; Výška: 0.56 m
101045604x59xxxxxx0 | Půdorys 1.PP | m2 | 0.059 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/58.5000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/58.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 59 | 560x400 | 560 | 400 | 0.000 | 1.000 m2 | PO.02.30056 | Podzemní podlaží 1.PP | - | - | 6772Obj0000139355 | Objekt | 101045604x59xxxxxx0 | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Šířka: 0.56 m; Výška: 0.4 m
101045604x5xxxxxxx | Půdorys 1.PP | m2 | 0.05 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/50.0000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 50 | 560x400 | 560 | 400 | 0.000 | 1.000 m2 | PO.02.30057 | Podzemní podlaží 1.PP | - | - | 6772Obj0000139370 | Objekt | 101045604x5xxxxxxx | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Šířka: 0.56 m; Výška: 0.4 m
101058607601xxxxxxx0 | Půdorys 1.PP | m2 | 0.1 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/860.0000/760.0000/1/100.0000/0/0/0/0/0/1.0000/860.0000/760.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/860.00/760.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 30/SB 30/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 100 | 860x760 | 860 | 760 | 0.000 | 1.000 m2 | PO.02.30058 | Podzemní podlaží 1.PP | - | - | 6772Obj0000139385 | Objekt | 101058607601xxxxxxx0 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 760; Šířka: 0.9 m; Výška: 0.76 m; K_EBT_BOX_WC: 100.000|450.000|352.500|0.000|-450.000|-352.500|0.000|0.000|0.000|1.000
101058607601xxxxxxx0 | Půdorys 1.PP | m2 | 0.1 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/860.0000/760.0000/1/100.0000/0/0/0/0/0/1.0000/860.0000/760.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/860.00/760.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 30/SB 30/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 100 | 860x760 | 860 | 760 | 0.000 | 1.000 m2 | PO.02.30059 | Podzemní podlaží 1.PP | - | - | 6772Obj0000139444 | Objekt | 101058607601xxxxxxx0 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 760; Šířka: 0.9 m; Výška: 0.76 m; K_EBT_BOX_WC: 100.000|450.000|352.500|0.000|-450.000|-352.500|0.000|0.000|0.000|1.000
1010586076065xxxxxx0 | Půdorys 1.PP | m2 | 0.065 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/860.0000/760.0000/1/64.7000/0/0/0/0/0/1.0000/860.0000/760.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/860.00/760.00/64.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 30/SB 30/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 65 | 860x760 | 860 | 760 | 0.000 | 1.000 m2 | PO.02.30060 | Podzemní podlaží 1.PP | - | - | 6772Obj0000139459 | Objekt | 1010586076065xxxxxx0 | NEMSOK - K_POSITION: L.6; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 760; Šířka: 0.9 m; Výška: 0.76 m
101058607601xxxxxxx0 | Půdorys 1.PP | m2 | 0.1 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/860.0000/760.0000/1/100.0000/0/0/0/0/0/1.0000/860.0000/760.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/860.00/760.00/100.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 30/SB 30/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 100 | 860x760 | 860 | 760 | 0.000 | 1.000 m2 | PO.02.30061 | Podzemní podlaží 1.PP | - | - | 6772Obj0000139481 | Objekt | 101058607601xxxxxxx0 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 760; Šířka: 0.9 m; Výška: 0.76 m; K_EBT_BOX_WC: 100.000|450.000|352.500|0.000|-450.000|-352.500|0.000|0.000|0.000|1.000
101055604x19xxxxxx0 | Půdorys 1.PP | m2 | 0.019 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/19.2304/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/19.23/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 19 | 560x400 | 560 | 400 | 0.000 | 1.000 m2 | PO.02.30062 | Podzemní podlaží 1.PP | - | - | 6772Obj0000139534 | Objekt | 101055604x19xxxxxx0 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Šířka: 0.56 m; Výška: 0.4 m
101055604x498xxxxxx0 | Půdorys 1.PP | m2 | 0.498 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/498.4181/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/498.42/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 498 | 560x400 | 560 | 400 | 0.000 | 1.000 m2 | PO.02.30063 | Podzemní podlaží 1.PP | - | - | 6772Obj0000139564 | Objekt | 101055604x498xxxxxx0 | NEMSOK - K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Šířka: 0.56 m; Výška: 0.4 m
101055604x462xxxxxx0 | Půdorys 1.PP | m2 | 0.462 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/461.9000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/461.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 462 | 560x400 | 560 | 400 | 0.000 | 1.000 m2 | PO.02.30064 | Podzemní podlaží 1.PP | - | - | 6772Obj0000139592 | Objekt | 101055604x462xxxxxx0 | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Šířka: 0.56 m; Výška: 0.4 m
101055604x1019xxxxxx0 | Půdorys 1.PP | m2 | 1.019 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/1019.0000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/1019.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1019 | 560x400 | 560 | 400 | 0.000 | 1.960 m2 | PO.02.30065 | Podzemní podlaží 1.PP | - | - | 6772Obj0000139607 | Objekt | 101055604x1019xxxxxx0 | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Šířka: 0.56 m; Výška: 0.4 m
1010556035545xxxxxxx | Půdorys 1.PP | m2 | 0.45 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/355.0000/1/450.0000/0/0/0/0/0/1.0000/560.0000/355.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/355.00/450.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 450 | 560x355 | 560 | 355 | 0.000 | 1.000 m2 | PO.02.30066 | Podzemní podlaží 1.PP | - | - | 6772Obj0000139622 | Objekt | 1010556035545xxxxxxx | NEMSOK - K_POSITION: L.4; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355; Šířka: 0.56 m; Výška: 0.355 m
1010556035545xxxxxxx | Půdorys 1.PP | m2 | 0.45 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/355.0000/1/450.0000/0/0/0/0/0/1.0000/560.0000/355.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/355.00/450.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/POZINK/OVALROHR | 450 | 560x355 | 560 | 355 | 0.000 | 1.000 m2 | PO.02.30067 | Podzemní podlaží 1.PP | - | - | 6772Obj0000139637 | Objekt | 1010556035545xxxxxxx | NEMSOK - K_POSITION: L.5; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 355; Šířka: 0.56 m; Výška: 0.355 m
1520416016061xxxxxxx | Půdorys 1.PP | m | 0.61 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/610.0000/160.0000/160.0000/2/610.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/610.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 610 | DN160 | 160 | 160 | 0.000 | 0.610 m | PO.02.30068 | Podzemní podlaží 1.PP | 160 mm | - | 6772Obj0000139642 | Objekt | 1520416016061xxxxxxx
152041601605xxxxxxx | Půdorys 1.PP | m | 0.05 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/50.0000/160.0000/160.0000/2/50.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/50.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 50 | DN160 | 160 | 160 | 0.000 | 0.050 m | PO.02.30069 | Podzemní podlaží 1.PP | 160 mm | - | 6772Obj0000139658 | Objekt | 152041601605xxxxxxx
1520416016081xxxxxxx | Půdorys 1.PP | m | 0.81 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/810.0000/160.0000/160.0000/2/810.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/810.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 810 | DN160 | 160 | 160 | 0.000 | 0.810 m | PO.02.30070 | Podzemní podlaží 1.PP | 160 mm | - | 6772Obj0000139688 | Objekt | 1520416016081xxxxxxx
15206160160171xxxxxxx | Půdorys 1.PP | m | 1.71 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1400.0000/160.0000/160.0000/2/1400.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/1400.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1400 | DN160 | 160 | 160 | 0.000 | 1.400 m | PO.02.30071 | Podzemní podlaží 1.PP | 160 mm | - | 6772Obj0000139697 | Objekt | 15206160160171xxxxxxx | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 1710.000|80.000|80.000|0.000|-80.000|-80.000|0.000|0.000|0.000|1.000
 | Půdorys 1.PP | m | 1.246 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/935.5000/125.0000/125.0000/2/935.5000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/935.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 936 | DN125 | 125 | 125 | 0.000 | 0.935 m | PO.02.30072 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000139721 | Objekt | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 1245.500|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
 | Půdorys 1.PP | m | 2.569 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/2258.6000/125.0000/125.0000/2/2258.6000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/2258.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 2259 | DN125 | 125 | 125 | 0.000 | 2.259 m | PO.02.30073 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000139741 | Objekt | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 2568.600|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
15204125125199xxxxxx0 | Půdorys 1.PP | m | 0.199 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/199.3560/125.0000/125.0000/2/199.3560/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/199.36/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 199 | DN125 | 125 | 125 | 0.000 | 0.199 m | PO.02.30074 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000141370 | Objekt | 15204125125199xxxxxx0
15204125125295xxxxxx0 | Půdorys 1.PP | m | 0.295 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/295.1587/125.0000/125.0000/2/295.1587/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/295.16/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 295 | DN125 | 125 | 125 | 0.000 | 0.295 m | PO.02.30075 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000141380 | Objekt | 15204125125295xxxxxx0
15204125125199xxxxxx0 | Půdorys 1.PP | m | 0.199 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/199.3560/125.0000/125.0000/2/199.3560/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/199.36/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 199 | DN125 | 125 | 125 | 0.000 | 0.199 m | PO.02.30076 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000141390 | Objekt | 15204125125199xxxxxx0
15205125125242xxxxxx0 | Půdorys 1.PP | m | 0.242 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/241.7349/125.0000/125.0000/2/241.7349/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/241.73/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 242 | DN125 | 125 | 125 | 0.000 | 0.242 m | PO.02.30077 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000141405 | Objekt | 15205125125242xxxxxx0
 | Půdorys 1.PP | m | 1.959 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1959.3000/125.0000/125.0000/2/1959.3000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/1959.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1959 | DN125 | 125 | 125 | 0.000 | 1.959 m | PO.02.30078 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000141425 | Objekt
15205125125126xxxxxx0 | Půdorys 1.PP | m | 0.126 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/126.2000/125.0000/125.0000/2/126.2000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/126.20/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 126 | DN125 | 125 | 125 | 0.000 | 0.126 m | PO.02.30079 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000141430 | Objekt | 15205125125126xxxxxx0
 | Půdorys 1.PP | m | 1.486 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1486.1000/125.0000/125.0000/2/1486.1000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/1486.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1486 | DN125 | 125 | 125 | 0.000 | 1.486 m | PO.02.30080 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000141435 | Objekt
101051x022599xxxxxx0 | Půdorys 1.PP | m2 | 0.099 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/1000.0000/225.0000/1/99.4000/0/0/0/0/0/1.0000/1000.0000/225.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/1000.00/225.00/99.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 30/SB 30/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 99 | 1000x225 | 1000 | 225 | 0.000 | 1.000 m2 | PO.02.30081 | Podzemní podlaží 1.PP | - | - | 6772Obj0000141466 | Objekt | 101051x022599xxxxxx0 | NEMSOK - K_POSITION: L.7; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 225; Šířka: 1 m; Výška: 0.225 m
1520412512589xxxxxx0 | Půdorys 1.PP | m | 0.089 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/89.0136/125.0000/125.0000/2/89.0136/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/89.01/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 89 | DN125 | 125 | 125 | 0.000 | 0.089 m | PO.02.30082 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000141473 | Objekt | 1520412512589xxxxxx0
15204125125138xxxxxx0 | Půdorys 1.PP | m | 0.138 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/138.0128/125.0000/125.0000/2/138.0128/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/138.01/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 138 | DN125 | 125 | 125 | 0.000 | 0.138 m | PO.02.30083 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000141483 | Objekt | 15204125125138xxxxxx0
1520412512589xxxxxx0 | Půdorys 1.PP | m | 0.089 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/88.9721/125.0000/125.0000/2/88.9721/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/88.97/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 89 | DN125 | 125 | 125 | 0.000 | 0.089 m | PO.02.30084 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000141493 | Objekt | 1520412512589xxxxxx0
 | Půdorys 1.PP | m | 1.175 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1175.2995/125.0000/125.0000/2/1175.2995/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/1175.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1175 | DN125 | 125 | 125 | 0.000 | 1.175 m | PO.02.30085 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000141498 | Konstrukce v aktuální hladině
1520412512538xxxxxx0 | Půdorys 1.PP | m | 0.038 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/38.0128/125.0000/125.0000/2/38.0128/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/38.01/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 38 | DN125 | 125 | 125 | 0.000 | 0.038 m | PO.02.30086 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000141508 | Objekt | 1520412512538xxxxxx0
 | Půdorys 1.PP | m | 1.175 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1175.3000/125.0000/125.0000/2/1175.3000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/1175.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1175 | DN125 | 125 | 125 | 0.000 | 1.175 m | PO.02.30087 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000141523 | Objekt
15206125125559xxxxxx0 | Půdorys 1.PP | m | 0.559 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/558.9708/125.0000/125.0000/2/558.9708/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/558.97/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 559 | DN125 | 125 | 125 | 0.000 | 0.559 m | PO.02.30088 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000141535 | Objekt | 15206125125559xxxxxx0
15204160160897xxxxxx0 | Půdorys 1.PP | m | 0.897 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/897.1336/160.0000/160.0000/2/897.1336/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/897.13/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 897 | DN160 | 160 | 160 | 0.000 | 0.897 m | PO.02.30089 | Podzemní podlaží 1.PP | 160 mm | - | 6772Obj0000143671 | Objekt | 15204160160897xxxxxx0
1520416016078xxxxxx0 | Půdorys 1.PP | m | 0.078 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/78.1891/160.0000/160.0000/2/78.1891/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/78.19/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 78 | DN160 | 160 | 160 | 0.000 | 0.078 m | PO.02.30090 | Podzemní podlaží 1.PP | 160 mm | - | 6772Obj0000143686 | Objekt | 1520416016078xxxxxx0
15204160160897xxxxxx0 | Půdorys 1.PP | m | 0.897 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/897.1336/160.0000/160.0000/2/897.1336/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/897.13/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 897 | DN160 | 160 | 160 | 0.000 | 0.897 m | PO.02.30091 | Podzemní podlaží 1.PP | 160 mm | - | 6772Obj0000143696 | Objekt | 15204160160897xxxxxx0
1520612512578xxxxxx0 | Půdorys 1.PP | m | 0.078 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/78.0012/125.0000/125.0000/2/78.0012/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/78.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 78 | DN125 | 125 | 125 | 0.000 | 0.078 m | PO.02.30092 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000143711 | Objekt | 1520612512578xxxxxx0
101058x5x384xxxxxx0 | Půdorys 1.PP | m2 | 0.384 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/800.0000/500.0000/1/384.3000/0/0/0/0/0/1.0000/800.0000/500.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/800.00/500.00/384.30/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 384 | 800x500 | 800 | 500 | 0.000 | 1.000 m2 | PO.02.30093 | Podzemní podlaží 1.PP | - | - | 6772Obj0000144476 | Objekt | 101058x5x384xxxxxx0 | NEMSOK - K_POSITION: L.10; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 500; Šířka: 0.8 m; Výška: 0.5 m
101051x0225121xxxxxxx | Půdorys 1.PP | m2 | 1.21 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/1000.0000/225.0000/1/1209.6000/0/0/0/0/0/1.0000/1000.0000/225.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/1000.00/225.00/1209.60/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 30/SB 30/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1210 | 1000x225 | 1000 | 225 | 0.000 | 2.960 m2 | PO.02.30094 | Podzemní podlaží 1.PP | - | - | 6772Obj0000144520 | Objekt | 101051x0225121xxxxxxx | NEMSOK - K_POSITION: L.15; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 225; Šířka: 1 m; Výška: 0.225 m; Plocha: 2.96
 | Půdorys 1.PP | m2 | 1.233 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/1000.0000/225.0000/1/1232.8000/0/0/0/0/0/1.0000/1000.0000/225.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/1000.00/225.00/1232.80/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 30/SB 30/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1233 | 1000x225 | 1000 | 225 | 0.000 | 3.020 m2 | PO.02.30095 | Podzemní podlaží 1.PP | - | - | 6772Obj0000144535 | Objekt | NEMSOK - K_POSITION: L.16; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 225; Šířka: 1 m; Výška: 0.225 m; Plocha: 3.02
101055604x6xxxxxxx | Půdorys 1.PP | m2 | 0.06 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/60.0000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/60.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 60 | 560x400 | 560 | 400 | 0.000 | 1.000 m2 | PO.02.30096 | Podzemní podlaží 1.PP | - | - | 6772Obj0000144763 | Objekt | 101055604x6xxxxxxx | NEMSOK - K_POSITION: L.18; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Šířka: 0.56 m; Výška: 0.4 m; Plocha: 1
101045604x1142xxxxxx0 | Půdorys 1.PP | m2 | 1.142 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/1142.4000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/1142.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1142 | 560x400 | 560 | 400 | 0.000 | 2.190 m2 | PO.02.30097 | Podzemní podlaží 1.PP | - | - | 6772Obj0000144801 | Objekt | 101045604x1142xxxxxx0 | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Šířka: 0.56 m; Výška: 0.4 m; Plocha: 2.19
101045604x15xxxxxxx0 | Půdorys 1.PP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/1500.0000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 560x400 | 560 | 400 | 0.000 | 2.880 m2 | PO.02.30098 | Podzemní podlaží 1.PP | - | - | 6772Obj0000144891 | Objekt | 101045604x15xxxxxxx0 | NEMSOK - K_POSITION: L.25; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Šířka: 0.56 m; Výška: 0.4 m; Plocha: 2.88
101045604x15xxxxxxx0 | Půdorys 1.PP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/1500.0000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 560x400 | 560 | 400 | 0.000 | 2.880 m2 | PO.02.30099 | Podzemní podlaží 1.PP | - | - | 6772Obj0000144906 | Objekt | 101045604x15xxxxxxx0 | NEMSOK - K_POSITION: L.26; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Šířka: 0.56 m; Výška: 0.4 m; Plocha: 2.88
101045604x14xxxxxxx | Půdorys 1.PP | m2 | 0.14 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/140.0000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/140.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 140 | 560x400 | 560 | 400 | 0.000 | 1.000 m2 | PO.02.30100 | Podzemní podlaží 1.PP | - | - | 6772Obj0000144921 | Objekt | 101045604x14xxxxxxx | NEMSOK - K_POSITION: L.27; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Šířka: 0.56 m; Výška: 0.4 m; Plocha: 1
101045604x45xxxxxxx | Půdorys 1.PP | m2 | 0.45 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/450.0000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/450.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/100.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 450 | 560x400 | 560 | 400 | 0.000 | 1.000 m2 | PO.02.30101 | Podzemní podlaží 1.PP | - | - | 6772Obj0000144977 | Objekt | 101045604x45xxxxxxx | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Šířka: 0.56 m; Výška: 0.4 m; K_DP_EBT: 0.00; K_EBT_BOX_WC: 59929.988|17100.000|-477.500|58379.988|16540.000|-877.500|0.000|0.000|0.000|1.000; Plocha: 1; K_DWGNAME: ${PROD}l\einbauteile\schalldaempfer\; K_DATE: 2023/01/18; N_FREI_68: Blech ST37 verzinkt
101045604x125xxxxxxx | Půdorys 1.PP | m2 | 1.25 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/1250.0000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/1250.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/0.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/ | 1250 | 560x400 | 560 | 400 | 0.000 | 2.400 m2 | PO.02.30102 | Podzemní podlaží 1.PP | - | - | 6772Obj0000144995 | Objekt | 101045604x125xxxxxxx | 2.400 m2 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Šířka: 0.56 m; Výška: 0.4 m; K_DP_EBT: 0.00; K_EBT_BOX_WC: 55260.000|5803.600|-841.500|54700.000|4553.600|-1241.500|0.000|0.000|0.000|1.000; Plocha: 2.4; K_DWGNAME: ${PROD}l\einbauteile\schalldaempfer\; K_DATE: 2023/01/13; N_FREI_68: Blech ST37 verzinkt
101055604x15xxxxxxx0 | Půdorys 1.PP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/1500.0000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Alu kaschiert/0.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/ | 1500 | 560x400 | 560 | 400 | 0.000 | 2.880 m2 | PO.02.30103 | Podzemní podlaží 1.PP | - | - | 6772Obj0000145010 | Objekt | 101055604x15xxxxxxx0 | 2.880 m2 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Šířka: 0.56 m; Výška: 0.4 m; K_DP_EBT: 0.00; K_EBT_BOX_WC: 59301.309|7410.000|-880.000|57801.309|6850.000|-1280.000|0.000|0.000|0.000|1.000; Plocha: 2.88; K_DWGNAME: ${PROD}l\einbauteile\schalldaempfer\; K_DATE: 2023/01/13; N_FREI_68: Blech ST37 verzinkt
 | Půdorys 1.PP | m | 3.989 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/3989.0000/160.0000/160.0000/2/3989.0000/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/3989.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 3989 | DN160 | 160 | 160 | 0.000 | 3.989 m | PO.02.30104 | Podzemní podlaží 1.PP | 160 mm | - | 6772Obj0000160136 | Objekt
152041601607xxxxxx0 | Půdorys 1.PP | m | 0.007 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/7.0720/160.0000/160.0000/2/7.0720/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/7.07/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 7 | DN160 | 160 | 160 | 0.000 | 0.007 m | PO.02.30105 | Podzemní podlaží 1.PP | 160 mm | - | 6772Obj0000160141 | Objekt | 152041601607xxxxxx0
15204160160235xxxxxx0 | Půdorys 1.PP | m | 0.235 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/235.1472/160.0000/160.0000/2/235.1472/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/235.15/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 235 | DN160 | 160 | 160 | 0.000 | 0.235 m | PO.02.30106 | Podzemní podlaží 1.PP | 160 mm | - | 6772Obj0000160151 | Objekt | 15204160160235xxxxxx0
152041601607xxxxxx0 | Půdorys 1.PP | m | 0.007 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/6.9986/160.0000/160.0000/2/6.9986/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/7.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 7 | DN160 | 160 | 160 | 0.000 | 0.007 m | PO.02.30107 | Podzemní podlaží 1.PP | 160 mm | - | 6772Obj0000160161 | Objekt | 152041601607xxxxxx0
15204160160667xxxxxx0 | Půdorys 1.PP | m | 0.667 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/666.8068/160.0000/160.0000/2/666.8068/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/666.81/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 667 | DN160 | 160 | 160 | 0.000 | 0.667 m | PO.02.30108 | Podzemní podlaží 1.PP | 160 mm | - | 6772Obj0000160166 | Objekt | 15204160160667xxxxxx0
1520416016014xxxxxxx | Půdorys 1.PP | m | 0.14 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/139.8104/160.0000/160.0000/2/139.8104/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/139.81/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 140 | DN160 | 160 | 160 | 0.000 | 0.140 m | PO.02.30109 | Podzemní podlaží 1.PP | 160 mm | - | 6772Obj0000160181 | Objekt | 1520416016014xxxxxxx
15204160160667xxxxxx0 | Půdorys 1.PP | m | 0.667 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/666.8069/160.0000/160.0000/2/666.8069/0/0/0/0/0/160.0000/160.0000/160.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/666.81/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 667 | DN160 | 160 | 160 | 0.000 | 0.667 m | PO.02.30110 | Podzemní podlaží 1.PP | 160 mm | - | 6772Obj0000160191 | Objekt | 15204160160667xxxxxx0
101054x560596xxxxxx0 | Půdorys 1.PP | m2 | 0.596 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/400.0000/560.0000/1/596.0000/0/0/0/0/0/1.0000/400.0000/560.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/400.00/560.00/596.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 596 | 400x560 | 400 | 560 | 0.000 | 1.140 m2 | PO.02.30111 | Podzemní podlaží 1.PP | - | - | 6772Obj0000160301 | Objekt | 101054x560596xxxxxx0 | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 560; Šířka: 0.4 m; Výška: 0.56 m; Plocha: 1.14
101055604x746xxxxxx0 | Půdorys 1.PP | m2 | 0.746 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/746.0000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/746.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 746 | 560x400 | 560 | 400 | 0.000 | 1.430 m2 | PO.02.30112 | Podzemní podlaží 1.PP | - | - | 6772Obj0000160316 | Objekt | 101055604x746xxxxxx0 | NEMSOK - K_POSITION: L.3; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Šířka: 0.56 m; Výška: 0.4 m; Plocha: 1.43
15204125125151xxxxxxx | Půdorys 1.PP | m | 1.51 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/1209.5000/125.0000/125.0000/2/1209.5000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/-1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/1209.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1210 | DN125 | 125 | 125 | 0.000 | 1.210 m | PO.02.30115 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000160361 | Objekt | 15204125125151xxxxxxx | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 1509.500|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
1520612512578xxxxxxx | Půdorys 1.PP | m | 0.78 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/479.7000/125.0000/125.0000/2/479.7000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/479.70/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 480 | DN125 | 125 | 125 | 0.000 | 0.480 m | PO.02.30116 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000160378 | Objekt | 1520612512578xxxxxxx | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 779.700|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
101055604x29xxxxxx0 | Půdorys 1.PP | m2 | 0.029 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/560.0000/400.0000/1/29.0000/0/0/0/0/0/1.0000/560.0000/400.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/560.00/400.00/29.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.80 | SB 20/SB 20/// | Mineralwolle/0.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 29 | 560x400 | 560 | 400 | 0.000 | 1.000 m2 | PO.02.30117 | Podzemní podlaží 1.PP | - | - | 6772Obj0000160404 | Objekt | 101055604x29xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.1; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 400; Šířka: 0.56 m; Výška: 0.4 m; K_EBT_BOX_WC: 379.000|300.000|220.000|0.000|-300.000|-220.000|0.000|0.000|0.000|1.000; Plocha: 1
15205125125468xxxxxx0 | Půdorys 1.PP | m | 0.468 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/168.4000/125.0000/125.0000/2/168.4000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/168.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 168 | DN125 | 125 | 125 | 0.000 | 0.168 m | PO.02.30118 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000160420 | Objekt | 15205125125468xxxxxx0 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 468.400|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
15205125125726xxxxxx0 | Půdorys 1.PP | m | 0.726 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/116.4000/125.0000/125.0000/2/116.4000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/116.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 116 | DN125 | 125 | 125 | 0.000 | 0.116 m | PO.02.30119 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000160436 | Objekt | 15205125125726xxxxxx0 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 416.400|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
152051251251x7xxxxxx0 | Půdorys 1.PP | m | 1.007 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/397.4000/125.0000/125.0000/2/397.4000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/0/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/397.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 397 | DN125 | 125 | 125 | 0.000 | 0.397 m | PO.02.30120 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000160452 | Objekt | 152051251251x7xxxxxx0 | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 697.400|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
 | Půdorys 1.PP | m | 4.898 | ROHR | 20 | 15 | 2/0/0/0/180.0/0/0/4288.4000/125.0000/125.0000/2/4288.4000/0/0/0/0/0/125.0000/125.0000/125.0000/2/ | 15/1/2/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/125.00/125.00/4288.40/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | SPIRO POTRUBÍ/0.00 | //// | Mineralwolle/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 4288 | DN125 | 125 | 125 | 0.000 | 4.288 m | PO.02.30121 | Podzemní podlaží 1.PP | 125 mm | - | 6772Obj0000160468 | Objekt | NEMSOK - K_POSITION: L.1; K_EBT_BOX_WC: 4588.400|62.500|62.500|0.000|-62.500|-62.500|0.000|0.000|0.000|1.000
10104315160798xxxxxx0 | Půdorys 1.PP | m2 | 0.798 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/798.1000/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/798.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 798 | 315x160 | 315 | 160 | 0.000 | 1.000 m2 | PO.02.30122 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000000945 | Hranaté potrubí | 10104315160798xxxxxx0 | 1.010 m2 | NEMSOK - K_POSITION: L.22; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.315 m; Výška: 0.16 m
101052x16074xxxxxxx | Půdorys 1.PP | m2 | 0.74 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/200.0000/160.0000/1/740.0000/0/0/0/0/0/1.0000/200.0000/160.0000/1/ | 10/0/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/200.00/160.00/740.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 740 | 200x160 | 200 | 160 | 0.000 | 1.000 m2 | PO.02.30123 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000000984 | Hranaté potrubí | 101052x16074xxxxxxx | 1.000 m2 | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.2 m; Výška: 0.16 m
 | Půdorys 1.PP | m2 | 1.492 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/160.0000/160.0000/1/1492.1000/0/0/0/0/0/1.0000/160.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/160.00/160.00/1492.10/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1492 | 160x160 | 160 | 160 | 0.000 | 0.950 m2 | PO.02.30124 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001026 | Hranaté potrubí |  | 1.430 m2 | NEMSOK - K_POSITION: L.2; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.16 m; Výška: 0.16 m
1010425016015xxxxxxx0 | Půdorys 1.PP | m2 | 1.5 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/250.0000/160.0000/1/1500.0000/0/0/0/0/0/1.0000/250.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/160.00/1500.00/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1500 | 250x160 | 250 | 160 | 0.000 | 1.230 m2 | PO.02.30125 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001034 | Hranaté potrubí | 1010425016015xxxxxxx0 | 1.710 m2 | NEMSOK - K_POSITION: L.6; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.25 m; Výška: 0.16 m
1010425016056xxxxxx0 | Půdorys 1.PP | m2 | 0.056 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/250.0000/160.0000/1/55.5000/0/0/0/0/0/1.0000/250.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/250.00/160.00/55.50/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 56 | 250x160 | 250 | 160 | 0.000 | 1.000 m2 | PO.02.30126 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001036 | Hranaté potrubí | 1010425016056xxxxxx0 | 1.000 m2 | NEMSOK - K_POSITION: L.7; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.25 m; Výška: 0.16 m
 | Půdorys 1.PP | m2 | 1.146 | LUFTLEITUNG | 10 | 10 | 2/0/0/0/180.0/0/0/1.0000/315.0000/160.0000/1/1145.9000/0/0/0/0/0/1.0000/315.0000/160.0000/1/ | 10/-1/1/0/0/0/0/1000/0/-1/0/0/0/0/0/0/0/0/0/0/315.00/160.00/1145.90/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/0/ | Blech ST37 verzinkt/0.60 | SB 20/SB 20/// | Blech ummantelt/40.00 | DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)/Blech ST37 verzinkt/SPIRO POTRUBÍ/OVALROHR | 1146 | 315x160 | 315 | 160 | 0.000 | 1.090 m2 | PO.02.30127 | Podzemní podlaží 1.PP | - | vzduch | 6772Obj0000001040 | Hranaté potrubí |  | 1.450 m2 | NEMSOK - K_POSITION: L.9; K_NORM: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa); L_BES_DIM_B: 160; Šířka: 0.315 m; Výška: 0.16 m
