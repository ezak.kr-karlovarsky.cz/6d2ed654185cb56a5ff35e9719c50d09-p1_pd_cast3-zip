Properties of the parts of a building model (IFC2X3), part 2 of 51

# IfcBuildingElementProxy (417)
Name | In | Allright_Stavebni_dil_ID | Jednotka | Název_objektu | V6 (m) = V7 (m) = V8 (m) = V9 | Označení | Kód prvku | Podlaží | Délka (m) | Třída reakce na oheň
ABL Regler RN | Půdorys 1.NP | 6782Obj0798480762 | Stk | Objekt | 0 | ABL Regler RN | KA.03.30106 | Nadzení podlaží 1.NP | 0.31 | B | NEMSOK - Číslo místnosti: K1.11; Jmenovitá velikost vstupu: DN200; Průtok: 1,002 m3/s; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|200.00|200.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Blech ummantelt|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN200; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/03; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN200; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
ABL Regler RN | Půdorys 1.NP | 6782Obj0798481320 | Stk | Objekt | 0 | ABL Regler RN | KA.03.30107 | Nadzení podlaží 1.NP | 0.31 | B | NEMSOK - Číslo místnosti: K1.11; Jmenovitá velikost vstupu: DN200; Průtok: 1,002 m3/s; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|200.00|200.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: POZINK|0.00; K_PROFIL: ||||; K_ISOLATION: Blech ummantelt|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN200; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/03; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: POZINK; Jmenovitá velikost výstupu: DN200; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
Schalldämpfer | Půdorys 1.NP | 6782Obj0798481591 | Stk | Objekt | 0 | Schalldämpfer | KA.03.30108 | Nadzení podlaží 1.NP | 1 | B | NEMSOK - Číslo místnosti: K1.09; Jmenovitá velikost vstupu: DN250; Průtok: 1,002 m3/s; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: Schalldämpfer; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|250.00|250.00|1000.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\schalldaempfer\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|100.00; L_BES_LAENGE: 1000; L_BES_DIM: DN250; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN250; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
Schalldämpfer | Půdorys 1.NP | 6782Obj0798481612 | Stk | Objekt | 0 | Schalldämpfer | KA.03.30109 | Nadzení podlaží 1.NP | 0.5 | B | NEMSOK - Číslo místnosti: K1.09; Jmenovitá velikost vstupu: DN250; Průtok: 1,002 m3/s; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: Schalldämpfer; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|250.00|250.00|500.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\schalldaempfer\; K_MATERIAL: POZINK|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|100.00; L_BES_LAENGE: 500; L_BES_DIM: DN250; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: POZINK; Jmenovitá velikost výstupu: DN250; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
ABL Regler RN | Půdorys 1.NP | 6782Obj0798481973 | Stk | Objekt | 0 | ABL Regler RN | KA.03.30111 | Nadzení podlaží 1.NP | 0.31 | B | NEMSOK - Číslo místnosti: K1.02; Jmenovitá velikost vstupu: DN160; Průtok: 1,002 m3/s; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|160.00|160.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Blech ummantelt|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN160; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN160; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
Absperrklappe händisch NAK-H | Půdorys 1.NP | 6782Obj0798482322 | Stk | Objekt | 0 | Absperrklappe händisch NAK-H | KA.03.30112 | Nadzení podlaží 1.NP | 0.2 | B | NEMSOK - Číslo místnosti: K1.11; Jmenovitá velikost vstupu: DN100; Průtok: 1,002 m3/s; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: Absperrklappe händisch NAK-H; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|100.00|100.00|200.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Blech ummantelt|40.00; L_BES_LAENGE: 200; L_BES_DIM: DN100; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN100; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
Absperrklappe elektrisch NAK-E | Půdorys 1.NP | 6782Obj0798482335 | Stk | Objekt | 0 | Absperrklappe elektrisch NAK-E | KA.03.30113 | Nadzení podlaží 1.NP | 0.2 | B | NEMSOK - Číslo místnosti: K1.08; Jmenovitá velikost vstupu: DN100; Průtok: 1,002 m3/s; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: Absperrklappe elektrisch NAK-E; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|100.00|100.00|200.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.1; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Blech ummantelt|40.00; L_BES_LAENGE: 200; L_BES_DIM: DN100; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN100; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální; K_ETAGE: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)|Blech ST37 verzinkt|SPIRO POTRUBÍ|OVALROHR; K_EBT_BOX_WC: 32774.998|-9204.727|3115.000|32464.998|-9329.727|3015.000|0.000|0.000|0.000|1.000
ABL Regler RN | Půdorys 1.NP | 6782Obj0798482543 | Stk | Objekt | 0 | ABL Regler RN | KA.03.30114 | Nadzení podlaží 1.NP | 0.31 | B | NEMSOK - Číslo místnosti: K1.10; Jmenovitá velikost vstupu: DN160; Průtok: 1,002 m3/s; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|160.00|160.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Blech ummantelt|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN160; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN160; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
Absperrklappe elektrisch NAK-E | Půdorys 1.NP | 6782Obj0798482747 | Stk | Objekt | 0 | Absperrklappe elektrisch NAK-E | KA.03.30115 | Nadzení podlaží 1.NP | 0.2 | B | NEMSOK - Číslo místnosti: K1.08; Jmenovitá velikost vstupu: DN100; Průtok: 1,002 m3/s; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: Absperrklappe elektrisch NAK-E; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|100.00|100.00|200.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.1; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Blech ummantelt|40.00; L_BES_LAENGE: 200; L_BES_DIM: DN100; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/04; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN100; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální; K_ETAGE: DIN Druckstufe 1 u 4 (bis 1000 Pa und -630 Pa)|Blech ST37 verzinkt|SPIRO POTRUBÍ|OVALROHR; K_EBT_BOX_WC: 129.255|50.000|50.000|0.000|-50.000|-50.000|0.000|0.000|0.000|1.000
ABL Regler RN | Půdorys 1.NP | 6782Obj0798486235 | Stk | Objekt | 0 | ABL Regler RN | KA.03.30116 | Nadzení podlaží 1.NP | 0.31 | B | NEMSOK - Číslo místnosti: K1.14; Jmenovitá velikost vstupu: DN160; Průtok: 1,002 m3/s; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|160.00|160.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: POZINK|0.00; K_PROFIL: ||||; K_ISOLATION: Blech ummantelt|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN160; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/11; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: POZINK; Jmenovitá velikost výstupu: DN160; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
Absperrklappe elektrisch NAK-E | Půdorys 1.NP | 6782Obj0798486236 | Stk | Objekt | 0 | Absperrklappe elektrisch NAK-E | KA.03.30117 | Nadzení podlaží 1.NP | 0.25 | B | NEMSOK - Číslo místnosti: K1.14; Jmenovitá velikost vstupu: DN125; Průtok: 1,002 m3/s; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: Absperrklappe elektrisch NAK-E; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|250.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_MATERIAL: POZINK|0.00; K_PROFIL: ||||; K_ISOLATION: Blech ummantelt|40.00; L_BES_LAENGE: 250; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/11; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: POZINK; Jmenovitá velikost výstupu: DN125; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
Absperrklappe elektrisch NAK-E | Půdorys 1.NP | 6782Obj0798488909 | Stk | Objekt | 0 | Absperrklappe elektrisch NAK-E | KA.03.30118 | Nadzení podlaží 1.NP | 0.24 | B | NEMSOK - Číslo místnosti: K1.03; Jmenovitá velikost vstupu: DN125; Průtok: 1,002 m3/s; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: Absperrklappe elektrisch NAK-E; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|240.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_MATERIAL: POZINK|0.00; K_PROFIL: ||||; K_ISOLATION: Blech ummantelt|40.00; L_BES_LAENGE: 240; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 120.000; K_DATE: 2023/01/13; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: POZINK; Jmenovitá velikost výstupu: DN125; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
Absperrklappe elektrisch NAK-E | Půdorys 1.NP | 6782Obj0798489025 | Stk | Objekt | 0 | Absperrklappe elektrisch NAK-E | KA.03.30119 | Nadzení podlaží 1.NP | 0.24 | B | NEMSOK - Číslo místnosti: K1.02; Jmenovitá velikost vstupu: DN125; Průtok: 1,002 m3/s; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: Absperrklappe elektrisch NAK-E; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|240.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_MATERIAL: POZINK|0.00; K_PROFIL: ||||; K_ISOLATION: Blech ummantelt|40.00; L_BES_LAENGE: 240; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/13; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: POZINK; Jmenovitá velikost výstupu: DN125; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
Jalousieklappe JZ | Půdorys 1.NP | 6782Obj0798491381 | Stk | Objekt | 0 | Jalousieklappe JZ | KA.03.30120 | Nadzení podlaží 1.NP | 0.3 | B | NEMSOK - Číslo místnosti: K1.09; Jmenovitá velikost vstupu: DN200; Průtok: 1,002 m3/s; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: Jalousieklappe JZ; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|200.00|200.00|300.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Alu kaschiert|100.00; L_BES_LAENGE: 300; L_BES_DIM: DN200; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/18; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN200; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
Muffe | Půdorys 1.NP | 6782Obj0798491426 | Stk | Objekt | 0 | Muffe | KA.03.30121 | Nadzení podlaží 1.NP | 0.085 | B | NEMSOK - Číslo místnosti: K1.09; Jmenovitá velikost vstupu: DN200; Průtok: 1,002 m3/s; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: Muffe; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|200.00|200.00|85.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\muffe-nippel\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Alu kaschiert|100.00; L_BES_LAENGE: 85; L_BES_DIM: DN200; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/18; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN200; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
Absperrklappe elektrisch NAK-E | Půdorys 1.NP | 6782Obj0798492378 | Stk | Objekt | 0 | Absperrklappe elektrisch NAK-E | KA.03.30123 | Nadzení podlaží 1.NP | 0.24 | B | NEMSOK - Číslo místnosti: K1.12; Jmenovitá velikost vstupu: DN100; Průtok: 1,002 m3/s; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: Absperrklappe elektrisch NAK-E; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|100.00|100.00|240.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile\klappen eckig\; K_MATERIAL: POZINK|0.00; K_PROFIL: ||||; K_ISOLATION: Blech ummantelt|40.00; L_BES_LAENGE: 240; L_BES_DIM: DN100; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/19; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: POZINK; Jmenovitá velikost výstupu: DN100; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
ABL Regler RN | Půdorys 1.NP | 6782Obj0798492418 | Stk | Objekt | 0 | ABL Regler RN | KA.03.30124 | Nadzení podlaží 1.NP | 0.31 | B | NEMSOK - Číslo místnosti: K1.10; Jmenovitá velikost vstupu: DN160; Průtok: 1,002 m3/s; Dolní_hrana: 0 m; Horní_hrana: 0 m; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|160.00|160.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.1; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Blech ummantelt|0.00; L_BES_LAENGE: 310; L_BES_DIM: DN160; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/20; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN160; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální; K_EBT_BOX_WC: 31943.474|-7592.747|3110.000|31633.474|-7792.747|2950.000|0.000|0.000|0.000|1.000
Schalldämpfer | Půdorys 1.NP | 6782Obj0798491498 | Stk | Konstrukce v aktuální hladině | 0 | Schalldämpfer | KA.03.30122 | Nadzení podlaží 1.NP | 1.25 | B | NEMSOK - Číslo místnosti: K1.10; Jmenovitá velikost vstupu: DN250; Průtok: 1,002 m3/s; K_GEWERK: 1; K_BLOCKNAME: Schalldämpfer; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|250.00|250.00|1250.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_DWGNAME: ${PROD}l\einbauteile\schalldaempfer\; K_MATERIAL: POZINK|0.00; K_PROFIL: ||||; K_ISOLATION: Blech ummantelt|40.00; L_BES_LAENGE: 1250; L_BES_DIM: DN250; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/19; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: POZINK; Jmenovitá velikost výstupu: DN250; Provozní tlak: 0,0055 bar; Tlaková třída: C; Typ ovladání: manuální
QMODEL_816b41ac_f5c9_475b_87ff_3 | Půdorys 1.NP | 6782Obj0798479110 | Kus | Objekt | 0 | QMODEL_816b41ac_f5c9_475b_87ff_3 | VV.03.3077 | Nadzemní podlaží 1.NP | 0.388 | A1 | NEMSOK - Číslo místnosti: K1.01; Šířka: 0.26 m; Výška: 0.255 m; Průměr: 100 mm; Jmenovitá velikost vstupu: 100 mm; Průtok: 150 m3/hod; Rychlost: 1,9 m/s
Jednotka VZT | Půdorys 1.NP | 6782Obj0798482755 | Kus | Objekt | 0 | Jednotka VZT | JV.03.30001 | Podzemní podlaží 1.PP | 2.4 | NEMSOK - Šířka: 1.8 m; Výška: 0.588 m; Hmotnost: 304 kg; Maximální tlak: 0,0065 bar; Jmenovitý výkon: 1,75 kW; Chladicí výkon citelný: 0,5 kW; Chladící výkon: 1,1 kW; Topný výkon: 1,5 kW; Odvaděný vzduch: 1180 m3/hod; Přiváděný vzduch: 1180 m3/hod; Stupeň krytí: IP 44; Napajecí napětí: 400 V
QMODEL_6fc183b3_b42d_4627_9a1f_c | Půdorys 1.NP | 6782Obj0798479314 | Kus | Objekt | 0 | QMODEL_6fc183b3_b42d_4627_9a1f_c | VV.03.30001 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.10; Šířka: 0.595 m; Výška: 0.261 m; Průměr: -; Jmenovitá velikost vstupu: 160 mm; Průtok: 140 m3/h; Rychlost: 2,1
QMODEL_6fc183b3_b42d_4627_9a1f_c | Půdorys 1.NP | 6782Obj0798479172 | Kus | Objekt | 0 | QMODEL_6fc183b3_b42d_4627_9a1f_c | VV.03.30002 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.10; Šířka: 0.595 m; Výška: 0.261 m; Průměr: -; Jmenovitá velikost vstupu: 160 mm; Průtok: 140 m3/h; Rychlost: 2,1
QMODEL_8f547253_65b4_4e98_96f4_2 | Půdorys 1.NP | 6782Obj0798478840 | Kus | Objekt | 0 | QMODEL_8f547253_65b4_4e98_96f4_2 | VV.03.30003 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.11; Šířka: 0.595 m; Výška: 0.226 m; Průměr: -; Jmenovitá velikost vstupu: 125 mm; Průtok: 70 m3/h; Rychlost: 0,9
QMODEL_8f547253_65b4_4e98_96f4_2 | Půdorys 1.NP | 6782Obj0798479429 | Kus | Objekt | 0 | QMODEL_8f547253_65b4_4e98_96f4_2 | VV.03.30004 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.11; Šířka: 0.595 m; Výška: 0.226 m; Průměr: -; Jmenovitá velikost vstupu: 125 mm; Průtok: 70 m3/h; Rychlost: 0,9
QMODEL_8f547253_65b4_4e98_96f4_2 | Půdorys 1.NP | 6782Obj0798478842 | Kus | Objekt | 0 | QMODEL_8f547253_65b4_4e98_96f4_2 | VV.03.30005 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.12; Šířka: 0.595 m; Výška: 0.226 m; Průměr: -; Jmenovitá velikost vstupu: 125 mm; Průtok: 70 m3/h; Rychlost: 0,9
QMODEL_8f547253_65b4_4e98_96f4_2 | Půdorys 1.NP | 6782Obj0798479427 | Kus | Objekt | 0 | QMODEL_8f547253_65b4_4e98_96f4_2 | VV.03.30006 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.12; Šířka: 0.595 m; Výška: 0.226 m; Průměr: -; Jmenovitá velikost vstupu: 125 mm; Průtok: 70 m3/h; Rychlost: 0,9
QMODEL_8f547253_65b4_4e98_96f4_2 | Půdorys 1.NP | 6782Obj0798478844 | Kus | Objekt | 0 | QMODEL_8f547253_65b4_4e98_96f4_2 | VV.03.30007 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.13; Šířka: 0.595 m; Výška: 0.226 m; Průměr: -; Jmenovitá velikost vstupu: 125 mm; Průtok: 70 m3/h; Rychlost: 0,9
QMODEL_8f547253_65b4_4e98_96f4_2 | Půdorys 1.NP | 6782Obj0798479425 | Kus | Objekt | 0 | QMODEL_8f547253_65b4_4e98_96f4_2 | VV.03.30008 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.13; Šířka: 0.595 m; Výška: 0.226 m; Průměr: -; Jmenovitá velikost vstupu: 125 mm; Průtok: 70 m3/h; Rychlost: 0,9
QMODEL_8f547253_65b4_4e98_96f4_2 | Půdorys 1.NP | 6782Obj0798478846 | Kus | Objekt | 0 | QMODEL_8f547253_65b4_4e98_96f4_2 | VV.03.30009 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.14; Šířka: 0.595 m; Výška: 0.226 m; Průměr: -; Jmenovitá velikost vstupu: 125 mm; Průtok: 70 m3/h; Rychlost: 0,9
QMODEL_8f547253_65b4_4e98_96f4_2 | Půdorys 1.NP | 6782Obj0798479423 | Kus | Objekt | 0 | QMODEL_8f547253_65b4_4e98_96f4_2 | VV.03.30010 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.14; Šířka: 0.595 m; Výška: 0.226 m; Průměr: -; Jmenovitá velikost vstupu: 125 mm; Průtok: 70 m3/h; Rychlost: 0,9
QMODEL_8f547253_65b4_4e98_96f4_2 | Půdorys 1.NP | 6782Obj0798478848 | Kus | Objekt | 0 | QMODEL_8f547253_65b4_4e98_96f4_2 | VV.03.30011 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.15; Šířka: 0.595 m; Výška: 0.226 m; Průměr: -; Jmenovitá velikost vstupu: 125 mm; Průtok: 70 m3/h; Rychlost: 0,9
QMODEL_8f547253_65b4_4e98_96f4_2 | Půdorys 1.NP | 6782Obj0798479421 | Kus | Objekt | 0 | QMODEL_8f547253_65b4_4e98_96f4_2 | VV.03.30012 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.15; Šířka: 0.595 m; Výška: 0.226 m; Průměr: -; Jmenovitá velikost vstupu: 125 mm; Průtok: 70 m3/h; Rychlost: 0,9
QMODEL_6fc183b3_b42d_4627_9a1f_c | Půdorys 1.NP | 6782Obj0798478850 | Kus | Objekt | 0 | QMODEL_6fc183b3_b42d_4627_9a1f_c | VV.03.30013 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.16; Šířka: 0.595 m; Výška: 0.261 m; Průměr: -; Jmenovitá velikost vstupu: 160 mm; Průtok: 140 m3/h; Rychlost: 2,1
QMODEL_6fc183b3_b42d_4627_9a1f_c | Půdorys 1.NP | 6782Obj0798479828 | Kus | Objekt | 0 | QMODEL_6fc183b3_b42d_4627_9a1f_c | VV.03.30014 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.16; Šířka: 0.595 m; Výška: 0.261 m; Průměr: -; Jmenovitá velikost vstupu: 160 mm; Průtok: 140 m3/h; Rychlost: 2,1
QMODEL_6fc183b3_b42d_4627_9a1f_c | Půdorys 1.NP | 6782Obj0798479853 | Kus | Objekt | 0 | QMODEL_6fc183b3_b42d_4627_9a1f_c | VV.03.30015 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.18; Šířka: 0.595 m; Výška: 0.261 m; Průměr: -; Jmenovitá velikost vstupu: 160 mm; Průtok: 200 m3/h; Rychlost: 3,1
QMODEL_6fc183b3_b42d_4627_9a1f_c | Půdorys 1.NP | 6782Obj0798479818 | Kus | Objekt | 0 | QMODEL_6fc183b3_b42d_4627_9a1f_c | VV.03.30016 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.18; Šířka: 0.595 m; Výška: 0.261 m; Průměr: -; Jmenovitá velikost vstupu: 160 mm; Průtok: 200 m3/h; Rychlost: 3,1
QMODEL_8f547253_65b4_4e98_96f4_2 | Půdorys 1.NP | 6782Obj0798479826 | Kus | Objekt | 0 | QMODEL_8f547253_65b4_4e98_96f4_2 | VV.03.30017 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.19; Šířka: 0.595 m; Výška: 0.226 m; Průměr: -; Jmenovitá velikost vstupu: 125 mm; Průtok: 100 m3/h; Rychlost: 1,3
QMODEL_8f547253_65b4_4e98_96f4_2 | Půdorys 1.NP | 6782Obj0798479810 | Kus | Objekt | 0 | QMODEL_8f547253_65b4_4e98_96f4_2 | VV.03.30018 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.19; Šířka: 0.595 m; Výška: 0.226 m; Průměr: -; Jmenovitá velikost vstupu: 125 mm; Průtok: 100 m3/h; Rychlost: 1,3
QMODEL_6fc183b3_b42d_4627_9a1f_c | Půdorys 1.NP | 6782Obj0798484553 | Kus | Objekt | 0 | QMODEL_6fc183b3_b42d_4627_9a1f_c | VV.03.30019 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.09; Šířka: 0.595 m; Výška: 0.261 m; Průměr: -; Jmenovitá velikost vstupu: 160 mm; Průtok: 130 m3/h; Rychlost: 2,0
QMODEL_6fc183b3_b42d_4627_9a1f_c | Půdorys 1.NP | 6782Obj0798484917 | Kus | Objekt | 0 | QMODEL_6fc183b3_b42d_4627_9a1f_c | VV.03.30020 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.09; Šířka: 0.595 m; Výška: 0.261 m; Průměr: -; Jmenovitá velikost vstupu: 160 mm; Průtok: 140 m3/h; Rychlost: 2,1
QMODEL_6fc183b3_b42d_4627_9a1f_c | Půdorys 1.NP | 6782Obj0798484551 | Kus | Objekt | 0 | QMODEL_6fc183b3_b42d_4627_9a1f_c | VV.03.30021 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.09; Šířka: 0.595 m; Výška: 0.261 m; Průměr: -; Jmenovitá velikost vstupu: 160 mm; Průtok: 130 m3/h; Rychlost: 2,0
QMODEL_6fc183b3_b42d_4627_9a1f_c | Půdorys 1.NP | 6782Obj0798487372 | Kus | Objekt | 0 | QMODEL_6fc183b3_b42d_4627_9a1f_c | VV.03.30022 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.09; Šířka: 0.595 m; Výška: 0.261 m; Průměr: -; Jmenovitá velikost vstupu: 160 mm; Průtok: 175 m3/h; Rychlost: 2,4
QMODEL_6fc183b3_b42d_4627_9a1f_c | Půdorys 1.NP | 6782Obj0798487438 | Kus | Objekt | 0 | QMODEL_6fc183b3_b42d_4627_9a1f_c | VV.03.30023 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.09; Šířka: 0.595 m; Výška: 0.261 m; Průměr: -; Jmenovitá velikost vstupu: 160 mm; Průtok: 175 m3/h; Rychlost: 2,4
QMODEL_8f547253_65b4_4e98_96f4_2 | Půdorys 1.NP | 6782Obj0798487934 | Kus | Objekt | 0 | QMODEL_8f547253_65b4_4e98_96f4_2 | VV.03.30024 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.03; Šířka: 0.595 m; Výška: 0.226 m; Průměr: -; Jmenovitá velikost vstupu: 125 mm; Průtok: 100 m3/h; Rychlost: 1,3
QMODEL_8f547253_65b4_4e98_96f4_2 | Půdorys 1.NP | 6782Obj0798479196 | Kus | Objekt | 0 | QMODEL_8f547253_65b4_4e98_96f4_2 | VV.03.30025 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.02; Šířka: 0.595 m; Výška: 0.226 m; Průměr: -; Jmenovitá velikost vstupu: 125 mm; Průtok: 100 m3/h; Rychlost: 1,3
QMODEL_8f547253_65b4_4e98_96f4_2 | Půdorys 1.NP | 6782Obj0798478854 | Kus | Objekt | 0 | QMODEL_8f547253_65b4_4e98_96f4_2 | VV.03.30026 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.02; Šířka: 0.595 m; Výška: 0.226 m; Průměr: -; Jmenovitá velikost vstupu: 125 mm; Průtok: 100 m3/h; Rychlost: 1,3
QMODEL_0a0fe211_1ade_4ead_b519_9 | Půdorys 1.NP | 6782Obj0798479190 | Kus | Objekt | 0 | QMODEL_0a0fe211_1ade_4ead_b519_9 | VV.03.30027 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.01b; Šířka: 0.595 m; Výška: 0.301 m; Průměr: -; Jmenovitá velikost vstupu: 200 mm; Průtok: 250 m3/h; Rychlost: 2,9
QMODEL_0a0fe211_1ade_4ead_b519_9 | Půdorys 1.NP | 6782Obj0798479192 | Kus | Objekt | 0 | QMODEL_0a0fe211_1ade_4ead_b519_9 | VV.03.30028 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.01b; Šířka: 0.595 m; Výška: 0.301 m; Průměr: -; Jmenovitá velikost vstupu: 200 mm; Průtok: 250 m3/h; Rychlost: 2,9
QMODEL_0a0fe211_1ade_4ead_b519_9 | Půdorys 1.NP | 6782Obj0798479194 | Kus | Objekt | 0 | QMODEL_0a0fe211_1ade_4ead_b519_9 | VV.03.30029 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.01b; Šířka: 0.595 m; Výška: 0.301 m; Průměr: -; Jmenovitá velikost vstupu: 200 mm; Průtok: 250 m3/h; Rychlost: 2,9
QMODEL_8f547253_65b4_4e98_96f4_2 | Půdorys 1.NP | 6782Obj0798479257 | Kus | Objekt | 0 | QMODEL_8f547253_65b4_4e98_96f4_2 | VV.03.30030 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.01a; Šířka: 0.595 m; Výška: 0.261 m; Průměr: -; Jmenovitá velikost vstupu: 160 mm; Průtok: 160 m3/h; Rychlost: 2,2
QMODEL_0a0fe211_1ade_4ead_b519_9 | Půdorys 1.NP | 6782Obj0798488002 | Kus | Objekt | 0 | QMODEL_0a0fe211_1ade_4ead_b519_9 | VV.03.30031 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.01; Šířka: 0.595 m; Výška: 0.301 m; Průměr: -; Jmenovitá velikost vstupu: 200 mm; Průtok: 275 m3/h; Rychlost: 2,4
QMODEL_0a0fe211_1ade_4ead_b519_9 | Půdorys 1.NP | 6782Obj0798479357 | Kus | Objekt | 0 | QMODEL_0a0fe211_1ade_4ead_b519_9 | VV.03.30032 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.01; Šířka: 0.595 m; Výška: 0.301 m; Průměr: -; Jmenovitá velikost vstupu: 200 mm; Průtok: 275 m3/h; Rychlost: 2,4
QMODEL_8f547253_65b4_4e98_96f4_2 | Půdorys 1.NP | 6782Obj0798478876 | Kus | Objekt | 0 | QMODEL_8f547253_65b4_4e98_96f4_2 | VV.03.30034 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.04; Šířka: 0.595 m; Výška: 0.226 m; Průměr: -; Jmenovitá velikost vstupu: 125 mm; Průtok: 100 m3/h; Rychlost: 1,3
QMODEL_8f547253_65b4_4e98_96f4_2 | Půdorys 1.NP | 6782Obj0798479593 | Kus | Objekt | 0 | QMODEL_8f547253_65b4_4e98_96f4_2 | VV.03.30035 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.05; Šířka: 0.595 m; Výška: 0.226 m; Průměr: -; Jmenovitá velikost vstupu: 125 mm; Průtok: 100 m3/h; Rychlost: 1,3
QMODEL_8f547253_65b4_4e98_96f4_2 | Půdorys 1.NP | 6782Obj0798479720 | Kus | Objekt | 0 | QMODEL_8f547253_65b4_4e98_96f4_2 | VV.03.30036 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.05; Šířka: 0.595 m; Výška: 0.226 m; Průměr: -; Jmenovitá velikost vstupu: 125 mm; Průtok: 100 m3/h; Rychlost: 1,3
QMODEL_6fc183b3_b42d_4627_9a1f_c | Půdorys 1.NP | 6782Obj0798487892 | Kus | Objekt | 0 | QMODEL_6fc183b3_b42d_4627_9a1f_c | VV.03.30037 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.06; Šířka: 0.595 m; Výška: 0.261 m; Průměr: -; Jmenovitá velikost vstupu: 160 mm; Průtok: 250 m3/h; Rychlost: 3,8
QMODEL_6fc183b3_b42d_4627_9a1f_c | Půdorys 1.NP | 6782Obj0798487863 | Kus | Objekt | 0 | QMODEL_6fc183b3_b42d_4627_9a1f_c | VV.03.30038 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.06; Šířka: 0.595 m; Výška: 0.261 m; Průměr: -; Jmenovitá velikost vstupu: 160 mm; Průtok: 250 m3/h; Rychlost: 3,8
QMODEL_6fc183b3_b42d_4627_9a1f_c | Půdorys 1.NP | 6782Obj0798479632 | Kus | Objekt | 0 | QMODEL_6fc183b3_b42d_4627_9a1f_c | VV.03.30042 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.30; Šířka: 0.595 m; Výška: 0.261 m; Průměr: -; Jmenovitá velikost vstupu: 160 mm; Průtok: 250 m3/h; Rychlost: 3,8
QMODEL_6fc183b3_b42d_4627_9a1f_c | Půdorys 1.NP | 6782Obj0798479547 | Kus | Objekt | 0 | QMODEL_6fc183b3_b42d_4627_9a1f_c | VV.03.30043 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.29; Šířka: 0.595 m; Výška: 0.261 m; Průměr: -; Jmenovitá velikost vstupu: 160 mm; Průtok: 150 m3/h; Rychlost: 2,1
QMODEL_0a0fe211_1ade_4ead_b519_9 | Půdorys 1.NP | 6782Obj0798478880 | Kus | Objekt | 0 | QMODEL_0a0fe211_1ade_4ead_b519_9 | VV.03.30044 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.27; Šířka: 0.595 m; Výška: 0.301 m; Průměr: -; Jmenovitá velikost vstupu: 200 mm; Průtok: 300 m3/h; Rychlost: 3,5
QMODEL_0a0fe211_1ade_4ead_b519_9 | Půdorys 1.NP | 6782Obj0798478878 | Kus | Objekt | 0 | QMODEL_0a0fe211_1ade_4ead_b519_9 | VV.03.30045 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.27; Šířka: 0.595 m; Výška: 0.301 m; Průměr: -; Jmenovitá velikost vstupu: 200 mm; Průtok: 300 m3/h; Rychlost: 3,5
QMODEL_0a0fe211_1ade_4ead_b519_9 | Půdorys 1.NP | 6782Obj0798478858 | Kus | Objekt | 0 | QMODEL_0a0fe211_1ade_4ead_b519_9 | VV.03.30046 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.27; Šířka: 0.595 m; Výška: 0.301 m; Průměr: -; Jmenovitá velikost vstupu: 200 mm; Průtok: 370 m3/h; Rychlost: 3,6
QMODEL_8f547253_65b4_4e98_96f4_2 | Půdorys 1.NP | 6782Obj0798478856 | Kus | Objekt | 0 | QMODEL_8f547253_65b4_4e98_96f4_2 | VV.03.30050 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.20; Šířka: 0.595 m; Výška: 0.226 m; Průměr: -; Jmenovitá velikost vstupu: 125 mm; Průtok: 100 m3/h; Rychlost: 1,3
QMODEL_0a0fe211_1ade_4ead_b519_9 | Půdorys 1.NP | 6782Obj0798479606 | Kus | Objekt | 0 | QMODEL_0a0fe211_1ade_4ead_b519_9 | VV.03.30051 | Nadzemní podlaží 1.NP | 0.595 | A1 | NEMSOK - Číslo místnosti: 1.20; Šířka: 0.595 m; Výška: 0.301 m; Průměr: -; Jmenovitá velikost vstupu: 200 mm; Průtok: 310 m3/h; Rychlost: 3,6
QMODEL_6fc183b3_b42d_4627_9a1f_c | Půdorys 1.NP | 6782Obj0798479623 | Kus | Objekt | 0 | QMODEL_6fc183b3_b42d_4627_9a1f_c | VV.03.30054 | Nadzemní podlaží 1.NP |  | A1 | NEMSOK - Číslo místnosti: 1.23; Průměr: 100 mm; Jmenovitá velikost vstupu: 100 mm; Průtok: 50 m3/h; Rychlost: 1,8
Regulátor konstantního průtoku | Půdorys 1.NP | 6782Obj0798484164 | Stk | Konstrukce v aktuální hladině | 0 | Regulátor konstantního průtoku | KA.03.30001 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.10; Jmenovitá velikost vstupu: DN160; Průtok: 140 m3/h; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|160.00|160.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN160; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/10; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN160; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
Regulátor konstantního průtoku | Půdorys 1.NP | 6782Obj0798484101 | Stk | Konstrukce v aktuální hladině | 0 | Regulátor konstantního průtoku | KA.03.30002 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.10; Jmenovitá velikost vstupu: DN160; Průtok: 140 m3/h; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|160.00|160.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN160; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/10; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN160; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
Regulátor konstantního průtoku | Půdorys 1.NP | 6782Obj0798484111 | Stk | Konstrukce v aktuální hladině | 0 | Regulátor konstantního průtoku | KA.03.30003 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.11; Jmenovitá velikost vstupu: DN125; Průtok: 70 m3/h; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/10; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
ABL Regler RN | Půdorys 1.NP | 6782Obj0798484091 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.03.30004 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.11; Jmenovitá velikost vstupu: DN125; Průtok: 70 m3/h; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/10; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
Regulátor konstantního průtoku | Půdorys 1.NP | 6782Obj0798484121 | Stk | Konstrukce v aktuální hladině | 0 | Regulátor konstantního průtoku | KA.03.30005 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.12; Jmenovitá velikost vstupu: DN125; Průtok: 70 m3/h; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/10; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
Regulátor konstantního průtoku | Půdorys 1.NP | 6782Obj0798484078 | Stk | Konstrukce v aktuální hladině | 0 | Regulátor konstantního průtoku | KA.03.30006 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.12; Jmenovitá velikost vstupu: DN125; Průtok: 70 m3/h; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/10; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
Regulátor konstantního průtoku | Půdorys 1.NP | 6782Obj0798484131 | Stk | Konstrukce v aktuální hladině | 0 | Regulátor konstantního průtoku | KA.03.30007 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.13; Jmenovitá velikost vstupu: DN125; Průtok: 70 m3/h; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/10; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
ABL Regler RN | Půdorys 1.NP | 6782Obj0798484068 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.03.30008 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.13; Jmenovitá velikost vstupu: DN125; Průtok: 70 m3/h; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/10; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
Regulátor konstantního průtoku | Půdorys 1.NP | 6782Obj0798484141 | Stk | Konstrukce v aktuální hladině | 0 | Regulátor konstantního průtoku | KA.03.30009 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.14; Jmenovitá velikost vstupu: DN125; Průtok: 70 m3/h; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/10; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
Regulátor konstantního průtoku | Půdorys 1.NP | 6782Obj0798484058 | Stk | Konstrukce v aktuální hladině | 0 | Regulátor konstantního průtoku | KA.03.30010 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.14; Jmenovitá velikost vstupu: DN125; Průtok: 70 m3/h; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/10; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
Regulátor konstantního průtoku | Půdorys 1.NP | 6782Obj0798484151 | Stk | Konstrukce v aktuální hladině | 0 | Regulátor konstantního průtoku | KA.03.30011 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.15; Jmenovitá velikost vstupu: DN125; Průtok: 70 m3/h; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/10; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
Regulátor konstantního průtoku | Půdorys 1.NP | 6782Obj0798484048 | Stk | Konstrukce v aktuální hladině | 0 | Regulátor konstantního průtoku | KA.03.30012 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.15; Jmenovitá velikost vstupu: DN125; Průtok: 70 m3/h; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/10; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
Regulátor konstantního průtoku | Půdorys 1.NP | 6782Obj0798490882 | Stk | Konstrukce v aktuální hladině | 0 | Regulátor konstantního průtoku | KA.03.30013 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.16; Jmenovitá velikost vstupu: DN160; Průtok: 140 m3/h; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|160.00|160.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN160; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/17; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN160; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
Regulátor konstantního průtoku | Půdorys 1.NP | 6782Obj0798484038 | Stk | Konstrukce v aktuální hladině | 0 | Regulátor konstantního průtoku | KA.03.30014 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.16; Jmenovitá velikost vstupu: DN160; Průtok: 140 m3/h; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|160.00|160.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN160; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/10; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN160; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
Regulátor konstantního průtoku | Půdorys 1.NP | 6782Obj0798490349 | Stk | Konstrukce v aktuální hladině | 0 | Regulátor konstantního průtoku | KA.03.30015 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.18; Jmenovitá velikost vstupu: DN160; Průtok: 200 m3/h; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|160.00|160.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN160; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/16; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN160; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
Regulátor konstantního průtoku | Půdorys 1.NP | 6782Obj0798483970 | Stk | Konstrukce v aktuální hladině | 0 | Regulátor konstantního průtoku | KA.03.30016 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.18; Jmenovitá velikost vstupu: DN160; Průtok: 200 m3/h; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|160.00|160.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN160; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/10; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN160; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
Regulátor konstantního průtoku | Půdorys 1.NP | 6782Obj0798483859 | Stk | Konstrukce v aktuální hladině | 0 | Regulátor konstantního průtoku | KA.03.30017 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.19; Jmenovitá velikost vstupu: DN125; Průtok: 100 m3/h; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/09; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
Regulátor konstantního průtoku | Půdorys 1.NP | 6782Obj0798483869 | Stk | Konstrukce v aktuální hladině | 0 | Regulátor konstantního průtoku | KA.03.30018 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.19; Jmenovitá velikost vstupu: DN125; Průtok: 100 m3/h; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|-1|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/10; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
Regulátor konstantního průtoku | Půdorys 1.NP | 6782Obj0798485661 | Stk | Konstrukce v aktuální hladině | 0 | Regulátor konstantního průtoku | KA.03.30019 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.08; Jmenovitá velikost vstupu: DN200; Průtok: 400 m3/h; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|200.00|200.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN200; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/10; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN200; Provozní tlak: -; Tlaková třída: -; Typ ovladání: manuální
ABL Regler RN | Půdorys 1.NP | 6782Obj0798487479 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.03.30020 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.08; Jmenovitá velikost vstupu: DN160; Průtok: 175 m3/h; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|160.00|160.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN160; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/12; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN160; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
ABL Regler RN | Půdorys 1.NP | 6782Obj0798487403 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.03.30021 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.08; Jmenovitá velikost vstupu: DN160; Průtok: 175 m3/h; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|160.00|160.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN160; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/12; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN160; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
ZG Klappe | Půdorys 1.NP | 6782Obj0798487342 | Stk | Konstrukce v aktuální hladině | 0 | ZG Klappe | KA.03.30022 | Nadzení podlaží 1.NP | 0.35 | - | NEMSOK - Číslo místnosti: 1.03; Jmenovitá velikost vstupu: DN200; Průtok: 350 m3/h; K_GEWERK: 1; K_BLOCKNAME: ZG Klappe; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|200.00|200.00|350.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_DWGNAME: ${PROD}l\zentralgeräte\zg klappen\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 350; L_BES_DIM: DN200; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/12; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN200; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
ABL Regler RN | Půdorys 1.NP | 6782Obj0798487945 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.03.30026 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.03; Jmenovitá velikost vstupu: DN125; Průtok: 100 m3/h; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/12; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
ABL Regler RN | Půdorys 1.NP | 6782Obj0798490723 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.03.30029 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.02; Jmenovitá velikost vstupu: DN125; Průtok: 100 m3/h; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/17; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
ABL Regler RN | Půdorys 1.NP | 6782Obj0798484307 | Stk | Konstrukce v aktuální hladině | 0 | ABL Regler RN | KA.03.30030 | Nadzení podlaží 1.NP | 0.31 | - | NEMSOK - Číslo místnosti: 1.02; Jmenovitá velikost vstupu: DN125; Průtok: 100 m3/h; K_GEWERK: 1; K_BLOCKNAME: ABL Regler RN; K_TYP: 30; K_FORMEL: 1015; K_APUNKT: 2|-0.5000|0|0|180.0|0|0|1.0000|1.0000|1.0000|2|0.5000|0|0|0|0|0|1.0000|1.0000|1.0000|2|; K_DIMENSION: 1015|0|2|0|0|0|0|1000|0|-1|356|-1|0|0|0|0|0|0|0|0|125.00|125.00|310.00|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|0|; K_POSITION: L.2; K_DWGNAME: ${PROD}l\einbauteile rund\volumenstromregler konstant\; K_MATERIAL: SPIRO POTRUBÍ|0.00; K_PROFIL: ||||; K_ISOLATION: Mineralwolle|40.00; L_BES_LAENGE: 310; L_BES_DIM: DN125; L_BES_DIM_A2: 1; L_BES_DIM_B2: 1; L_BES_DIM_A: 1; K_DP_EBT: 0.00; K_VOLSTROM: 0.000; K_DATE: 2023/01/10; K_MLH_GOST: 0; K_MLD_GOST: 0; K_LISTVALUE: 1.0; N_FREI_68: SPIRO POTRUBÍ; Jmenovitá velikost výstupu: DN125; Provozní tlak: -; Tlaková třída: -; Typ ovladání: servopohon
